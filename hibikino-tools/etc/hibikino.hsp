*
**.LIB mos_tt
* DATE: Mar  4/10
* LOT: 1                     WAF: 1
* DIE: 1                     DEV: nW120L360
* Temp= 27
.MODEL TN nmos (                                 LEVEL   = 49
+VERSION = 3.3            TNOM    = 27             TOX     = 2.5E-8
+XJ      = 1.5E-7         NCH     = 1.7E17         VTH0    = 0.5170719
+K1      = 0.651491       K2      = 0              K3      = 29.04952
+K3B     = 0.1534115      W0      = 1.187536E-6    NLX     = 5.847095E-8
+DVT0W   = 0              DVT1W   = 0              DVT2W   = -0.032
+DVT0    = 0.7513662      DVT1    = 0.0394835      DVT2    = -0.0491886
+U0      = 0.0475844      UA      = 9.703369E-10   UB      = 1E-21
+UC      = -2.72549E-11   VSAT    = 1.26498E5      A0      = 0.56427
+AGS     = 0              B0      = 1.401621E-6    B1      = 1E-7
+KETA    = -5.06235E-3    A1      = 0              A2      = 1
+RDSW    = 2.330784E3     PRWG    = 6.334957E-4    PRWB    = -1E-3
+WR      = 1              WINT    = 2.563443E-7    LINT    = 2.689635E-8
+XL      = 0              XW      = 0              DWG     = -6.56397E-8
+DWB     = -5.57927E-8    VOFF    = -0.0819032     NFACTOR = 0.4459316
+CIT     = 0              CDSC    = 1.002311E-4    CDSCD   = 0
+CDSCB   = 0              ETA0    = 0              ETAB    = 0
+DSUB    = 0.0889854      PCLM    = 2.305038       PDIBLC1 = 0
+PDIBLC2 = 1E-5           PDIBLCB = 0              DROUT   = 0.2827366
+PSCBE1  = 7.542472E9     PSCBE2  = 2.09158E-5     PVAG    = 0
+DELTA   = 0.01           MOBMOD  = 1              PRT     = 0
+UTE     = -1.5           KT1     = 0              KT1L    = 0
+KT2     = 0              UA1     = 4.31E-9        UB1     = -7.61E-18
+UC1     = -5.6E-11       AT      = 3.3E4          NQSMOD  = 0
+WL      = 0              WLN     = 1              WW      = 0
+WWN     = 1              WWL     = 0              LL      = 0
+LLN     = 1              LW      = 0              LWN     = 1
+LWL     = 0              CAPMOD  = 2              CGDO    = 3E-10
+CGSO    = 3E-10          CGBO    = 1E-11          CJ      = 4.15E-4
+PB      = 0.9            MJ      = 0.5            CJSW    = 2.65E-10
+PBSW    = 0.75           MJSW    = 0.45           NOFF    = 1
+ACDE    = 1              MOIN    = 15             TPB     = 0
+TPBSW   = 0              TPBSWG  = 0              TCJ     = 0
+TCJSW   = 0              TCJSWG  = 0               )

*

.MODEL TP pmos (                                 LEVEL   = 49
+VERSION = 3.3            TNOM    = 27             TOX     = 2.5E-8
+XJ      = 1.5E-7         NCH     = 1.7E17         VTH0    = -0.501412
+K1      = 1.0807627      K2      = 0.05           K3      = 17.42443
+K3B     = 0              W0      = 1.043589E-6    NLX     = 1.505718E-7
+DVT0W   = 0              DVT1W   = 0              DVT2W   = -0.032
+DVT0    = 0.3535365      DVT1    = 0.0571199      DVT2    = -0.187256
+U0      = 0.014562       UA      = 2.47573E-9     UB      = -2.15683E-18
+UC      = -1E-10         VSAT    = 1.49747E5      A0      = 0.764
+AGS     = 0              B0      = 0              B1      = 0
+KETA    = 4.40953E-3     A1      = 0              A2      = 1
+RDSW    = 0              PRWG    = 0              PRWB    = 0
+WR      = 1              WINT    = 1.519959E-7    LINT    = 1.010582E-7
+XL      = 0              XW      = 0              DWG     = 0
+DWB     = 0              VOFF    = -0.15          NFACTOR = 1.813005
+CIT     = 0              CDSC    = 8.05041E-5     CDSCD   = 0
+CDSCB   = 0              ETA0    = 0.73           ETAB    = 0
+DSUB    = 0.25           PCLM    = 9.7446536      PDIBLC1 = 0.1993367
+PDIBLC2 = 1.002337E-5    PDIBLCB = 0              DROUT   = 0.0249431
+PSCBE1  = 7.96786E8      PSCBE2  = 5E-5           PVAG    = 9.97008E-3
+DELTA   = 0.0100477      MOBMOD  = 1              PRT     = 0
+UTE     = -1.5           KT1     = 0              KT1L    = 0
+KT2     = 0              UA1     = 4.31E-9        UB1     = -7.61E-18
+UC1     = -5.6E-11       AT      = 3.3E4          NQSMOD  = 0
+WL      = 0              WLN     = 1              WW      = 0
+WWN     = 1              WWL     = 0              LL      = 0
+LLN     = 1              LW      = 0              LWN     = 1
+LWL     = 0              CAPMOD  = 2              CGDO    = 3E-10
+CGSO    = 3E-10          CGBO    = 1E-11          CJ      = 6.52E-4
+PB      = 0.9            MJ      = 0.45           CJSW    = 3.18E-10
+PBSW    = 0.6            MJSW    = 0.5            TCJ     = 0
+TPB     = 0              TCJSW   = 0              TPBSW   = 0
+NOFF    = 1              ACDE    = 1              MOIN    = 15
+TPBSWG  = 0              TCJSWG  = 0               )

*
**.ENDL mos_tt
