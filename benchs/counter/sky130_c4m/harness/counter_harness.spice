* SPICE netlist generated by Yosys 0.19+20 (git sha1 12f41f005, gcc 9.4.0-1ubuntu1~20.04.1 -fPIC -Os)

.SUBCKT counter_harness io_in_0_ io_in_1_ io_in_2_ io_in_3_ io_in_4_ io_in_5_ io_in_6_ io_in_7_ io_in_8_ io_in_9_ io_in_10_ io_in_11_ io_in_12_ io_in_13_ io_in_14_ io_in_15_ io_in_16_ io_in_17_ io_in_18_ io_in_19_ io_in_20_ io_in_21_ io_in_22_ io_in_23_ io_in_24_ io_in_25_ io_in_26_ io_in_27_ io_in_28_ io_in_29_ io_in_30_ io_in_31_ io_in_32_ io_in_33_ io_in_34_ io_in_35_ io_in_36_ io_in_37_ io_out_0_ io_out_1_ io_out_2_ io_out_3_ io_out_4_ io_out_5_ io_out_6_ io_out_7_ io_out_8_ io_out_9_ io_out_10_ io_out_11_ io_out_12_ io_out_13_ io_out_14_ io_out_15_ io_out_16_ io_out_17_ io_out_18_ io_out_19_ io_out_20_ io_out_21_ io_out_22_ io_out_23_ io_out_24_ io_out_25_ io_out_26_ io_out_27_ io_out_28_ io_out_29_ io_out_30_ io_out_31_ io_out_32_ io_out_33_ io_out_34_ io_out_35_ io_out_36_ io_out_37_ io_oeb_0_ io_oeb_1_ io_oeb_2_ io_oeb_3_ io_oeb_4_ io_oeb_5_ io_oeb_6_ io_oeb_7_ io_oeb_8_ io_oeb_9_ io_oeb_10_ io_oeb_11_ io_oeb_12_ io_oeb_13_ io_oeb_14_ io_oeb_15_ io_oeb_16_ io_oeb_17_ io_oeb_18_ io_oeb_19_ io_oeb_20_ io_oeb_21_ io_oeb_22_ io_oeb_23_ io_oeb_24_ io_oeb_25_ io_oeb_26_ io_oeb_27_ io_oeb_28_ io_oeb_29_ io_oeb_30_ io_oeb_31_ io_oeb_32_ io_oeb_33_ io_oeb_34_ io_oeb_35_ io_oeb_36_ io_oeb_37_
X0 counter.ctr_10_ 1 io_in_30_ sff1_x4
X1 counter.ctr_9_ 2 io_in_30_ sff1_x4
X2 counter.ctr_8_ 3 io_in_30_ sff1_x4
X3 counter.ctr_7_ 4 io_in_30_ sff1_x4
X4 counter.ctr_6_ 5 io_in_30_ sff1_x4
X5 counter.ctr_5_ 6 io_in_30_ sff1_x4
X6 counter.ctr_4_ 7 io_in_30_ sff1_x4
X7 counter.ctr_3_ 8 io_in_30_ sff1_x4
X8 counter.ctr_2_ 9 io_in_30_ sff1_x4
X9 counter.ctr_1_ 10 io_in_30_ sff1_x4
X10 counter.ctr_0_ 11 io_in_30_ sff1_x4
X11 counter.ctr_127_ 12 io_in_30_ sff1_x4
X12 counter.ctr_126_ 13 io_in_30_ sff1_x4
X13 counter.ctr_125_ 14 io_in_30_ sff1_x4
X14 counter.ctr_124_ 15 io_in_30_ sff1_x4
X15 counter.ctr_123_ 16 io_in_30_ sff1_x4
X16 counter.ctr_122_ 17 io_in_30_ sff1_x4
X17 counter.ctr_121_ 18 io_in_30_ sff1_x4
X18 counter.ctr_120_ 19 io_in_30_ sff1_x4
X19 counter.ctr_119_ 20 io_in_30_ sff1_x4
X20 counter.ctr_118_ 21 io_in_30_ sff1_x4
X21 counter.ctr_117_ 22 io_in_30_ sff1_x4
X22 counter.ctr_116_ 23 io_in_30_ sff1_x4
X23 counter.ctr_115_ 24 io_in_30_ sff1_x4
X24 counter.ctr_114_ 25 io_in_30_ sff1_x4
X25 counter.ctr_113_ 26 io_in_30_ sff1_x4
X26 counter.ctr_112_ 27 io_in_30_ sff1_x4
X27 counter.ctr_111_ 28 io_in_30_ sff1_x4
X28 counter.ctr_110_ 29 io_in_30_ sff1_x4
X29 counter.ctr_109_ 30 io_in_30_ sff1_x4
X30 counter.ctr_108_ 31 io_in_30_ sff1_x4
X31 counter.ctr_107_ 32 io_in_30_ sff1_x4
X32 counter.ctr_106_ 33 io_in_30_ sff1_x4
X33 counter.ctr_105_ 34 io_in_30_ sff1_x4
X34 counter.ctr_104_ 35 io_in_30_ sff1_x4
X35 counter.ctr_103_ 36 io_in_30_ sff1_x4
X36 counter.ctr_102_ 37 io_in_30_ sff1_x4
X37 counter.ctr_101_ 38 io_in_30_ sff1_x4
X38 counter.ctr_100_ 39 io_in_30_ sff1_x4
X39 counter.ctr_99_ 40 io_in_30_ sff1_x4
X40 counter.ctr_98_ 41 io_in_30_ sff1_x4
X41 counter.ctr_97_ 42 io_in_30_ sff1_x4
X42 counter.ctr_96_ 43 io_in_30_ sff1_x4
X43 counter.ctr_95_ 44 io_in_30_ sff1_x4
X44 counter.ctr_94_ 45 io_in_30_ sff1_x4
X45 counter.ctr_93_ 46 io_in_30_ sff1_x4
X46 counter.ctr_92_ 47 io_in_30_ sff1_x4
X47 counter.ctr_91_ 48 io_in_30_ sff1_x4
X48 counter.ctr_90_ 49 io_in_30_ sff1_x4
X49 counter.ctr_89_ 50 io_in_30_ sff1_x4
X50 counter.ctr_88_ 51 io_in_30_ sff1_x4
X51 counter.ctr_87_ 52 io_in_30_ sff1_x4
X52 counter.ctr_86_ 53 io_in_30_ sff1_x4
X53 counter.ctr_85_ 54 io_in_30_ sff1_x4
X54 counter.ctr_84_ 55 io_in_30_ sff1_x4
X55 counter.ctr_83_ 56 io_in_30_ sff1_x4
X56 counter.ctr_82_ 57 io_in_30_ sff1_x4
X57 counter.ctr_81_ 58 io_in_30_ sff1_x4
X58 counter.ctr_80_ 59 io_in_30_ sff1_x4
X59 counter.ctr_79_ 60 io_in_30_ sff1_x4
X60 counter.ctr_78_ 61 io_in_30_ sff1_x4
X61 counter.ctr_77_ 62 io_in_30_ sff1_x4
X62 counter.ctr_76_ 63 io_in_30_ sff1_x4
X63 counter.ctr_75_ 64 io_in_30_ sff1_x4
X64 counter.ctr_74_ 65 io_in_30_ sff1_x4
X65 counter.ctr_73_ 66 io_in_30_ sff1_x4
X66 counter.ctr_72_ 67 io_in_30_ sff1_x4
X67 counter.ctr_71_ 68 io_in_30_ sff1_x4
X68 counter.ctr_70_ 69 io_in_30_ sff1_x4
X69 counter.ctr_69_ 70 io_in_30_ sff1_x4
X70 counter.ctr_68_ 71 io_in_30_ sff1_x4
X71 counter.ctr_67_ 72 io_in_30_ sff1_x4
X72 counter.ctr_66_ 73 io_in_30_ sff1_x4
X73 counter.ctr_65_ 74 io_in_30_ sff1_x4
X74 counter.ctr_64_ 75 io_in_30_ sff1_x4
X75 counter.ctr_63_ 76 io_in_30_ sff1_x4
X76 counter.ctr_62_ 77 io_in_30_ sff1_x4
X77 counter.ctr_61_ 78 io_in_30_ sff1_x4
X78 counter.ctr_60_ 79 io_in_30_ sff1_x4
X79 counter.ctr_59_ 80 io_in_30_ sff1_x4
X80 counter.ctr_58_ 81 io_in_30_ sff1_x4
X81 counter.ctr_57_ 82 io_in_30_ sff1_x4
X82 counter.ctr_56_ 83 io_in_30_ sff1_x4
X83 counter.ctr_55_ 84 io_in_30_ sff1_x4
X84 counter.ctr_54_ 85 io_in_30_ sff1_x4
X85 counter.ctr_53_ 86 io_in_30_ sff1_x4
X86 counter.ctr_52_ 87 io_in_30_ sff1_x4
X87 counter.ctr_51_ 88 io_in_30_ sff1_x4
X88 counter.ctr_50_ 89 io_in_30_ sff1_x4
X89 counter.ctr_49_ 90 io_in_30_ sff1_x4
X90 counter.ctr_48_ 91 io_in_30_ sff1_x4
X91 counter.ctr_47_ 92 io_in_30_ sff1_x4
X92 counter.ctr_46_ 93 io_in_30_ sff1_x4
X93 counter.ctr_45_ 94 io_in_30_ sff1_x4
X94 counter.ctr_44_ 95 io_in_30_ sff1_x4
X95 counter.ctr_43_ 96 io_in_30_ sff1_x4
X96 counter.ctr_42_ 97 io_in_30_ sff1_x4
X97 counter.ctr_41_ 98 io_in_30_ sff1_x4
X98 counter.ctr_40_ 99 io_in_30_ sff1_x4
X99 counter.ctr_39_ 100 io_in_30_ sff1_x4
X100 counter.ctr_38_ 101 io_in_30_ sff1_x4
X101 counter.ctr_37_ 102 io_in_30_ sff1_x4
X102 counter.ctr_36_ 103 io_in_30_ sff1_x4
X103 counter.ctr_35_ 104 io_in_30_ sff1_x4
X104 counter.ctr_34_ 105 io_in_30_ sff1_x4
X105 counter.ctr_33_ 106 io_in_30_ sff1_x4
X106 counter.ctr_32_ 107 io_in_30_ sff1_x4
X107 counter.ctr_31_ 108 io_in_30_ sff1_x4
X108 counter.ctr_30_ 109 io_in_30_ sff1_x4
X109 counter.ctr_29_ 110 io_in_30_ sff1_x4
X110 counter.ctr_28_ 111 io_in_30_ sff1_x4
X111 counter.ctr_27_ 112 io_in_30_ sff1_x4
X112 counter.ctr_26_ 113 io_in_30_ sff1_x4
X113 counter.ctr_25_ 114 io_in_30_ sff1_x4
X114 counter.ctr_24_ 115 io_in_30_ sff1_x4
X115 counter.ctr_23_ 116 io_in_30_ sff1_x4
X116 counter.ctr_22_ 117 io_in_30_ sff1_x4
X117 counter.ctr_21_ 118 io_in_30_ sff1_x4
X118 counter.ctr_20_ 119 io_in_30_ sff1_x4
X119 counter.ctr_19_ 120 io_in_30_ sff1_x4
X120 counter.ctr_18_ 121 io_in_30_ sff1_x4
X121 counter.ctr_17_ 122 io_in_30_ sff1_x4
X122 counter.ctr_16_ 123 io_in_30_ sff1_x4
X123 counter.ctr_15_ 124 io_in_30_ sff1_x4
X124 counter.ctr_14_ 125 io_in_30_ sff1_x4
X125 counter.ctr_13_ 126 io_in_30_ sff1_x4
X126 counter.ctr_12_ 127 io_in_30_ sff1_x4
X127 counter.ctr_11_ 128 io_in_30_ sff1_x4
X128 12 129 130 nxr2_x1
X129 13 131 132 nxr2_x1
X130 130 counter.ctr_126_ 132 a2_x2
X131 14 133 134 nxr2_x1
X132 132 counter.ctr_123_ counter.ctr_124_ counter.ctr_125_ 135 a4_x2
X133 15 136 137 nxr2_x1
X134 134 counter.ctr_123_ counter.ctr_124_ 135 a3_x2
X135 16 138 135 nxr2_x1
X136 137 counter.ctr_123_ 135 a2_x2
X137 17 counter.ctr_122_ 139 nxr2_x1
X138 135 counter.ctr_120_ counter.ctr_121_ counter.ctr_122_ 140 a4_x2
X139 18 141 142 nxr2_x1
X140 139 counter.ctr_120_ counter.ctr_121_ 140 nand3_x0
X141 19 143 140 nxr2_x1
X142 142 counter.ctr_120_ 140 a2_x2
X143 20 counter.ctr_119_ 144 nxr2_x1
X144 140 counter.ctr_117_ counter.ctr_118_ counter.ctr_119_ 145 a4_x2
X145 21 146 147 nxr2_x1
X146 144 counter.ctr_117_ counter.ctr_118_ 145 nand3_x0
X147 22 148 145 nxr2_x1
X148 147 counter.ctr_117_ 145 a2_x2
X149 23 counter.ctr_116_ 149 nxr2_x1
X150 145 counter.ctr_114_ counter.ctr_115_ counter.ctr_116_ 150 a4_x2
X151 24 151 152 nxr2_x1
X152 149 counter.ctr_114_ counter.ctr_115_ 150 nand3_x0
X153 25 153 150 nxr2_x1
X154 152 counter.ctr_114_ 150 a2_x2
X155 26 counter.ctr_113_ 154 nxr2_x1
X156 150 counter.ctr_111_ counter.ctr_112_ counter.ctr_113_ 155 a4_x2
X157 27 156 157 nxr2_x1
X158 154 counter.ctr_111_ counter.ctr_112_ 155 nand3_x0
X159 28 158 155 nxr2_x1
X160 157 counter.ctr_111_ 155 a2_x2
X161 29 counter.ctr_110_ 159 nxr2_x1
X162 155 counter.ctr_108_ counter.ctr_109_ counter.ctr_110_ 160 a4_x2
X163 30 161 162 nxr2_x1
X164 159 counter.ctr_108_ counter.ctr_109_ 160 nand3_x0
X165 31 163 160 nxr2_x1
X166 162 counter.ctr_108_ 160 a2_x2
X167 32 counter.ctr_107_ 164 nxr2_x1
X168 160 counter.ctr_105_ counter.ctr_106_ counter.ctr_107_ 165 a4_x2
X169 33 166 167 nxr2_x1
X170 164 counter.ctr_105_ counter.ctr_106_ 165 nand3_x0
X171 34 168 165 nxr2_x1
X172 167 counter.ctr_105_ 165 a2_x2
X173 35 counter.ctr_104_ 169 nxr2_x1
X174 165 counter.ctr_102_ counter.ctr_103_ counter.ctr_104_ 170 a4_x2
X175 36 171 172 nxr2_x1
X176 169 counter.ctr_102_ counter.ctr_103_ 170 nand3_x0
X177 37 173 170 nxr2_x1
X178 172 counter.ctr_102_ 170 a2_x2
X179 38 counter.ctr_101_ 174 nxr2_x1
X180 170 counter.ctr_99_ counter.ctr_100_ counter.ctr_101_ 175 a4_x2
X181 39 176 177 nxr2_x1
X182 174 counter.ctr_99_ counter.ctr_100_ 175 nand3_x0
X183 40 178 175 nxr2_x1
X184 177 counter.ctr_99_ 175 a2_x2
X185 41 counter.ctr_98_ 179 nxr2_x1
X186 175 counter.ctr_96_ counter.ctr_97_ counter.ctr_98_ 180 a4_x2
X187 42 181 182 nxr2_x1
X188 179 counter.ctr_96_ counter.ctr_97_ 180 nand3_x0
X189 43 183 180 nxr2_x1
X190 182 counter.ctr_96_ 180 a2_x2
X191 44 counter.ctr_95_ 184 nxr2_x1
X192 180 counter.ctr_93_ counter.ctr_94_ counter.ctr_95_ 185 a4_x2
X193 45 186 187 nxr2_x1
X194 184 counter.ctr_93_ counter.ctr_94_ 185 nand3_x0
X195 46 188 185 nxr2_x1
X196 187 counter.ctr_93_ 185 a2_x2
X197 47 counter.ctr_92_ 189 nxr2_x1
X198 185 counter.ctr_90_ counter.ctr_91_ counter.ctr_92_ 190 a4_x2
X199 48 191 192 nxr2_x1
X200 189 counter.ctr_90_ counter.ctr_91_ 190 nand3_x0
X201 49 193 190 nxr2_x1
X202 192 counter.ctr_90_ 190 a2_x2
X203 50 counter.ctr_89_ 194 nxr2_x1
X204 190 counter.ctr_87_ counter.ctr_88_ counter.ctr_89_ 195 a4_x2
X205 51 196 197 nxr2_x1
X206 194 counter.ctr_87_ counter.ctr_88_ 195 nand3_x0
X207 52 198 195 nxr2_x1
X208 197 counter.ctr_87_ 195 a2_x2
X209 53 199 200 a2_x2
X210 200 counter.ctr_86_ 201 o2_x2
X211 199 counter.ctr_83_ counter.ctr_84_ 202 203 nand4_x0
X212 195 counter.ctr_83_ counter.ctr_84_ 202 203 a4_x2
X213 203 counter.ctr_85_ counter.ctr_86_ a2_x2
X214 54 counter.ctr_85_ 204 nxr2_x1
X215 201 counter.ctr_83_ counter.ctr_84_ counter.ctr_85_ 202 a4_x2
X216 55 205 206 nxr2_x1
X217 204 counter.ctr_83_ counter.ctr_84_ 202 nand3_x0
X218 56 207 202 nxr2_x1
X219 206 counter.ctr_83_ 202 a2_x2
X220 57 208 209 a2_x2
X221 209 counter.ctr_82_ 210 o2_x2
X222 208 counter.ctr_79_ counter.ctr_80_ 211 212 nand4_x0
X223 202 counter.ctr_79_ counter.ctr_80_ 211 212 a4_x2
X224 212 counter.ctr_81_ counter.ctr_82_ a2_x2
X225 58 counter.ctr_81_ 213 nxr2_x1
X226 210 counter.ctr_79_ counter.ctr_80_ counter.ctr_81_ 211 a4_x2
X227 59 214 215 nxr2_x1
X228 213 counter.ctr_79_ counter.ctr_80_ 211 nand3_x0
X229 60 216 211 nxr2_x1
X230 215 counter.ctr_79_ 211 a2_x2
X231 61 counter.ctr_78_ 217 nxr2_x1
X232 211 counter.ctr_76_ counter.ctr_77_ counter.ctr_78_ 218 a4_x2
X233 62 219 220 nxr2_x1
X234 217 counter.ctr_76_ counter.ctr_77_ 218 nand3_x0
X235 63 221 218 nxr2_x1
X236 220 counter.ctr_76_ 218 a2_x2
X237 64 counter.ctr_75_ 222 nxr2_x1
X238 218 counter.ctr_73_ counter.ctr_74_ counter.ctr_75_ 223 a4_x2
X239 65 224 225 nxr2_x1
X240 222 counter.ctr_73_ counter.ctr_74_ 223 nand3_x0
X241 66 226 223 nxr2_x1
X242 225 counter.ctr_73_ 223 a2_x2
X243 67 227 228 nxr2_x1
X244 223 counter.ctr_71_ counter.ctr_72_ 229 230 a4_x2
X245 68 231 232 nxr2_x1
X246 228 counter.ctr_71_ 229 230 a3_x2
X247 69 233 234 counter.ctr_70_ ao22_x2
X248 233 229 230 nand2_x0
X249 232 229 230 a2_x2
X250 230 counter.ctr_69_ counter.ctr_70_ a2_x2
X251 70 235 229 nxr2_x1
X252 234 counter.ctr_69_ 229 a2_x2
X253 71 236 237 nxr2_x1
X254 229 counter.ctr_67_ counter.ctr_68_ 238 239 a4_x2
X255 72 240 241 nxr2_x1
X256 237 counter.ctr_67_ 238 239 a3_x2
X257 73 242 243 counter.ctr_66_ ao22_x2
X258 242 238 239 nand2_x0
X259 241 238 239 a2_x2
X260 239 counter.ctr_65_ counter.ctr_66_ a2_x2
X261 74 244 238 nxr2_x1
X262 243 counter.ctr_65_ 238 a2_x2
X263 75 counter.ctr_64_ 245 nxr2_x1
X264 238 counter.ctr_62_ counter.ctr_63_ counter.ctr_64_ 246 a4_x2
X265 76 247 248 nxr2_x1
X266 245 counter.ctr_62_ counter.ctr_63_ 246 nand3_x0
X267 77 249 246 nxr2_x1
X268 248 counter.ctr_62_ 246 a2_x2
X269 78 counter.ctr_61_ 250 nxr2_x1
X270 246 counter.ctr_59_ counter.ctr_60_ counter.ctr_61_ 251 a4_x2
X271 79 252 253 nxr2_x1
X272 250 counter.ctr_59_ counter.ctr_60_ 251 nand3_x0
X273 80 254 251 nxr2_x1
X274 253 counter.ctr_59_ 251 a2_x2
X275 81 counter.ctr_58_ 255 nxr2_x1
X276 251 counter.ctr_56_ counter.ctr_57_ counter.ctr_58_ 256 a4_x2
X277 82 257 258 nxr2_x1
X278 255 counter.ctr_56_ counter.ctr_57_ 256 nand3_x0
X279 83 259 256 nxr2_x1
X280 258 counter.ctr_56_ 256 a2_x2
X281 84 260 261 nxr2_x1
X282 256 counter.ctr_52_ counter.ctr_55_ 262 263 a4_x2
X283 85 264 265 a2_x2
X284 265 counter.ctr_54_ 266 o2_x2
X285 264 counter.ctr_52_ 262 263 nand3_x0
X286 261 counter.ctr_52_ 262 263 a3_x2
X287 263 counter.ctr_53_ counter.ctr_54_ a2_x2
X288 86 267 268 nxr2_x1
X289 266 counter.ctr_52_ counter.ctr_53_ 262 a3_x2
X290 87 269 262 nxr2_x1
X291 268 counter.ctr_52_ 262 a2_x2
X292 88 270 271 nxr2_x1
X293 262 counter.ctr_48_ counter.ctr_51_ 272 273 a4_x2
X294 89 274 275 a2_x2
X295 275 counter.ctr_50_ 276 o2_x2
X296 274 counter.ctr_48_ 272 273 nand3_x0
X297 271 counter.ctr_48_ 272 273 a3_x2
X298 273 counter.ctr_49_ counter.ctr_50_ a2_x2
X299 90 277 278 nxr2_x1
X300 276 counter.ctr_48_ counter.ctr_49_ 272 a3_x2
X301 91 279 272 nxr2_x1
X302 278 counter.ctr_48_ 272 a2_x2
X303 92 counter.ctr_47_ 280 nxr2_x1
X304 272 counter.ctr_45_ counter.ctr_46_ counter.ctr_47_ 281 a4_x2
X305 93 282 283 nxr2_x1
X306 280 counter.ctr_45_ counter.ctr_46_ 281 nand3_x0
X307 94 284 281 nxr2_x1
X308 283 counter.ctr_45_ 281 a2_x2
X309 95 counter.ctr_44_ 285 nxr2_x1
X310 281 counter.ctr_42_ counter.ctr_43_ counter.ctr_44_ 286 a4_x2
X311 96 287 288 nxr2_x1
X312 285 counter.ctr_42_ counter.ctr_43_ 286 nand3_x0
X313 97 289 286 nxr2_x1
X314 288 counter.ctr_42_ 286 a2_x2
X315 98 counter.ctr_41_ 290 nxr2_x1
X316 286 counter.ctr_39_ counter.ctr_40_ counter.ctr_41_ 291 a4_x2
X317 99 292 293 nxr2_x1
X318 290 counter.ctr_39_ counter.ctr_40_ 291 nand3_x0
X319 100 294 291 nxr2_x1
X320 293 counter.ctr_39_ 291 a2_x2
X321 101 295 296 a2_x2
X322 296 counter.ctr_38_ 297 o2_x2
X323 295 counter.ctr_35_ counter.ctr_36_ 298 299 nand4_x0
X324 291 counter.ctr_35_ counter.ctr_36_ 298 299 a4_x2
X325 299 counter.ctr_37_ counter.ctr_38_ a2_x2
X326 102 counter.ctr_37_ 300 nxr2_x1
X327 297 counter.ctr_35_ counter.ctr_36_ counter.ctr_37_ 298 a4_x2
X328 103 301 302 nxr2_x1
X329 300 counter.ctr_35_ counter.ctr_36_ 298 nand3_x0
X330 104 303 298 nxr2_x1
X331 302 counter.ctr_35_ 298 a2_x2
X332 105 304 305 a2_x2
X333 305 counter.ctr_34_ 306 o2_x2
X334 304 counter.ctr_31_ counter.ctr_32_ 307 308 nand4_x0
X335 298 counter.ctr_31_ counter.ctr_32_ 307 308 a4_x2
X336 308 counter.ctr_33_ counter.ctr_34_ a2_x2
X337 106 counter.ctr_33_ 309 nxr2_x1
X338 306 counter.ctr_31_ counter.ctr_32_ counter.ctr_33_ 307 a4_x2
X339 107 310 311 nxr2_x1
X340 309 counter.ctr_31_ counter.ctr_32_ 307 nand3_x0
X341 108 312 307 nxr2_x1
X342 311 counter.ctr_31_ 307 a2_x2
X343 109 counter.ctr_30_ 313 nxr2_x1
X344 307 counter.ctr_28_ counter.ctr_29_ counter.ctr_30_ 314 a4_x2
X345 110 315 316 nxr2_x1
X346 313 counter.ctr_28_ counter.ctr_29_ 314 nand3_x0
X347 111 317 314 nxr2_x1
X348 316 counter.ctr_28_ 314 a2_x2
X349 112 counter.ctr_27_ 318 nxr2_x1
X350 314 counter.ctr_25_ counter.ctr_26_ counter.ctr_27_ 319 a4_x2
X351 113 320 321 nxr2_x1
X352 318 counter.ctr_25_ counter.ctr_26_ 319 nand3_x0
X353 114 322 319 nxr2_x1
X354 321 counter.ctr_25_ 319 a2_x2
X355 115 counter.ctr_24_ 323 nxr2_x1
X356 319 counter.ctr_22_ counter.ctr_23_ counter.ctr_24_ 324 a4_x2
X357 116 325 326 nxr2_x1
X358 323 counter.ctr_22_ counter.ctr_23_ 324 nand3_x0
X359 117 327 324 nxr2_x1
X360 326 counter.ctr_22_ 324 a2_x2
X361 118 counter.ctr_21_ 328 nxr2_x1
X362 324 counter.ctr_19_ counter.ctr_20_ counter.ctr_21_ 329 a4_x2
X363 119 330 331 nxr2_x1
X364 328 counter.ctr_19_ counter.ctr_20_ 329 nand3_x0
X365 120 332 329 nxr2_x1
X366 331 counter.ctr_19_ 329 a2_x2
X367 121 counter.ctr_18_ 333 nxr2_x1
X368 329 counter.ctr_16_ counter.ctr_17_ counter.ctr_18_ 334 a4_x2
X369 122 335 336 nxr2_x1
X370 333 counter.ctr_16_ counter.ctr_17_ 334 nand3_x0
X371 123 337 334 nxr2_x1
X372 336 counter.ctr_16_ 334 a2_x2
X373 124 counter.ctr_15_ 338 nxr2_x1
X374 334 counter.ctr_13_ counter.ctr_14_ counter.ctr_15_ 339 a4_x2
X375 125 340 341 nxr2_x1
X376 338 counter.ctr_13_ counter.ctr_14_ 339 nand3_x0
X377 126 342 339 nxr2_x1
X378 341 counter.ctr_13_ 339 a2_x2
X379 127 counter.ctr_12_ 343 nxr2_x1
X380 339 counter.ctr_10_ counter.ctr_11_ counter.ctr_12_ 344 a4_x2
X381 128 345 346 nxr2_x1
X382 343 counter.ctr_10_ counter.ctr_11_ 344 nand3_x0
X383 1 347 344 nxr2_x1
X384 346 counter.ctr_10_ 344 a2_x2
X385 2 counter.ctr_9_ 348 nxr2_x1
X386 344 counter.ctr_7_ counter.ctr_8_ counter.ctr_9_ 349 a4_x2
X387 3 350 351 nxr2_x1
X388 348 counter.ctr_7_ counter.ctr_8_ 349 nand3_x0
X389 4 352 349 nxr2_x1
X390 351 counter.ctr_7_ 349 a2_x2
X391 5 counter.ctr_6_ 353 nxr2_x1
X392 349 counter.ctr_4_ counter.ctr_5_ counter.ctr_6_ 354 a4_x2
X393 6 355 356 nxr2_x1
X394 353 counter.ctr_4_ counter.ctr_5_ 354 nand3_x0
X395 7 357 354 nxr2_x1
X396 356 counter.ctr_4_ 354 a2_x2
X397 8 358 359 nxr2_x1
X398 354 counter.ctr_1_ counter.ctr_0_ counter.ctr_2_ counter.ctr_3_ a4_x2
X399 9 360 361 nxr2_x1
X400 359 counter.ctr_1_ counter.ctr_0_ counter.ctr_2_ a3_x2
X401 10 counter.ctr_1_ counter.ctr_0_ xr2_x1
X402 361 counter.ctr_1_ counter.ctr_0_ a2_x2
X403 129 counter.ctr_127_ inv_x0
X404 131 counter.ctr_126_ inv_x0
X405 133 counter.ctr_125_ inv_x0
X406 136 counter.ctr_124_ inv_x0
X407 138 counter.ctr_123_ inv_x0
X408 141 counter.ctr_121_ inv_x0
X409 143 counter.ctr_120_ inv_x0
X410 146 counter.ctr_118_ inv_x0
X411 148 counter.ctr_117_ inv_x0
X412 151 counter.ctr_115_ inv_x0
X413 153 counter.ctr_114_ inv_x0
X414 156 counter.ctr_112_ inv_x0
X415 158 counter.ctr_111_ inv_x0
X416 161 counter.ctr_109_ inv_x0
X417 163 counter.ctr_108_ inv_x0
X418 166 counter.ctr_106_ inv_x0
X419 168 counter.ctr_105_ inv_x0
X420 171 counter.ctr_103_ inv_x0
X421 173 counter.ctr_102_ inv_x0
X422 176 counter.ctr_100_ inv_x0
X423 178 counter.ctr_99_ inv_x0
X424 181 counter.ctr_97_ inv_x0
X425 183 counter.ctr_96_ inv_x0
X426 186 counter.ctr_94_ inv_x0
X427 188 counter.ctr_93_ inv_x0
X428 191 counter.ctr_91_ inv_x0
X429 193 counter.ctr_90_ inv_x0
X430 196 counter.ctr_88_ inv_x0
X431 198 counter.ctr_87_ inv_x0
X432 205 counter.ctr_84_ inv_x0
X433 207 counter.ctr_83_ inv_x0
X434 214 counter.ctr_80_ inv_x0
X435 216 counter.ctr_79_ inv_x0
X436 219 counter.ctr_77_ inv_x0
X437 221 counter.ctr_76_ inv_x0
X438 224 counter.ctr_74_ inv_x0
X439 226 counter.ctr_73_ inv_x0
X440 227 counter.ctr_72_ inv_x0
X441 231 counter.ctr_71_ inv_x0
X442 235 counter.ctr_69_ inv_x0
X443 236 counter.ctr_68_ inv_x0
X444 240 counter.ctr_67_ inv_x0
X445 244 counter.ctr_65_ inv_x0
X446 247 counter.ctr_63_ inv_x0
X447 249 counter.ctr_62_ inv_x0
X448 252 counter.ctr_60_ inv_x0
X449 254 counter.ctr_59_ inv_x0
X450 257 counter.ctr_57_ inv_x0
X451 259 counter.ctr_56_ inv_x0
X452 260 counter.ctr_55_ inv_x0
X453 267 counter.ctr_53_ inv_x0
X454 269 counter.ctr_52_ inv_x0
X455 270 counter.ctr_51_ inv_x0
X456 277 counter.ctr_49_ inv_x0
X457 279 counter.ctr_48_ inv_x0
X458 282 counter.ctr_46_ inv_x0
X459 284 counter.ctr_45_ inv_x0
X460 287 counter.ctr_43_ inv_x0
X461 289 counter.ctr_42_ inv_x0
X462 292 counter.ctr_40_ inv_x0
X463 294 counter.ctr_39_ inv_x0
X464 301 counter.ctr_36_ inv_x0
X465 303 counter.ctr_35_ inv_x0
X466 310 counter.ctr_32_ inv_x0
X467 312 counter.ctr_31_ inv_x0
X468 315 counter.ctr_29_ inv_x0
X469 317 counter.ctr_28_ inv_x0
X470 320 counter.ctr_26_ inv_x0
X471 322 counter.ctr_25_ inv_x0
X472 325 counter.ctr_23_ inv_x0
X473 327 counter.ctr_22_ inv_x0
X474 330 counter.ctr_20_ inv_x0
X475 332 counter.ctr_19_ inv_x0
X476 335 counter.ctr_17_ inv_x0
X477 337 counter.ctr_16_ inv_x0
X478 340 counter.ctr_14_ inv_x0
X479 342 counter.ctr_13_ inv_x0
X480 345 counter.ctr_11_ inv_x0
X481 347 counter.ctr_10_ inv_x0
X482 350 counter.ctr_8_ inv_x0
X483 352 counter.ctr_7_ inv_x0
X484 355 counter.ctr_5_ inv_x0
X485 357 counter.ctr_4_ inv_x0
X486 358 counter.ctr_3_ inv_x0
X487 360 counter.ctr_2_ inv_x0
X488 11 counter.ctr_0_ inv_x0
V0 Vss 362 DC 0
V1 Vdd 363 DC 0
V2 _NC0 364 DC 0
V3 364 io_out_37_ DC 0
V4 364 io_out_36_ DC 0
V5 364 io_out_35_ DC 0
V6 364 io_out_34_ DC 0
V7 364 io_out_33_ DC 0
V8 364 io_out_32_ DC 0
V9 364 io_out_31_ DC 0
V10 362 io_out_30_ DC 0
V11 364 io_out_29_ DC 0
V12 364 io_out_28_ DC 0
V13 364 io_out_27_ DC 0
V14 364 io_out_26_ DC 0
V15 364 io_out_25_ DC 0
V16 364 io_out_24_ DC 0
V17 364 io_out_23_ DC 0
V18 364 io_out_22_ DC 0
V19 364 io_out_21_ DC 0
V20 364 io_out_20_ DC 0
V21 364 io_out_19_ DC 0
V22 364 io_out_18_ DC 0
V23 364 io_out_17_ DC 0
V24 364 io_out_16_ DC 0
V25 364 io_out_15_ DC 0
V26 364 io_out_14_ DC 0
V27 364 io_out_13_ DC 0
V28 364 io_out_12_ DC 0
V29 counter.ctr_127_ io_out_11_ DC 0
V30 counter.ctr_126_ io_out_10_ DC 0
V31 counter.ctr_125_ io_out_9_ DC 0
V32 counter.ctr_124_ io_out_8_ DC 0
V33 counter.ctr_123_ io_out_7_ DC 0
V34 counter.ctr_122_ io_out_6_ DC 0
V35 counter.ctr_121_ io_out_5_ DC 0
V36 counter.ctr_120_ io_out_4_ DC 0
V37 364 io_out_3_ DC 0
V38 364 io_out_2_ DC 0
V39 364 io_out_1_ DC 0
V40 364 io_out_0_ DC 0
V41 364 io_oeb_37_ DC 0
V42 364 io_oeb_36_ DC 0
V43 364 io_oeb_35_ DC 0
V44 364 io_oeb_34_ DC 0
V45 364 io_oeb_33_ DC 0
V46 364 io_oeb_32_ DC 0
V47 364 io_oeb_31_ DC 0
V48 363 io_oeb_30_ DC 0
V49 364 io_oeb_29_ DC 0
V50 364 io_oeb_28_ DC 0
V51 364 io_oeb_27_ DC 0
V52 364 io_oeb_26_ DC 0
V53 364 io_oeb_25_ DC 0
V54 364 io_oeb_24_ DC 0
V55 364 io_oeb_23_ DC 0
V56 364 io_oeb_22_ DC 0
V57 364 io_oeb_21_ DC 0
V58 364 io_oeb_20_ DC 0
V59 364 io_oeb_19_ DC 0
V60 364 io_oeb_18_ DC 0
V61 364 io_oeb_17_ DC 0
V62 364 io_oeb_16_ DC 0
V63 364 io_oeb_15_ DC 0
V64 364 io_oeb_14_ DC 0
V65 364 io_oeb_13_ DC 0
V66 364 io_oeb_12_ DC 0
V67 362 io_oeb_11_ DC 0
V68 362 io_oeb_10_ DC 0
V69 362 io_oeb_9_ DC 0
V70 362 io_oeb_8_ DC 0
V71 362 io_oeb_7_ DC 0
V72 362 io_oeb_6_ DC 0
V73 362 io_oeb_5_ DC 0
V74 362 io_oeb_4_ DC 0
V75 364 io_oeb_3_ DC 0
V76 364 io_oeb_2_ DC 0
V77 364 io_oeb_1_ DC 0
V78 364 io_oeb_0_ DC 0
V79 counter.ctr_127_ counter.count_7_ DC 0
V80 counter.ctr_126_ counter.count_6_ DC 0
V81 counter.ctr_125_ counter.count_5_ DC 0
V82 counter.ctr_124_ counter.count_4_ DC 0
V83 counter.ctr_123_ counter.count_3_ DC 0
V84 counter.ctr_122_ counter.count_2_ DC 0
V85 counter.ctr_121_ counter.count_1_ DC 0
V86 counter.ctr_120_ counter.count_0_ DC 0
V87 io_in_30_ counter.clk DC 0
V88 11 365 DC 0
V89 counter.ctr_127_ 366 DC 0
V90 counter.ctr_126_ 367 DC 0
V91 counter.ctr_125_ 368 DC 0
V92 counter.ctr_124_ 369 DC 0
V93 counter.ctr_123_ 370 DC 0
V94 counter.ctr_122_ 371 DC 0
V95 counter.ctr_121_ 372 DC 0
V96 counter.ctr_120_ 373 DC 0
V97 counter.ctr_119_ 374 DC 0
V98 counter.ctr_118_ 375 DC 0
V99 counter.ctr_117_ 376 DC 0
V100 counter.ctr_116_ 377 DC 0
V101 counter.ctr_115_ 378 DC 0
V102 counter.ctr_114_ 379 DC 0
V103 counter.ctr_113_ 380 DC 0
V104 counter.ctr_112_ 381 DC 0
V105 counter.ctr_111_ 382 DC 0
V106 counter.ctr_110_ 383 DC 0
V107 counter.ctr_109_ 384 DC 0
V108 counter.ctr_108_ 385 DC 0
V109 counter.ctr_107_ 386 DC 0
V110 counter.ctr_106_ 387 DC 0
V111 counter.ctr_105_ 388 DC 0
V112 counter.ctr_104_ 389 DC 0
V113 counter.ctr_103_ 390 DC 0
V114 counter.ctr_102_ 391 DC 0
V115 counter.ctr_101_ 392 DC 0
V116 counter.ctr_100_ 393 DC 0
V117 counter.ctr_99_ 394 DC 0
V118 counter.ctr_98_ 395 DC 0
V119 counter.ctr_97_ 396 DC 0
V120 counter.ctr_96_ 397 DC 0
V121 counter.ctr_95_ 398 DC 0
V122 counter.ctr_94_ 399 DC 0
V123 counter.ctr_93_ 400 DC 0
V124 counter.ctr_92_ 401 DC 0
V125 counter.ctr_91_ 402 DC 0
V126 counter.ctr_90_ 403 DC 0
V127 counter.ctr_89_ 404 DC 0
V128 counter.ctr_88_ 405 DC 0
V129 counter.ctr_87_ 406 DC 0
V130 counter.ctr_86_ 407 DC 0
V131 counter.ctr_85_ 408 DC 0
V132 counter.ctr_84_ 409 DC 0
V133 counter.ctr_83_ 410 DC 0
V134 counter.ctr_82_ 411 DC 0
V135 counter.ctr_81_ 412 DC 0
V136 counter.ctr_80_ 413 DC 0
V137 counter.ctr_79_ 414 DC 0
V138 counter.ctr_78_ 415 DC 0
V139 counter.ctr_77_ 416 DC 0
V140 counter.ctr_76_ 417 DC 0
V141 counter.ctr_75_ 418 DC 0
V142 counter.ctr_74_ 419 DC 0
V143 counter.ctr_73_ 420 DC 0
V144 counter.ctr_72_ 421 DC 0
V145 counter.ctr_71_ 422 DC 0
V146 counter.ctr_70_ 423 DC 0
V147 counter.ctr_69_ 424 DC 0
V148 counter.ctr_68_ 425 DC 0
V149 counter.ctr_67_ 426 DC 0
V150 counter.ctr_66_ 427 DC 0
V151 counter.ctr_65_ 428 DC 0
V152 counter.ctr_64_ 429 DC 0
V153 counter.ctr_63_ 430 DC 0
V154 counter.ctr_62_ 431 DC 0
V155 counter.ctr_61_ 432 DC 0
V156 counter.ctr_60_ 433 DC 0
V157 counter.ctr_59_ 434 DC 0
V158 counter.ctr_58_ 435 DC 0
V159 counter.ctr_57_ 436 DC 0
V160 counter.ctr_56_ 437 DC 0
V161 counter.ctr_55_ 438 DC 0
V162 counter.ctr_54_ 439 DC 0
V163 counter.ctr_53_ 440 DC 0
V164 counter.ctr_52_ 441 DC 0
V165 counter.ctr_51_ 442 DC 0
V166 counter.ctr_50_ 443 DC 0
V167 counter.ctr_49_ 444 DC 0
V168 counter.ctr_48_ 445 DC 0
V169 counter.ctr_47_ 446 DC 0
V170 counter.ctr_46_ 447 DC 0
V171 counter.ctr_45_ 448 DC 0
V172 counter.ctr_44_ 449 DC 0
V173 counter.ctr_43_ 450 DC 0
V174 counter.ctr_42_ 451 DC 0
V175 counter.ctr_41_ 452 DC 0
V176 counter.ctr_40_ 453 DC 0
V177 counter.ctr_39_ 454 DC 0
V178 counter.ctr_38_ 455 DC 0
V179 counter.ctr_37_ 456 DC 0
V180 counter.ctr_36_ 457 DC 0
V181 counter.ctr_35_ 458 DC 0
V182 counter.ctr_34_ 459 DC 0
V183 counter.ctr_33_ 460 DC 0
V184 counter.ctr_32_ 461 DC 0
V185 counter.ctr_31_ 462 DC 0
V186 counter.ctr_30_ 463 DC 0
V187 counter.ctr_29_ 464 DC 0
V188 counter.ctr_28_ 465 DC 0
V189 counter.ctr_27_ 466 DC 0
V190 counter.ctr_26_ 467 DC 0
V191 counter.ctr_25_ 468 DC 0
V192 counter.ctr_24_ 469 DC 0
V193 counter.ctr_23_ 470 DC 0
V194 counter.ctr_22_ 471 DC 0
V195 counter.ctr_21_ 472 DC 0
V196 counter.ctr_20_ 473 DC 0
V197 counter.ctr_19_ 474 DC 0
V198 counter.ctr_18_ 475 DC 0
V199 counter.ctr_17_ 476 DC 0
V200 counter.ctr_16_ 477 DC 0
V201 counter.ctr_15_ 478 DC 0
V202 counter.ctr_14_ 479 DC 0
V203 counter.ctr_13_ 480 DC 0
V204 counter.ctr_12_ 481 DC 0
V205 counter.ctr_11_ 482 DC 0
V206 counter.ctr_10_ 483 DC 0
V207 counter.ctr_9_ 484 DC 0
V208 counter.ctr_8_ 485 DC 0
V209 counter.ctr_7_ 486 DC 0
V210 counter.ctr_6_ 487 DC 0
V211 counter.ctr_5_ 488 DC 0
V212 counter.ctr_4_ 489 DC 0
V213 counter.ctr_3_ 490 DC 0
V214 counter.ctr_2_ 491 DC 0
V215 counter.ctr_1_ 492 DC 0
.ENDS counter_harness

************************
* end of SPICE netlist *
************************
