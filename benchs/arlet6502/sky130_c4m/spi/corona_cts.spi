* Coriolis Structural SPICE Driver
* Generated on Mar 31, 2022, 12:59
* Cell/Subckt "corona_cts".
*
* INTERF     0  vss.
* INTERF     1  vdd.
* INTERF     2  io_out_to_pad(9).
* INTERF     3  io_out_to_pad(8).
* INTERF     4  io_out_to_pad(7).
* INTERF     5  io_out_to_pad(6).
* INTERF     6  io_out_to_pad(5).
* INTERF     7  io_out_to_pad(4).
* INTERF     8  io_out_to_pad(37).
* INTERF     9  io_out_to_pad(36).
* INTERF    10  io_out_to_pad(35).
* INTERF    11  io_out_to_pad(34).
* INTERF    12  io_out_to_pad(33).
* INTERF    13  io_out_to_pad(32).
* INTERF    14  io_out_to_pad(31).
* INTERF    15  io_out_to_pad(30).
* INTERF    16  io_out_to_pad(3).
* INTERF    17  io_out_to_pad(29).
* INTERF    18  io_out_to_pad(28).
* INTERF    19  io_out_to_pad(27).
* INTERF    20  io_out_to_pad(26).
* INTERF    21  io_out_to_pad(25).
* INTERF    22  io_out_to_pad(24).
* INTERF    23  io_out_to_pad(23).
* INTERF    24  io_out_to_pad(22).
* INTERF    25  io_out_to_pad(21).
* INTERF    26  io_out_to_pad(20).
* INTERF    27  io_out_to_pad(2).
* INTERF    28  io_out_to_pad(19).
* INTERF    29  io_out_to_pad(18).
* INTERF    30  io_out_to_pad(17).
* INTERF    31  io_out_to_pad(16).
* INTERF    32  io_out_to_pad(15).
* INTERF    33  io_out_to_pad(14).
* INTERF    34  io_out_to_pad(13).
* INTERF    35  io_out_to_pad(12).
* INTERF    36  io_out_to_pad(11).
* INTERF    37  io_out_to_pad(10).
* INTERF    38  io_out_to_pad(1).
* INTERF    39  io_out_to_pad(0).
* INTERF    40  io_oeb_to_pad(9).
* INTERF    41  io_oeb_to_pad(8).
* INTERF    42  io_oeb_to_pad(7).
* INTERF    43  io_oeb_to_pad(6).
* INTERF    44  io_oeb_to_pad(5).
* INTERF    45  io_oeb_to_pad(4).
* INTERF    46  io_oeb_to_pad(37).
* INTERF    47  io_oeb_to_pad(36).
* INTERF    48  io_oeb_to_pad(35).
* INTERF    49  io_oeb_to_pad(34).
* INTERF    50  io_oeb_to_pad(33).
* INTERF    51  io_oeb_to_pad(32).
* INTERF    52  io_oeb_to_pad(31).
* INTERF    53  io_oeb_to_pad(30).
* INTERF    54  io_oeb_to_pad(3).
* INTERF    55  io_oeb_to_pad(29).
* INTERF    56  io_oeb_to_pad(28).
* INTERF    57  io_oeb_to_pad(27).
* INTERF    58  io_oeb_to_pad(26).
* INTERF    59  io_oeb_to_pad(25).
* INTERF    60  io_oeb_to_pad(24).
* INTERF    61  io_oeb_to_pad(23).
* INTERF    62  io_oeb_to_pad(22).
* INTERF    63  io_oeb_to_pad(21).
* INTERF    64  io_oeb_to_pad(20).
* INTERF    65  io_oeb_to_pad(2).
* INTERF    66  io_oeb_to_pad(19).
* INTERF    67  io_oeb_to_pad(18).
* INTERF    68  io_oeb_to_pad(17).
* INTERF    69  io_oeb_to_pad(16).
* INTERF    70  io_oeb_to_pad(15).
* INTERF    71  io_oeb_to_pad(14).
* INTERF    72  io_oeb_to_pad(13).
* INTERF    73  io_oeb_to_pad(12).
* INTERF    74  io_oeb_to_pad(11).
* INTERF    75  io_oeb_to_pad(10).
* INTERF    76  io_oeb_to_pad(1).
* INTERF    77  io_oeb_to_pad(0).
* INTERF   155  io_in_from_pad(9).
* INTERF   156  io_in_from_pad(8).
* INTERF   157  io_in_from_pad(7).
* INTERF   158  io_in_from_pad(6).
* INTERF   159  io_in_from_pad(5).
* INTERF   160  io_in_from_pad(4).
* INTERF   161  io_in_from_pad(37).
* INTERF   162  io_in_from_pad(36).
* INTERF   163  io_in_from_pad(35).
* INTERF   164  io_in_from_pad(34).
* INTERF   165  io_in_from_pad(33).
* INTERF   166  io_in_from_pad(32).
* INTERF   167  io_in_from_pad(31).
* INTERF   168  io_in_from_pad(30).
* INTERF   169  io_in_from_pad(3).
* INTERF   170  io_in_from_pad(29).
* INTERF   171  io_in_from_pad(28).
* INTERF   172  io_in_from_pad(27).
* INTERF   173  io_in_from_pad(26).
* INTERF   174  io_in_from_pad(25).
* INTERF   175  io_in_from_pad(24).
* INTERF   176  io_in_from_pad(23).
* INTERF   177  io_in_from_pad(22).
* INTERF   178  io_in_from_pad(21).
* INTERF   179  io_in_from_pad(20).
* INTERF   180  io_in_from_pad(2).
* INTERF   181  io_in_from_pad(19).
* INTERF   182  io_in_from_pad(18).
* INTERF   183  io_in_from_pad(17).
* INTERF   184  io_in_from_pad(16).
* INTERF   185  io_in_from_pad(15).
* INTERF   186  io_in_from_pad(14).
* INTERF   187  io_in_from_pad(13).
* INTERF   188  io_in_from_pad(12).
* INTERF   189  io_in_from_pad(11).
* INTERF   190  io_in_from_pad(10).
* INTERF   191  io_in_from_pad(1).
* INTERF   192  io_in_from_pad(0).

* Terminal models (aka standard cells) used througout all the hierarchy.
.include buf_x4.spi
.include decap_w0.spi
.include tie.spi
.include one_x1.spi
.include zero_x1.spi
.include buf_x1.spi
.include a2_x2.spi
.include mx2_x2.spi
.include nand2_x0.spi
.include ao22_x2.spi
.include nor3_x0.spi
.include nor4_x0.spi
.include nand3_x0.spi
.include a3_x2.spi
.include nor2_x0.spi
.include sff1_x4.spi
.include oa22_x2.spi
.include a4_x2.spi
.include nand4_x0.spi
.include o3_x2.spi
.include o4_x2.spi
.include nxr2_x1.spi
.include o2_x2.spi
.include inv_x0.spi
.include xr2_x1.spi

* Non-terminal models (part of the user's design hierarchy).
.include arlet6502_harness_cts.spi
.include arlet6502_cts.spi
.include cmpt_cpu_cts.spi
.include cmpt_alu_cts.spi

.subckt corona_cts 0 1 2 3 4 5 6 7 8 9 10 11 12 13 14 15 16 17 18 19 20 21 22 23 24 25 26 27 28 29 30 31 32 33 34 35 36 37 38 39 40 41 42 43 44 45 46 47 48 49 50 51 52 53 54 55 56 57 58 59 60 61 62 63 64 65 66 67 68 69 70 71 72 73 74 75 76 77 155 156 157 158 159 160 161 162 163 164 165 166 167 168 169 170 171 172 173 174 175 176 177 178 179 180 181 182 183 184 185 186 187 188 189 190 191 192
* NET     0  vss.
* NET     1  vdd.
* NET     2  io_out_to_pad(9).
* NET     3  io_out_to_pad(8).
* NET     4  io_out_to_pad(7).
* NET     5  io_out_to_pad(6).
* NET     6  io_out_to_pad(5).
* NET     7  io_out_to_pad(4).
* NET     8  io_out_to_pad(37).
* NET     9  io_out_to_pad(36).
* NET    10  io_out_to_pad(35).
* NET    11  io_out_to_pad(34).
* NET    12  io_out_to_pad(33).
* NET    13  io_out_to_pad(32).
* NET    14  io_out_to_pad(31).
* NET    15  io_out_to_pad(30).
* NET    16  io_out_to_pad(3).
* NET    17  io_out_to_pad(29).
* NET    18  io_out_to_pad(28).
* NET    19  io_out_to_pad(27).
* NET    20  io_out_to_pad(26).
* NET    21  io_out_to_pad(25).
* NET    22  io_out_to_pad(24).
* NET    23  io_out_to_pad(23).
* NET    24  io_out_to_pad(22).
* NET    25  io_out_to_pad(21).
* NET    26  io_out_to_pad(20).
* NET    27  io_out_to_pad(2).
* NET    28  io_out_to_pad(19).
* NET    29  io_out_to_pad(18).
* NET    30  io_out_to_pad(17).
* NET    31  io_out_to_pad(16).
* NET    32  io_out_to_pad(15).
* NET    33  io_out_to_pad(14).
* NET    34  io_out_to_pad(13).
* NET    35  io_out_to_pad(12).
* NET    36  io_out_to_pad(11).
* NET    37  io_out_to_pad(10).
* NET    38  io_out_to_pad(1).
* NET    39  io_out_to_pad(0).
* NET    40  io_oeb_to_pad(9).
* NET    41  io_oeb_to_pad(8).
* NET    42  io_oeb_to_pad(7).
* NET    43  io_oeb_to_pad(6).
* NET    44  io_oeb_to_pad(5).
* NET    45  io_oeb_to_pad(4).
* NET    46  io_oeb_to_pad(37).
* NET    47  io_oeb_to_pad(36).
* NET    48  io_oeb_to_pad(35).
* NET    49  io_oeb_to_pad(34).
* NET    50  io_oeb_to_pad(33).
* NET    51  io_oeb_to_pad(32).
* NET    52  io_oeb_to_pad(31).
* NET    53  io_oeb_to_pad(30).
* NET    54  io_oeb_to_pad(3).
* NET    55  io_oeb_to_pad(29).
* NET    56  io_oeb_to_pad(28).
* NET    57  io_oeb_to_pad(27).
* NET    58  io_oeb_to_pad(26).
* NET    59  io_oeb_to_pad(25).
* NET    60  io_oeb_to_pad(24).
* NET    61  io_oeb_to_pad(23).
* NET    62  io_oeb_to_pad(22).
* NET    63  io_oeb_to_pad(21).
* NET    64  io_oeb_to_pad(20).
* NET    65  io_oeb_to_pad(2).
* NET    66  io_oeb_to_pad(19).
* NET    67  io_oeb_to_pad(18).
* NET    68  io_oeb_to_pad(17).
* NET    69  io_oeb_to_pad(16).
* NET    70  io_oeb_to_pad(15).
* NET    71  io_oeb_to_pad(14).
* NET    72  io_oeb_to_pad(13).
* NET    73  io_oeb_to_pad(12).
* NET    74  io_oeb_to_pad(11).
* NET    75  io_oeb_to_pad(10).
* NET    76  io_oeb_to_pad(1).
* NET    77  io_oeb_to_pad(0).
* NET    78  io_in_from_pad_bit28_root_tr_tr_0.
* NET    79  io_in_from_pad_bit28_root_tr_tl_0.
* NET    80  io_in_from_pad_bit28_root_tr_br_0.
* NET    81  io_in_from_pad_bit28_root_tr_bl_0.
* NET    82  io_in_from_pad_bit28_root_tr_0.
* NET    83  io_in_from_pad_bit28_root_tl_tr_0.
* NET    84  io_in_from_pad_bit28_root_tl_tl_0.
* NET    85  io_in_from_pad_bit28_root_tl_br_0.
* NET    86  io_in_from_pad_bit28_root_tl_bl_0.
* NET    87  io_in_from_pad_bit28_root_tl_0.
* NET    88  io_in_from_pad_bit28_root_br_tr_0.
* NET    89  io_in_from_pad_bit28_root_br_tl_0.
* NET    90  io_in_from_pad_bit28_root_br_br_0.
* NET    91  io_in_from_pad_bit28_root_br_bl_0.
* NET    92  io_in_from_pad_bit28_root_br_0.
* NET    93  io_in_from_pad_bit28_root_bl_tr_0.
* NET    94  io_in_from_pad_bit28_root_bl_tl_0.
* NET    95  io_in_from_pad_bit28_root_bl_br_0.
* NET    96  io_in_from_pad_bit28_root_bl_bl_0.
* NET    97  io_in_from_pad_bit28_root_bl_0.
* NET    98  io_in_from_pad_bit28_root_0.
* NET    99  io_in_from_pad_bit27_hfns_2.
* NET   100  io_in_from_pad_bit27_hfns_1.
* NET   101  io_in_from_pad_bit27_hfns_0.
* NET   102  io_in_from_pad_bit0_root_tr_tr_2.
* NET   103  io_in_from_pad_bit0_root_tr_tr_1.
* NET   104  io_in_from_pad_bit0_root_tr_tr_0.
* NET   105  io_in_from_pad_bit0_root_tr_tl_2.
* NET   106  io_in_from_pad_bit0_root_tr_tl_1.
* NET   107  io_in_from_pad_bit0_root_tr_tl_0.
* NET   108  io_in_from_pad_bit0_root_tr_br_2.
* NET   109  io_in_from_pad_bit0_root_tr_br_1.
* NET   110  io_in_from_pad_bit0_root_tr_br_0.
* NET   111  io_in_from_pad_bit0_root_tr_bl_2.
* NET   112  io_in_from_pad_bit0_root_tr_bl_1.
* NET   113  io_in_from_pad_bit0_root_tr_bl_0.
* NET   114  io_in_from_pad_bit0_root_tr_0.
* NET   115  io_in_from_pad_bit0_root_tl_tr_2.
* NET   116  io_in_from_pad_bit0_root_tl_tr_1.
* NET   117  io_in_from_pad_bit0_root_tl_tr_0.
* NET   118  io_in_from_pad_bit0_root_tl_tl_2.
* NET   119  io_in_from_pad_bit0_root_tl_tl_1.
* NET   120  io_in_from_pad_bit0_root_tl_tl_0.
* NET   121  io_in_from_pad_bit0_root_tl_br_2.
* NET   122  io_in_from_pad_bit0_root_tl_br_1.
* NET   123  io_in_from_pad_bit0_root_tl_br_0.
* NET   124  io_in_from_pad_bit0_root_tl_bl_2.
* NET   125  io_in_from_pad_bit0_root_tl_bl_1.
* NET   126  io_in_from_pad_bit0_root_tl_bl_0.
* NET   127  io_in_from_pad_bit0_root_tl_0.
* NET   128  io_in_from_pad_bit0_root_br_tr_2.
* NET   129  io_in_from_pad_bit0_root_br_tr_1.
* NET   130  io_in_from_pad_bit0_root_br_tr_0.
* NET   131  io_in_from_pad_bit0_root_br_tl_2.
* NET   132  io_in_from_pad_bit0_root_br_tl_1.
* NET   133  io_in_from_pad_bit0_root_br_tl_0.
* NET   134  io_in_from_pad_bit0_root_br_br_2.
* NET   135  io_in_from_pad_bit0_root_br_br_1.
* NET   136  io_in_from_pad_bit0_root_br_br_0.
* NET   137  io_in_from_pad_bit0_root_br_bl_2.
* NET   138  io_in_from_pad_bit0_root_br_bl_1.
* NET   139  io_in_from_pad_bit0_root_br_bl_0.
* NET   140  io_in_from_pad_bit0_root_br_0.
* NET   141  io_in_from_pad_bit0_root_bl_tr_2.
* NET   142  io_in_from_pad_bit0_root_bl_tr_1.
* NET   143  io_in_from_pad_bit0_root_bl_tr_0.
* NET   144  io_in_from_pad_bit0_root_bl_tl_2.
* NET   145  io_in_from_pad_bit0_root_bl_tl_1.
* NET   146  io_in_from_pad_bit0_root_bl_tl_0.
* NET   147  io_in_from_pad_bit0_root_bl_br_2.
* NET   148  io_in_from_pad_bit0_root_bl_br_1.
* NET   149  io_in_from_pad_bit0_root_bl_br_0.
* NET   150  io_in_from_pad_bit0_root_bl_bl_2.
* NET   151  io_in_from_pad_bit0_root_bl_bl_1.
* NET   152  io_in_from_pad_bit0_root_bl_bl_0.
* NET   153  io_in_from_pad_bit0_root_bl_0.
* NET   154  io_in_from_pad_bit0_root_0.
* NET   155  io_in_from_pad(9).
* NET   156  io_in_from_pad(8).
* NET   157  io_in_from_pad(7).
* NET   158  io_in_from_pad(6).
* NET   159  io_in_from_pad(5).
* NET   160  io_in_from_pad(4).
* NET   161  io_in_from_pad(37).
* NET   162  io_in_from_pad(36).
* NET   163  io_in_from_pad(35).
* NET   164  io_in_from_pad(34).
* NET   165  io_in_from_pad(33).
* NET   166  io_in_from_pad(32).
* NET   167  io_in_from_pad(31).
* NET   168  io_in_from_pad(30).
* NET   169  io_in_from_pad(3).
* NET   170  io_in_from_pad(29).
* NET   171  io_in_from_pad(28).
* NET   172  io_in_from_pad(27).
* NET   173  io_in_from_pad(26).
* NET   174  io_in_from_pad(25).
* NET   175  io_in_from_pad(24).
* NET   176  io_in_from_pad(23).
* NET   177  io_in_from_pad(22).
* NET   178  io_in_from_pad(21).
* NET   179  io_in_from_pad(20).
* NET   180  io_in_from_pad(2).
* NET   181  io_in_from_pad(19).
* NET   182  io_in_from_pad(18).
* NET   183  io_in_from_pad(17).
* NET   184  io_in_from_pad(16).
* NET   185  io_in_from_pad(15).
* NET   186  io_in_from_pad(14).
* NET   187  io_in_from_pad(13).
* NET   188  io_in_from_pad(12).
* NET   189  io_in_from_pad(11).
* NET   190  io_in_from_pad(10).
* NET   191  io_in_from_pad(1).
* NET   192  io_in_from_pad(0).
* NET   193  core.zero_29.
* NET   194  core.zero_28.
* NET   195  core.zero_27.
* NET   196  core.zero_26.
* NET   197  core.zero_25.
* NET   198  core.zero_24.
* NET   199  core.zero_23.
* NET   200  core.zero_22.
* NET   201  core.zero_21.
* NET   202  core.zero_20.
* NET   203  core.zero_19.
* NET   204  core.zero_18.
* NET   205  core.zero_17.
* NET   206  core.zero_16.
* NET   207  core.zero_15.
* NET   208  core.zero_14.
* NET   209  core.zero_13.
* NET   210  core.zero_12.
* NET   211  core.zero_11.
* NET   212  core.zero_10.
* NET   213  core.zero_09.
* NET   214  core.zero_08.
* NET   215  core.zero_07.
* NET   216  core.zero_06.
* NET   217  core.zero_05.
* NET   218  core.zero_04.
* NET   219  core.zero_03.
* NET   220  core.zero_02.
* NET   221  core.zero_01.
* NET   222  core.zero_00.
* NET   223  core.real_chip.subckt_0_cpu.z.
* NET   224  core.real_chip.subckt_0_cpu.write_back.
* NET   225  core.real_chip.subckt_0_cpu.v.
* NET   226  core.real_chip.subckt_0_cpu.subckt_1654_alu.bi7.
* NET   227  core.real_chip.subckt_0_cpu.subckt_1654_alu.ai7.
* NET   228  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n99.
* NET   229  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n98.
* NET   230  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n97.
* NET   231  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n96.
* NET   232  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n95.
* NET   233  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n94.
* NET   234  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n93.
* NET   235  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n92.
* NET   236  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n91.
* NET   237  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n90.
* NET   238  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n89.
* NET   239  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n87.
* NET   240  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n86.
* NET   241  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n85.
* NET   242  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n84.
* NET   243  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n83.
* NET   244  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n82.
* NET   245  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n81.
* NET   246  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n80.
* NET   247  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n79.
* NET   248  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n78.
* NET   249  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n77.
* NET   250  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n76.
* NET   251  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n75.
* NET   252  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n74.
* NET   253  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n73.
* NET   254  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n72.
* NET   255  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n71.
* NET   256  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n70.
* NET   257  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n69.
* NET   258  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n68.
* NET   259  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n67.
* NET   260  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n66.
* NET   261  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n65.
* NET   262  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n64.
* NET   263  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n62.
* NET   264  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n61.
* NET   265  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n59.
* NET   266  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n58.
* NET   267  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n57.
* NET   268  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n56.
* NET   269  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n55.
* NET   270  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n54.
* NET   271  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n53.
* NET   272  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n52.
* NET   273  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n51_hfns_2.
* NET   274  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n51_hfns_1.
* NET   275  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n51_hfns_0.
* NET   276  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n51.
* NET   277  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n278.
* NET   278  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n273.
* NET   279  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n272.
* NET   280  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n270.
* NET   281  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n269.
* NET   282  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n268.
* NET   283  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n267.
* NET   284  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n266.
* NET   285  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n265.
* NET   286  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n264.
* NET   287  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n263.
* NET   288  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n262.
* NET   289  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n261.
* NET   290  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n260.
* NET   291  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n259.
* NET   292  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n258.
* NET   293  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n257.
* NET   294  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n256.
* NET   295  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n255.
* NET   296  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n254.
* NET   297  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n253.
* NET   298  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n252.
* NET   299  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n251.
* NET   300  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n250.
* NET   301  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n249.
* NET   302  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n248.
* NET   303  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n247.
* NET   304  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n246.
* NET   305  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n245.
* NET   306  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n244.
* NET   307  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n243.
* NET   308  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n242.
* NET   309  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n241.
* NET   310  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n240.
* NET   311  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n239.
* NET   312  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n238.
* NET   313  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n237.
* NET   314  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n236.
* NET   315  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n235.
* NET   316  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n234.
* NET   317  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n233.
* NET   318  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n232.
* NET   319  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n231.
* NET   320  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n230.
* NET   321  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n229.
* NET   322  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n228.
* NET   323  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n227.
* NET   324  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n226.
* NET   325  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n225.
* NET   326  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n224.
* NET   327  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n223.
* NET   328  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n222.
* NET   329  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n221.
* NET   330  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n220.
* NET   331  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n219.
* NET   332  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n218.
* NET   333  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n217.
* NET   334  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n216.
* NET   335  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n215.
* NET   336  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n214.
* NET   337  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n213.
* NET   338  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n212.
* NET   339  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n211.
* NET   340  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n210.
* NET   341  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n209.
* NET   342  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n208.
* NET   343  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n207.
* NET   344  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n206.
* NET   345  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n205.
* NET   346  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n204.
* NET   347  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n203.
* NET   348  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n202.
* NET   349  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n201.
* NET   350  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n200.
* NET   351  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n199.
* NET   352  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n198.
* NET   353  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n197.
* NET   354  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n196.
* NET   355  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n195.
* NET   356  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n194.
* NET   357  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n193.
* NET   358  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n192.
* NET   359  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n191.
* NET   360  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n190.
* NET   361  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n189.
* NET   362  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n188.
* NET   363  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n187.
* NET   364  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n186.
* NET   365  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n185.
* NET   366  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n184.
* NET   367  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n183.
* NET   368  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n182.
* NET   369  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n181.
* NET   370  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n180.
* NET   371  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n179.
* NET   372  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n178.
* NET   373  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n177.
* NET   374  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n176.
* NET   375  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n175.
* NET   376  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n174.
* NET   377  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n173.
* NET   378  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n172.
* NET   379  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n171.
* NET   380  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n170.
* NET   381  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n169.
* NET   382  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n168.
* NET   383  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n167.
* NET   384  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n166.
* NET   385  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n165.
* NET   386  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n164.
* NET   387  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n163.
* NET   388  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n162.
* NET   389  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n161.
* NET   390  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n160.
* NET   391  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n159.
* NET   392  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n158.
* NET   393  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n157.
* NET   394  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n156.
* NET   395  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n155.
* NET   396  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n154.
* NET   397  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n153.
* NET   398  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n152.
* NET   399  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n151.
* NET   400  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n150.
* NET   401  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n149.
* NET   402  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n148.
* NET   403  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n147.
* NET   404  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n146.
* NET   405  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n145.
* NET   406  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n144.
* NET   407  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n143.
* NET   408  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n142.
* NET   409  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n141.
* NET   410  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n140.
* NET   411  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n139.
* NET   412  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n138.
* NET   413  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n137.
* NET   414  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n136.
* NET   415  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n135.
* NET   416  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n134.
* NET   417  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n133.
* NET   418  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n132.
* NET   419  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n131.
* NET   420  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n130.
* NET   421  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n129.
* NET   422  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n128.
* NET   423  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n127.
* NET   424  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n126.
* NET   425  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n125.
* NET   426  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n124.
* NET   427  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n123.
* NET   428  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n122.
* NET   429  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n121.
* NET   430  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n120.
* NET   431  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n119.
* NET   432  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n118.
* NET   433  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n117.
* NET   434  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n116.
* NET   435  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n115.
* NET   436  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n114.
* NET   437  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n113.
* NET   438  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n112.
* NET   439  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n111.
* NET   440  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n110.
* NET   441  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n109.
* NET   442  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n108.
* NET   443  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n107.
* NET   444  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n106.
* NET   445  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n105.
* NET   446  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n104.
* NET   447  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n103.
* NET   448  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n102.
* NET   449  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n101.
* NET   450  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_new_n100.
* NET   451  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_auto_rtlil_cc_2515_muxgate_11641.
* NET   452  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_auto_rtlil_cc_2515_muxgate_11639.
* NET   453  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_auto_rtlil_cc_2515_muxgate_11637.
* NET   454  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_auto_rtlil_cc_2515_muxgate_11635.
* NET   455  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_auto_rtlil_cc_2515_muxgate_11633.
* NET   456  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_auto_rtlil_cc_2515_muxgate_11631.
* NET   457  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_auto_rtlil_cc_2515_muxgate_11629.
* NET   458  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_auto_rtlil_cc_2515_muxgate_11627.
* NET   459  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_auto_rtlil_cc_2515_muxgate_11625.
* NET   460  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_auto_rtlil_cc_2515_muxgate_11623.
* NET   461  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_auto_rtlil_cc_2515_muxgate_11621.
* NET   462  core.real_chip.subckt_0_cpu.subckt_1654_alu.abc_11882_auto_rtlil_cc_2515_muxgate_11619.
* NET   463  core.real_chip.subckt_0_cpu.store.
* NET   464  core.real_chip.subckt_0_cpu.state_bit5_hfns_2.
* NET   465  core.real_chip.subckt_0_cpu.state_bit5_hfns_1.
* NET   466  core.real_chip.subckt_0_cpu.state_bit5_hfns_0.
* NET   467  core.real_chip.subckt_0_cpu.state_bit3_hfns_2.
* NET   468  core.real_chip.subckt_0_cpu.state_bit3_hfns_1.
* NET   469  core.real_chip.subckt_0_cpu.state_bit3_hfns_0.
* NET   470  core.real_chip.subckt_0_cpu.state_bit2_hfns_2.
* NET   471  core.real_chip.subckt_0_cpu.state_bit2_hfns_1.
* NET   472  core.real_chip.subckt_0_cpu.state_bit2_hfns_0.
* NET   473  core.real_chip.subckt_0_cpu.state_bit0_hfns_2.
* NET   474  core.real_chip.subckt_0_cpu.state_bit0_hfns_1.
* NET   475  core.real_chip.subckt_0_cpu.state_bit0_hfns_0.
* NET   476  core.real_chip.subckt_0_cpu.state(5).
* NET   477  core.real_chip.subckt_0_cpu.state(4).
* NET   478  core.real_chip.subckt_0_cpu.state(3).
* NET   479  core.real_chip.subckt_0_cpu.state(2).
* NET   480  core.real_chip.subckt_0_cpu.state(1).
* NET   481  core.real_chip.subckt_0_cpu.state(0).
* NET   482  core.real_chip.subckt_0_cpu.src_reg(1).
* NET   483  core.real_chip.subckt_0_cpu.src_reg(0).
* NET   484  core.real_chip.subckt_0_cpu.shift_right.
* NET   485  core.real_chip.subckt_0_cpu.shift.
* NET   486  core.real_chip.subckt_0_cpu.sei.
* NET   487  core.real_chip.subckt_0_cpu.sed.
* NET   488  core.real_chip.subckt_0_cpu.sec.
* NET   489  core.real_chip.subckt_0_cpu.rotate.
* NET   490  core.real_chip.subckt_0_cpu.res.
* NET   491  core.real_chip.subckt_0_cpu.plp.
* NET   492  core.real_chip.subckt_0_cpu.php.
* NET   493  core.real_chip.subckt_0_cpu.pc(9).
* NET   494  core.real_chip.subckt_0_cpu.pc(8).
* NET   495  core.real_chip.subckt_0_cpu.pc(7).
* NET   496  core.real_chip.subckt_0_cpu.pc(6).
* NET   497  core.real_chip.subckt_0_cpu.pc(5).
* NET   498  core.real_chip.subckt_0_cpu.pc(4).
* NET   499  core.real_chip.subckt_0_cpu.pc(3).
* NET   500  core.real_chip.subckt_0_cpu.pc(2).
* NET   501  core.real_chip.subckt_0_cpu.pc(15).
* NET   502  core.real_chip.subckt_0_cpu.pc(14).
* NET   503  core.real_chip.subckt_0_cpu.pc(13).
* NET   504  core.real_chip.subckt_0_cpu.pc(12).
* NET   505  core.real_chip.subckt_0_cpu.pc(11).
* NET   506  core.real_chip.subckt_0_cpu.pc(10).
* NET   507  core.real_chip.subckt_0_cpu.pc(1).
* NET   508  core.real_chip.subckt_0_cpu.pc(0).
* NET   509  core.real_chip.subckt_0_cpu.op(3).
* NET   510  core.real_chip.subckt_0_cpu.op(2).
* NET   511  core.real_chip.subckt_0_cpu.op(1).
* NET   512  core.real_chip.subckt_0_cpu.op(0).
* NET   513  core.real_chip.subckt_0_cpu.nmi_edge.
* NET   514  core.real_chip.subckt_0_cpu.nmi_1.
* NET   515  core.real_chip.subckt_0_cpu.n0_adj_bcd_0_0.
* NET   516  core.real_chip.subckt_0_cpu.n.
* NET   517  core.real_chip.subckt_0_cpu.load_reg.
* NET   518  core.real_chip.subckt_0_cpu.load_only.
* NET   519  core.real_chip.subckt_0_cpu.irhold_valid_hfns_2.
* NET   520  core.real_chip.subckt_0_cpu.irhold_valid_hfns_1.
* NET   521  core.real_chip.subckt_0_cpu.irhold_valid_hfns_0.
* NET   522  core.real_chip.subckt_0_cpu.irhold_valid.
* NET   523  core.real_chip.subckt_0_cpu.irhold(7).
* NET   524  core.real_chip.subckt_0_cpu.irhold(6).
* NET   525  core.real_chip.subckt_0_cpu.irhold(5).
* NET   526  core.real_chip.subckt_0_cpu.irhold(4).
* NET   527  core.real_chip.subckt_0_cpu.irhold(3).
* NET   528  core.real_chip.subckt_0_cpu.irhold(2).
* NET   529  core.real_chip.subckt_0_cpu.irhold(1).
* NET   530  core.real_chip.subckt_0_cpu.irhold(0).
* NET   531  core.real_chip.subckt_0_cpu.index_y.
* NET   532  core.real_chip.subckt_0_cpu.inc.
* NET   533  core.real_chip.subckt_0_cpu.i.
* NET   534  core.real_chip.subckt_0_cpu.hc.
* NET   535  core.real_chip.subckt_0_cpu.dst_reg(1).
* NET   536  core.real_chip.subckt_0_cpu.dst_reg(0).
* NET   537  core.real_chip.subckt_0_cpu.dimux(7).
* NET   538  core.real_chip.subckt_0_cpu.dimux(6).
* NET   539  core.real_chip.subckt_0_cpu.dimux(5).
* NET   540  core.real_chip.subckt_0_cpu.dimux(4).
* NET   541  core.real_chip.subckt_0_cpu.dimux(3).
* NET   542  core.real_chip.subckt_0_cpu.dimux(2).
* NET   543  core.real_chip.subckt_0_cpu.dimux(1).
* NET   544  core.real_chip.subckt_0_cpu.dimux(0).
* NET   545  core.real_chip.subckt_0_cpu.dihold(7).
* NET   546  core.real_chip.subckt_0_cpu.dihold(6).
* NET   547  core.real_chip.subckt_0_cpu.dihold(5).
* NET   548  core.real_chip.subckt_0_cpu.dihold(4).
* NET   549  core.real_chip.subckt_0_cpu.dihold(3).
* NET   550  core.real_chip.subckt_0_cpu.dihold(2).
* NET   551  core.real_chip.subckt_0_cpu.dihold(1).
* NET   552  core.real_chip.subckt_0_cpu.dihold(0).
* NET   553  core.real_chip.subckt_0_cpu.d.
* NET   554  core.real_chip.subckt_0_cpu.cond_code(2).
* NET   555  core.real_chip.subckt_0_cpu.cond_code(1).
* NET   556  core.real_chip.subckt_0_cpu.cond_code(0).
* NET   557  core.real_chip.subckt_0_cpu.compare.
* NET   558  core.real_chip.subckt_0_cpu.co.
* NET   559  core.real_chip.subckt_0_cpu.clv.
* NET   560  core.real_chip.subckt_0_cpu.cli.
* NET   561  core.real_chip.subckt_0_cpu.cld.
* NET   562  core.real_chip.subckt_0_cpu.clc.
* NET   563  core.real_chip.subckt_0_cpu.ci.
* NET   564  core.real_chip.subckt_0_cpu.c.
* NET   565  core.real_chip.subckt_0_cpu.bit_ins.
* NET   566  core.real_chip.subckt_0_cpu.bi(7).
* NET   567  core.real_chip.subckt_0_cpu.bi(6).
* NET   568  core.real_chip.subckt_0_cpu.bi(5).
* NET   569  core.real_chip.subckt_0_cpu.bi(4).
* NET   570  core.real_chip.subckt_0_cpu.bi(3).
* NET   571  core.real_chip.subckt_0_cpu.bi(2).
* NET   572  core.real_chip.subckt_0_cpu.bi(1).
* NET   573  core.real_chip.subckt_0_cpu.bi(0).
* NET   574  core.real_chip.subckt_0_cpu.backwards.
* NET   575  core.real_chip.subckt_0_cpu.az.
* NET   576  core.real_chip.subckt_0_cpu.axys_3_7.
* NET   577  core.real_chip.subckt_0_cpu.axys_3_6.
* NET   578  core.real_chip.subckt_0_cpu.axys_3_5.
* NET   579  core.real_chip.subckt_0_cpu.axys_3_4.
* NET   580  core.real_chip.subckt_0_cpu.axys_3_3.
* NET   581  core.real_chip.subckt_0_cpu.axys_3_2.
* NET   582  core.real_chip.subckt_0_cpu.axys_3_1.
* NET   583  core.real_chip.subckt_0_cpu.axys_3_0.
* NET   584  core.real_chip.subckt_0_cpu.axys_2_7.
* NET   585  core.real_chip.subckt_0_cpu.axys_2_6.
* NET   586  core.real_chip.subckt_0_cpu.axys_2_5.
* NET   587  core.real_chip.subckt_0_cpu.axys_2_4.
* NET   588  core.real_chip.subckt_0_cpu.axys_2_3.
* NET   589  core.real_chip.subckt_0_cpu.axys_2_2.
* NET   590  core.real_chip.subckt_0_cpu.axys_2_1.
* NET   591  core.real_chip.subckt_0_cpu.axys_2_0.
* NET   592  core.real_chip.subckt_0_cpu.axys_1_7.
* NET   593  core.real_chip.subckt_0_cpu.axys_1_6.
* NET   594  core.real_chip.subckt_0_cpu.axys_1_5.
* NET   595  core.real_chip.subckt_0_cpu.axys_1_4.
* NET   596  core.real_chip.subckt_0_cpu.axys_1_3.
* NET   597  core.real_chip.subckt_0_cpu.axys_1_2.
* NET   598  core.real_chip.subckt_0_cpu.axys_1_1.
* NET   599  core.real_chip.subckt_0_cpu.axys_1_0.
* NET   600  core.real_chip.subckt_0_cpu.axys_0_7.
* NET   601  core.real_chip.subckt_0_cpu.axys_0_6.
* NET   602  core.real_chip.subckt_0_cpu.axys_0_5.
* NET   603  core.real_chip.subckt_0_cpu.axys_0_4.
* NET   604  core.real_chip.subckt_0_cpu.axys_0_3.
* NET   605  core.real_chip.subckt_0_cpu.axys_0_2.
* NET   606  core.real_chip.subckt_0_cpu.axys_0_1.
* NET   607  core.real_chip.subckt_0_cpu.axys_0_0.
* NET   608  core.real_chip.subckt_0_cpu.av.
* NET   609  core.real_chip.subckt_0_cpu.auto_fsm_map_cc_288_map_fsm_1405_y(5).
* NET   610  core.real_chip.subckt_0_cpu.auto_fsm_map_cc_288_map_fsm_1405_y(4).
* NET   611  core.real_chip.subckt_0_cpu.auto_fsm_map_cc_288_map_fsm_1405_y(3).
* NET   612  core.real_chip.subckt_0_cpu.auto_fsm_map_cc_288_map_fsm_1405_y(2).
* NET   613  core.real_chip.subckt_0_cpu.auto_fsm_map_cc_288_map_fsm_1405_y(1).
* NET   614  core.real_chip.subckt_0_cpu.auto_fsm_map_cc_288_map_fsm_1405_y(0).
* NET   615  core.real_chip.subckt_0_cpu.alu_shift_right.
* NET   616  core.real_chip.subckt_0_cpu.alu_op_bit2_hfns_2.
* NET   617  core.real_chip.subckt_0_cpu.alu_op_bit2_hfns_1.
* NET   618  core.real_chip.subckt_0_cpu.alu_op_bit2_hfns_0.
* NET   619  core.real_chip.subckt_0_cpu.alu_op(3).
* NET   620  core.real_chip.subckt_0_cpu.alu_op(2).
* NET   621  core.real_chip.subckt_0_cpu.alu_op(1).
* NET   622  core.real_chip.subckt_0_cpu.alu_op(0).
* NET   623  core.real_chip.subckt_0_cpu.ai(7).
* NET   624  core.real_chip.subckt_0_cpu.ai(6).
* NET   625  core.real_chip.subckt_0_cpu.ai(5).
* NET   626  core.real_chip.subckt_0_cpu.ai(4).
* NET   627  core.real_chip.subckt_0_cpu.ai(3).
* NET   628  core.real_chip.subckt_0_cpu.ai(2).
* NET   629  core.real_chip.subckt_0_cpu.ai(1).
* NET   630  core.real_chip.subckt_0_cpu.ai(0).
* NET   631  core.real_chip.subckt_0_cpu.adj_bcd.
* NET   632  core.real_chip.subckt_0_cpu.add(7).
* NET   633  core.real_chip.subckt_0_cpu.add(6).
* NET   634  core.real_chip.subckt_0_cpu.add(5).
* NET   635  core.real_chip.subckt_0_cpu.add(4).
* NET   636  core.real_chip.subckt_0_cpu.add(3).
* NET   637  core.real_chip.subckt_0_cpu.add(2).
* NET   638  core.real_chip.subckt_0_cpu.add(1).
* NET   639  core.real_chip.subckt_0_cpu.add(0).
* NET   640  core.real_chip.subckt_0_cpu.adc_sbc.
* NET   641  core.real_chip.subckt_0_cpu.adc_bcd.
* NET   642  core.real_chip.subckt_0_cpu.abl(7).
* NET   643  core.real_chip.subckt_0_cpu.abl(6).
* NET   644  core.real_chip.subckt_0_cpu.abl(5).
* NET   645  core.real_chip.subckt_0_cpu.abl(4).
* NET   646  core.real_chip.subckt_0_cpu.abl(3).
* NET   647  core.real_chip.subckt_0_cpu.abl(2).
* NET   648  core.real_chip.subckt_0_cpu.abl(1).
* NET   649  core.real_chip.subckt_0_cpu.abl(0).
* NET   650  core.real_chip.subckt_0_cpu.abh(7).
* NET   651  core.real_chip.subckt_0_cpu.abh(6).
* NET   652  core.real_chip.subckt_0_cpu.abh(5).
* NET   653  core.real_chip.subckt_0_cpu.abh(4).
* NET   654  core.real_chip.subckt_0_cpu.abh(3).
* NET   655  core.real_chip.subckt_0_cpu.abh(2).
* NET   656  core.real_chip.subckt_0_cpu.abh(1).
* NET   657  core.real_chip.subckt_0_cpu.abh(0).
* NET   658  core.real_chip.subckt_0_cpu.abc_12118_new_n999.
* NET   659  core.real_chip.subckt_0_cpu.abc_12118_new_n998.
* NET   660  core.real_chip.subckt_0_cpu.abc_12118_new_n997.
* NET   661  core.real_chip.subckt_0_cpu.abc_12118_new_n996.
* NET   662  core.real_chip.subckt_0_cpu.abc_12118_new_n995.
* NET   663  core.real_chip.subckt_0_cpu.abc_12118_new_n994.
* NET   664  core.real_chip.subckt_0_cpu.abc_12118_new_n993.
* NET   665  core.real_chip.subckt_0_cpu.abc_12118_new_n992.
* NET   666  core.real_chip.subckt_0_cpu.abc_12118_new_n991.
* NET   667  core.real_chip.subckt_0_cpu.abc_12118_new_n990.
* NET   668  core.real_chip.subckt_0_cpu.abc_12118_new_n989.
* NET   669  core.real_chip.subckt_0_cpu.abc_12118_new_n988.
* NET   670  core.real_chip.subckt_0_cpu.abc_12118_new_n987.
* NET   671  core.real_chip.subckt_0_cpu.abc_12118_new_n986.
* NET   672  core.real_chip.subckt_0_cpu.abc_12118_new_n985.
* NET   673  core.real_chip.subckt_0_cpu.abc_12118_new_n984.
* NET   674  core.real_chip.subckt_0_cpu.abc_12118_new_n983.
* NET   675  core.real_chip.subckt_0_cpu.abc_12118_new_n982.
* NET   676  core.real_chip.subckt_0_cpu.abc_12118_new_n981.
* NET   677  core.real_chip.subckt_0_cpu.abc_12118_new_n980.
* NET   678  core.real_chip.subckt_0_cpu.abc_12118_new_n979.
* NET   679  core.real_chip.subckt_0_cpu.abc_12118_new_n978.
* NET   680  core.real_chip.subckt_0_cpu.abc_12118_new_n977.
* NET   681  core.real_chip.subckt_0_cpu.abc_12118_new_n976.
* NET   682  core.real_chip.subckt_0_cpu.abc_12118_new_n975.
* NET   683  core.real_chip.subckt_0_cpu.abc_12118_new_n974.
* NET   684  core.real_chip.subckt_0_cpu.abc_12118_new_n973.
* NET   685  core.real_chip.subckt_0_cpu.abc_12118_new_n972.
* NET   686  core.real_chip.subckt_0_cpu.abc_12118_new_n970.
* NET   687  core.real_chip.subckt_0_cpu.abc_12118_new_n969.
* NET   688  core.real_chip.subckt_0_cpu.abc_12118_new_n967.
* NET   689  core.real_chip.subckt_0_cpu.abc_12118_new_n966.
* NET   690  core.real_chip.subckt_0_cpu.abc_12118_new_n964.
* NET   691  core.real_chip.subckt_0_cpu.abc_12118_new_n963.
* NET   692  core.real_chip.subckt_0_cpu.abc_12118_new_n961.
* NET   693  core.real_chip.subckt_0_cpu.abc_12118_new_n960.
* NET   694  core.real_chip.subckt_0_cpu.abc_12118_new_n958.
* NET   695  core.real_chip.subckt_0_cpu.abc_12118_new_n957.
* NET   696  core.real_chip.subckt_0_cpu.abc_12118_new_n955.
* NET   697  core.real_chip.subckt_0_cpu.abc_12118_new_n954.
* NET   698  core.real_chip.subckt_0_cpu.abc_12118_new_n952.
* NET   699  core.real_chip.subckt_0_cpu.abc_12118_new_n951.
* NET   700  core.real_chip.subckt_0_cpu.abc_12118_new_n949.
* NET   701  core.real_chip.subckt_0_cpu.abc_12118_new_n948.
* NET   702  core.real_chip.subckt_0_cpu.abc_12118_new_n947.
* NET   703  core.real_chip.subckt_0_cpu.abc_12118_new_n946.
* NET   704  core.real_chip.subckt_0_cpu.abc_12118_new_n945.
* NET   705  core.real_chip.subckt_0_cpu.abc_12118_new_n944.
* NET   706  core.real_chip.subckt_0_cpu.abc_12118_new_n943.
* NET   707  core.real_chip.subckt_0_cpu.abc_12118_new_n942.
* NET   708  core.real_chip.subckt_0_cpu.abc_12118_new_n941.
* NET   709  core.real_chip.subckt_0_cpu.abc_12118_new_n940.
* NET   710  core.real_chip.subckt_0_cpu.abc_12118_new_n939.
* NET   711  core.real_chip.subckt_0_cpu.abc_12118_new_n938.
* NET   712  core.real_chip.subckt_0_cpu.abc_12118_new_n937.
* NET   713  core.real_chip.subckt_0_cpu.abc_12118_new_n936.
* NET   714  core.real_chip.subckt_0_cpu.abc_12118_new_n934.
* NET   715  core.real_chip.subckt_0_cpu.abc_12118_new_n933.
* NET   716  core.real_chip.subckt_0_cpu.abc_12118_new_n932.
* NET   717  core.real_chip.subckt_0_cpu.abc_12118_new_n931.
* NET   718  core.real_chip.subckt_0_cpu.abc_12118_new_n930.
* NET   719  core.real_chip.subckt_0_cpu.abc_12118_new_n929.
* NET   720  core.real_chip.subckt_0_cpu.abc_12118_new_n928.
* NET   721  core.real_chip.subckt_0_cpu.abc_12118_new_n927.
* NET   722  core.real_chip.subckt_0_cpu.abc_12118_new_n926.
* NET   723  core.real_chip.subckt_0_cpu.abc_12118_new_n925.
* NET   724  core.real_chip.subckt_0_cpu.abc_12118_new_n924.
* NET   725  core.real_chip.subckt_0_cpu.abc_12118_new_n923.
* NET   726  core.real_chip.subckt_0_cpu.abc_12118_new_n922.
* NET   727  core.real_chip.subckt_0_cpu.abc_12118_new_n921.
* NET   728  core.real_chip.subckt_0_cpu.abc_12118_new_n920.
* NET   729  core.real_chip.subckt_0_cpu.abc_12118_new_n919.
* NET   730  core.real_chip.subckt_0_cpu.abc_12118_new_n918.
* NET   731  core.real_chip.subckt_0_cpu.abc_12118_new_n917.
* NET   732  core.real_chip.subckt_0_cpu.abc_12118_new_n915.
* NET   733  core.real_chip.subckt_0_cpu.abc_12118_new_n914.
* NET   734  core.real_chip.subckt_0_cpu.abc_12118_new_n913.
* NET   735  core.real_chip.subckt_0_cpu.abc_12118_new_n912.
* NET   736  core.real_chip.subckt_0_cpu.abc_12118_new_n911.
* NET   737  core.real_chip.subckt_0_cpu.abc_12118_new_n910.
* NET   738  core.real_chip.subckt_0_cpu.abc_12118_new_n909.
* NET   739  core.real_chip.subckt_0_cpu.abc_12118_new_n908.
* NET   740  core.real_chip.subckt_0_cpu.abc_12118_new_n907.
* NET   741  core.real_chip.subckt_0_cpu.abc_12118_new_n906.
* NET   742  core.real_chip.subckt_0_cpu.abc_12118_new_n905.
* NET   743  core.real_chip.subckt_0_cpu.abc_12118_new_n904.
* NET   744  core.real_chip.subckt_0_cpu.abc_12118_new_n903.
* NET   745  core.real_chip.subckt_0_cpu.abc_12118_new_n902.
* NET   746  core.real_chip.subckt_0_cpu.abc_12118_new_n900.
* NET   747  core.real_chip.subckt_0_cpu.abc_12118_new_n899.
* NET   748  core.real_chip.subckt_0_cpu.abc_12118_new_n898.
* NET   749  core.real_chip.subckt_0_cpu.abc_12118_new_n897.
* NET   750  core.real_chip.subckt_0_cpu.abc_12118_new_n896.
* NET   751  core.real_chip.subckt_0_cpu.abc_12118_new_n895.
* NET   752  core.real_chip.subckt_0_cpu.abc_12118_new_n894.
* NET   753  core.real_chip.subckt_0_cpu.abc_12118_new_n892.
* NET   754  core.real_chip.subckt_0_cpu.abc_12118_new_n891.
* NET   755  core.real_chip.subckt_0_cpu.abc_12118_new_n890.
* NET   756  core.real_chip.subckt_0_cpu.abc_12118_new_n889.
* NET   757  core.real_chip.subckt_0_cpu.abc_12118_new_n888.
* NET   758  core.real_chip.subckt_0_cpu.abc_12118_new_n887.
* NET   759  core.real_chip.subckt_0_cpu.abc_12118_new_n886.
* NET   760  core.real_chip.subckt_0_cpu.abc_12118_new_n885.
* NET   761  core.real_chip.subckt_0_cpu.abc_12118_new_n884.
* NET   762  core.real_chip.subckt_0_cpu.abc_12118_new_n883.
* NET   763  core.real_chip.subckt_0_cpu.abc_12118_new_n882.
* NET   764  core.real_chip.subckt_0_cpu.abc_12118_new_n881.
* NET   765  core.real_chip.subckt_0_cpu.abc_12118_new_n880.
* NET   766  core.real_chip.subckt_0_cpu.abc_12118_new_n879.
* NET   767  core.real_chip.subckt_0_cpu.abc_12118_new_n878.
* NET   768  core.real_chip.subckt_0_cpu.abc_12118_new_n877.
* NET   769  core.real_chip.subckt_0_cpu.abc_12118_new_n876.
* NET   770  core.real_chip.subckt_0_cpu.abc_12118_new_n875.
* NET   771  core.real_chip.subckt_0_cpu.abc_12118_new_n874.
* NET   772  core.real_chip.subckt_0_cpu.abc_12118_new_n873.
* NET   773  core.real_chip.subckt_0_cpu.abc_12118_new_n872.
* NET   774  core.real_chip.subckt_0_cpu.abc_12118_new_n871.
* NET   775  core.real_chip.subckt_0_cpu.abc_12118_new_n870.
* NET   776  core.real_chip.subckt_0_cpu.abc_12118_new_n869.
* NET   777  core.real_chip.subckt_0_cpu.abc_12118_new_n868.
* NET   778  core.real_chip.subckt_0_cpu.abc_12118_new_n866.
* NET   779  core.real_chip.subckt_0_cpu.abc_12118_new_n865.
* NET   780  core.real_chip.subckt_0_cpu.abc_12118_new_n864.
* NET   781  core.real_chip.subckt_0_cpu.abc_12118_new_n863.
* NET   782  core.real_chip.subckt_0_cpu.abc_12118_new_n862.
* NET   783  core.real_chip.subckt_0_cpu.abc_12118_new_n861.
* NET   784  core.real_chip.subckt_0_cpu.abc_12118_new_n860.
* NET   785  core.real_chip.subckt_0_cpu.abc_12118_new_n859.
* NET   786  core.real_chip.subckt_0_cpu.abc_12118_new_n858.
* NET   787  core.real_chip.subckt_0_cpu.abc_12118_new_n857.
* NET   788  core.real_chip.subckt_0_cpu.abc_12118_new_n856.
* NET   789  core.real_chip.subckt_0_cpu.abc_12118_new_n855.
* NET   790  core.real_chip.subckt_0_cpu.abc_12118_new_n854.
* NET   791  core.real_chip.subckt_0_cpu.abc_12118_new_n853.
* NET   792  core.real_chip.subckt_0_cpu.abc_12118_new_n852.
* NET   793  core.real_chip.subckt_0_cpu.abc_12118_new_n851.
* NET   794  core.real_chip.subckt_0_cpu.abc_12118_new_n850.
* NET   795  core.real_chip.subckt_0_cpu.abc_12118_new_n849.
* NET   796  core.real_chip.subckt_0_cpu.abc_12118_new_n848.
* NET   797  core.real_chip.subckt_0_cpu.abc_12118_new_n847.
* NET   798  core.real_chip.subckt_0_cpu.abc_12118_new_n846.
* NET   799  core.real_chip.subckt_0_cpu.abc_12118_new_n845.
* NET   800  core.real_chip.subckt_0_cpu.abc_12118_new_n844.
* NET   801  core.real_chip.subckt_0_cpu.abc_12118_new_n843.
* NET   802  core.real_chip.subckt_0_cpu.abc_12118_new_n842.
* NET   803  core.real_chip.subckt_0_cpu.abc_12118_new_n841.
* NET   804  core.real_chip.subckt_0_cpu.abc_12118_new_n840.
* NET   805  core.real_chip.subckt_0_cpu.abc_12118_new_n839.
* NET   806  core.real_chip.subckt_0_cpu.abc_12118_new_n838.
* NET   807  core.real_chip.subckt_0_cpu.abc_12118_new_n837.
* NET   808  core.real_chip.subckt_0_cpu.abc_12118_new_n836.
* NET   809  core.real_chip.subckt_0_cpu.abc_12118_new_n835.
* NET   810  core.real_chip.subckt_0_cpu.abc_12118_new_n834.
* NET   811  core.real_chip.subckt_0_cpu.abc_12118_new_n833.
* NET   812  core.real_chip.subckt_0_cpu.abc_12118_new_n832.
* NET   813  core.real_chip.subckt_0_cpu.abc_12118_new_n831.
* NET   814  core.real_chip.subckt_0_cpu.abc_12118_new_n830.
* NET   815  core.real_chip.subckt_0_cpu.abc_12118_new_n829.
* NET   816  core.real_chip.subckt_0_cpu.abc_12118_new_n828.
* NET   817  core.real_chip.subckt_0_cpu.abc_12118_new_n827.
* NET   818  core.real_chip.subckt_0_cpu.abc_12118_new_n826.
* NET   819  core.real_chip.subckt_0_cpu.abc_12118_new_n825.
* NET   820  core.real_chip.subckt_0_cpu.abc_12118_new_n824.
* NET   821  core.real_chip.subckt_0_cpu.abc_12118_new_n823.
* NET   822  core.real_chip.subckt_0_cpu.abc_12118_new_n822.
* NET   823  core.real_chip.subckt_0_cpu.abc_12118_new_n821.
* NET   824  core.real_chip.subckt_0_cpu.abc_12118_new_n820.
* NET   825  core.real_chip.subckt_0_cpu.abc_12118_new_n819.
* NET   826  core.real_chip.subckt_0_cpu.abc_12118_new_n818.
* NET   827  core.real_chip.subckt_0_cpu.abc_12118_new_n817.
* NET   828  core.real_chip.subckt_0_cpu.abc_12118_new_n816.
* NET   829  core.real_chip.subckt_0_cpu.abc_12118_new_n815.
* NET   830  core.real_chip.subckt_0_cpu.abc_12118_new_n814.
* NET   831  core.real_chip.subckt_0_cpu.abc_12118_new_n813.
* NET   832  core.real_chip.subckt_0_cpu.abc_12118_new_n812.
* NET   833  core.real_chip.subckt_0_cpu.abc_12118_new_n810.
* NET   834  core.real_chip.subckt_0_cpu.abc_12118_new_n809.
* NET   835  core.real_chip.subckt_0_cpu.abc_12118_new_n808.
* NET   836  core.real_chip.subckt_0_cpu.abc_12118_new_n807.
* NET   837  core.real_chip.subckt_0_cpu.abc_12118_new_n806.
* NET   838  core.real_chip.subckt_0_cpu.abc_12118_new_n805.
* NET   839  core.real_chip.subckt_0_cpu.abc_12118_new_n804.
* NET   840  core.real_chip.subckt_0_cpu.abc_12118_new_n803.
* NET   841  core.real_chip.subckt_0_cpu.abc_12118_new_n802.
* NET   842  core.real_chip.subckt_0_cpu.abc_12118_new_n801.
* NET   843  core.real_chip.subckt_0_cpu.abc_12118_new_n800.
* NET   844  core.real_chip.subckt_0_cpu.abc_12118_new_n799.
* NET   845  core.real_chip.subckt_0_cpu.abc_12118_new_n798.
* NET   846  core.real_chip.subckt_0_cpu.abc_12118_new_n797.
* NET   847  core.real_chip.subckt_0_cpu.abc_12118_new_n796.
* NET   848  core.real_chip.subckt_0_cpu.abc_12118_new_n795.
* NET   849  core.real_chip.subckt_0_cpu.abc_12118_new_n794.
* NET   850  core.real_chip.subckt_0_cpu.abc_12118_new_n793.
* NET   851  core.real_chip.subckt_0_cpu.abc_12118_new_n792.
* NET   852  core.real_chip.subckt_0_cpu.abc_12118_new_n791.
* NET   853  core.real_chip.subckt_0_cpu.abc_12118_new_n790.
* NET   854  core.real_chip.subckt_0_cpu.abc_12118_new_n789.
* NET   855  core.real_chip.subckt_0_cpu.abc_12118_new_n788.
* NET   856  core.real_chip.subckt_0_cpu.abc_12118_new_n787.
* NET   857  core.real_chip.subckt_0_cpu.abc_12118_new_n786.
* NET   858  core.real_chip.subckt_0_cpu.abc_12118_new_n785.
* NET   859  core.real_chip.subckt_0_cpu.abc_12118_new_n784.
* NET   860  core.real_chip.subckt_0_cpu.abc_12118_new_n783.
* NET   861  core.real_chip.subckt_0_cpu.abc_12118_new_n782.
* NET   862  core.real_chip.subckt_0_cpu.abc_12118_new_n781.
* NET   863  core.real_chip.subckt_0_cpu.abc_12118_new_n780.
* NET   864  core.real_chip.subckt_0_cpu.abc_12118_new_n779.
* NET   865  core.real_chip.subckt_0_cpu.abc_12118_new_n778.
* NET   866  core.real_chip.subckt_0_cpu.abc_12118_new_n777.
* NET   867  core.real_chip.subckt_0_cpu.abc_12118_new_n776.
* NET   868  core.real_chip.subckt_0_cpu.abc_12118_new_n775.
* NET   869  core.real_chip.subckt_0_cpu.abc_12118_new_n774.
* NET   870  core.real_chip.subckt_0_cpu.abc_12118_new_n773.
* NET   871  core.real_chip.subckt_0_cpu.abc_12118_new_n772.
* NET   872  core.real_chip.subckt_0_cpu.abc_12118_new_n771.
* NET   873  core.real_chip.subckt_0_cpu.abc_12118_new_n770.
* NET   874  core.real_chip.subckt_0_cpu.abc_12118_new_n769.
* NET   875  core.real_chip.subckt_0_cpu.abc_12118_new_n768.
* NET   876  core.real_chip.subckt_0_cpu.abc_12118_new_n767.
* NET   877  core.real_chip.subckt_0_cpu.abc_12118_new_n766.
* NET   878  core.real_chip.subckt_0_cpu.abc_12118_new_n765.
* NET   879  core.real_chip.subckt_0_cpu.abc_12118_new_n764.
* NET   880  core.real_chip.subckt_0_cpu.abc_12118_new_n763.
* NET   881  core.real_chip.subckt_0_cpu.abc_12118_new_n762.
* NET   882  core.real_chip.subckt_0_cpu.abc_12118_new_n761.
* NET   883  core.real_chip.subckt_0_cpu.abc_12118_new_n760.
* NET   884  core.real_chip.subckt_0_cpu.abc_12118_new_n759.
* NET   885  core.real_chip.subckt_0_cpu.abc_12118_new_n758.
* NET   886  core.real_chip.subckt_0_cpu.abc_12118_new_n757.
* NET   887  core.real_chip.subckt_0_cpu.abc_12118_new_n756.
* NET   888  core.real_chip.subckt_0_cpu.abc_12118_new_n755.
* NET   889  core.real_chip.subckt_0_cpu.abc_12118_new_n754.
* NET   890  core.real_chip.subckt_0_cpu.abc_12118_new_n753.
* NET   891  core.real_chip.subckt_0_cpu.abc_12118_new_n752.
* NET   892  core.real_chip.subckt_0_cpu.abc_12118_new_n751.
* NET   893  core.real_chip.subckt_0_cpu.abc_12118_new_n750.
* NET   894  core.real_chip.subckt_0_cpu.abc_12118_new_n749.
* NET   895  core.real_chip.subckt_0_cpu.abc_12118_new_n748.
* NET   896  core.real_chip.subckt_0_cpu.abc_12118_new_n747.
* NET   897  core.real_chip.subckt_0_cpu.abc_12118_new_n746.
* NET   898  core.real_chip.subckt_0_cpu.abc_12118_new_n745.
* NET   899  core.real_chip.subckt_0_cpu.abc_12118_new_n744.
* NET   900  core.real_chip.subckt_0_cpu.abc_12118_new_n743.
* NET   901  core.real_chip.subckt_0_cpu.abc_12118_new_n741.
* NET   902  core.real_chip.subckt_0_cpu.abc_12118_new_n740.
* NET   903  core.real_chip.subckt_0_cpu.abc_12118_new_n739.
* NET   904  core.real_chip.subckt_0_cpu.abc_12118_new_n738.
* NET   905  core.real_chip.subckt_0_cpu.abc_12118_new_n737.
* NET   906  core.real_chip.subckt_0_cpu.abc_12118_new_n736.
* NET   907  core.real_chip.subckt_0_cpu.abc_12118_new_n735.
* NET   908  core.real_chip.subckt_0_cpu.abc_12118_new_n734.
* NET   909  core.real_chip.subckt_0_cpu.abc_12118_new_n733.
* NET   910  core.real_chip.subckt_0_cpu.abc_12118_new_n732.
* NET   911  core.real_chip.subckt_0_cpu.abc_12118_new_n731.
* NET   912  core.real_chip.subckt_0_cpu.abc_12118_new_n730.
* NET   913  core.real_chip.subckt_0_cpu.abc_12118_new_n729.
* NET   914  core.real_chip.subckt_0_cpu.abc_12118_new_n728.
* NET   915  core.real_chip.subckt_0_cpu.abc_12118_new_n727.
* NET   916  core.real_chip.subckt_0_cpu.abc_12118_new_n726.
* NET   917  core.real_chip.subckt_0_cpu.abc_12118_new_n725.
* NET   918  core.real_chip.subckt_0_cpu.abc_12118_new_n724.
* NET   919  core.real_chip.subckt_0_cpu.abc_12118_new_n723.
* NET   920  core.real_chip.subckt_0_cpu.abc_12118_new_n722.
* NET   921  core.real_chip.subckt_0_cpu.abc_12118_new_n721.
* NET   922  core.real_chip.subckt_0_cpu.abc_12118_new_n720.
* NET   923  core.real_chip.subckt_0_cpu.abc_12118_new_n719.
* NET   924  core.real_chip.subckt_0_cpu.abc_12118_new_n718.
* NET   925  core.real_chip.subckt_0_cpu.abc_12118_new_n717.
* NET   926  core.real_chip.subckt_0_cpu.abc_12118_new_n716.
* NET   927  core.real_chip.subckt_0_cpu.abc_12118_new_n715.
* NET   928  core.real_chip.subckt_0_cpu.abc_12118_new_n714.
* NET   929  core.real_chip.subckt_0_cpu.abc_12118_new_n713.
* NET   930  core.real_chip.subckt_0_cpu.abc_12118_new_n712.
* NET   931  core.real_chip.subckt_0_cpu.abc_12118_new_n711.
* NET   932  core.real_chip.subckt_0_cpu.abc_12118_new_n710.
* NET   933  core.real_chip.subckt_0_cpu.abc_12118_new_n709.
* NET   934  core.real_chip.subckt_0_cpu.abc_12118_new_n708.
* NET   935  core.real_chip.subckt_0_cpu.abc_12118_new_n707.
* NET   936  core.real_chip.subckt_0_cpu.abc_12118_new_n706.
* NET   937  core.real_chip.subckt_0_cpu.abc_12118_new_n705.
* NET   938  core.real_chip.subckt_0_cpu.abc_12118_new_n704.
* NET   939  core.real_chip.subckt_0_cpu.abc_12118_new_n703.
* NET   940  core.real_chip.subckt_0_cpu.abc_12118_new_n702.
* NET   941  core.real_chip.subckt_0_cpu.abc_12118_new_n701.
* NET   942  core.real_chip.subckt_0_cpu.abc_12118_new_n700.
* NET   943  core.real_chip.subckt_0_cpu.abc_12118_new_n699.
* NET   944  core.real_chip.subckt_0_cpu.abc_12118_new_n698.
* NET   945  core.real_chip.subckt_0_cpu.abc_12118_new_n697.
* NET   946  core.real_chip.subckt_0_cpu.abc_12118_new_n696.
* NET   947  core.real_chip.subckt_0_cpu.abc_12118_new_n695.
* NET   948  core.real_chip.subckt_0_cpu.abc_12118_new_n694.
* NET   949  core.real_chip.subckt_0_cpu.abc_12118_new_n693.
* NET   950  core.real_chip.subckt_0_cpu.abc_12118_new_n692.
* NET   951  core.real_chip.subckt_0_cpu.abc_12118_new_n691.
* NET   952  core.real_chip.subckt_0_cpu.abc_12118_new_n690.
* NET   953  core.real_chip.subckt_0_cpu.abc_12118_new_n689.
* NET   954  core.real_chip.subckt_0_cpu.abc_12118_new_n688.
* NET   955  core.real_chip.subckt_0_cpu.abc_12118_new_n687.
* NET   956  core.real_chip.subckt_0_cpu.abc_12118_new_n686.
* NET   957  core.real_chip.subckt_0_cpu.abc_12118_new_n685.
* NET   958  core.real_chip.subckt_0_cpu.abc_12118_new_n684.
* NET   959  core.real_chip.subckt_0_cpu.abc_12118_new_n683.
* NET   960  core.real_chip.subckt_0_cpu.abc_12118_new_n682.
* NET   961  core.real_chip.subckt_0_cpu.abc_12118_new_n681.
* NET   962  core.real_chip.subckt_0_cpu.abc_12118_new_n680.
* NET   963  core.real_chip.subckt_0_cpu.abc_12118_new_n679.
* NET   964  core.real_chip.subckt_0_cpu.abc_12118_new_n678.
* NET   965  core.real_chip.subckt_0_cpu.abc_12118_new_n677.
* NET   966  core.real_chip.subckt_0_cpu.abc_12118_new_n676.
* NET   967  core.real_chip.subckt_0_cpu.abc_12118_new_n675.
* NET   968  core.real_chip.subckt_0_cpu.abc_12118_new_n674.
* NET   969  core.real_chip.subckt_0_cpu.abc_12118_new_n673.
* NET   970  core.real_chip.subckt_0_cpu.abc_12118_new_n672.
* NET   971  core.real_chip.subckt_0_cpu.abc_12118_new_n671.
* NET   972  core.real_chip.subckt_0_cpu.abc_12118_new_n670.
* NET   973  core.real_chip.subckt_0_cpu.abc_12118_new_n669.
* NET   974  core.real_chip.subckt_0_cpu.abc_12118_new_n668.
* NET   975  core.real_chip.subckt_0_cpu.abc_12118_new_n667.
* NET   976  core.real_chip.subckt_0_cpu.abc_12118_new_n666.
* NET   977  core.real_chip.subckt_0_cpu.abc_12118_new_n665.
* NET   978  core.real_chip.subckt_0_cpu.abc_12118_new_n664.
* NET   979  core.real_chip.subckt_0_cpu.abc_12118_new_n663.
* NET   980  core.real_chip.subckt_0_cpu.abc_12118_new_n662.
* NET   981  core.real_chip.subckt_0_cpu.abc_12118_new_n661.
* NET   982  core.real_chip.subckt_0_cpu.abc_12118_new_n660.
* NET   983  core.real_chip.subckt_0_cpu.abc_12118_new_n659.
* NET   984  core.real_chip.subckt_0_cpu.abc_12118_new_n658.
* NET   985  core.real_chip.subckt_0_cpu.abc_12118_new_n657.
* NET   986  core.real_chip.subckt_0_cpu.abc_12118_new_n656.
* NET   987  core.real_chip.subckt_0_cpu.abc_12118_new_n655.
* NET   988  core.real_chip.subckt_0_cpu.abc_12118_new_n654.
* NET   989  core.real_chip.subckt_0_cpu.abc_12118_new_n653.
* NET   990  core.real_chip.subckt_0_cpu.abc_12118_new_n652.
* NET   991  core.real_chip.subckt_0_cpu.abc_12118_new_n651.
* NET   992  core.real_chip.subckt_0_cpu.abc_12118_new_n650.
* NET   993  core.real_chip.subckt_0_cpu.abc_12118_new_n649.
* NET   994  core.real_chip.subckt_0_cpu.abc_12118_new_n648.
* NET   995  core.real_chip.subckt_0_cpu.abc_12118_new_n647.
* NET   996  core.real_chip.subckt_0_cpu.abc_12118_new_n646.
* NET   997  core.real_chip.subckt_0_cpu.abc_12118_new_n645.
* NET   998  core.real_chip.subckt_0_cpu.abc_12118_new_n644.
* NET   999  core.real_chip.subckt_0_cpu.abc_12118_new_n643.
* NET  1000  core.real_chip.subckt_0_cpu.abc_12118_new_n642.
* NET  1001  core.real_chip.subckt_0_cpu.abc_12118_new_n641.
* NET  1002  core.real_chip.subckt_0_cpu.abc_12118_new_n640.
* NET  1003  core.real_chip.subckt_0_cpu.abc_12118_new_n639.
* NET  1004  core.real_chip.subckt_0_cpu.abc_12118_new_n638.
* NET  1005  core.real_chip.subckt_0_cpu.abc_12118_new_n637.
* NET  1006  core.real_chip.subckt_0_cpu.abc_12118_new_n636_hfns_2.
* NET  1007  core.real_chip.subckt_0_cpu.abc_12118_new_n636_hfns_1.
* NET  1008  core.real_chip.subckt_0_cpu.abc_12118_new_n636_hfns_0.
* NET  1009  core.real_chip.subckt_0_cpu.abc_12118_new_n636.
* NET  1010  core.real_chip.subckt_0_cpu.abc_12118_new_n635.
* NET  1011  core.real_chip.subckt_0_cpu.abc_12118_new_n634.
* NET  1012  core.real_chip.subckt_0_cpu.abc_12118_new_n633.
* NET  1013  core.real_chip.subckt_0_cpu.abc_12118_new_n632.
* NET  1014  core.real_chip.subckt_0_cpu.abc_12118_new_n631.
* NET  1015  core.real_chip.subckt_0_cpu.abc_12118_new_n630.
* NET  1016  core.real_chip.subckt_0_cpu.abc_12118_new_n629.
* NET  1017  core.real_chip.subckt_0_cpu.abc_12118_new_n628.
* NET  1018  core.real_chip.subckt_0_cpu.abc_12118_new_n627.
* NET  1019  core.real_chip.subckt_0_cpu.abc_12118_new_n626.
* NET  1020  core.real_chip.subckt_0_cpu.abc_12118_new_n625.
* NET  1021  core.real_chip.subckt_0_cpu.abc_12118_new_n624.
* NET  1022  core.real_chip.subckt_0_cpu.abc_12118_new_n623.
* NET  1023  core.real_chip.subckt_0_cpu.abc_12118_new_n622.
* NET  1024  core.real_chip.subckt_0_cpu.abc_12118_new_n621.
* NET  1025  core.real_chip.subckt_0_cpu.abc_12118_new_n620.
* NET  1026  core.real_chip.subckt_0_cpu.abc_12118_new_n619.
* NET  1027  core.real_chip.subckt_0_cpu.abc_12118_new_n618.
* NET  1028  core.real_chip.subckt_0_cpu.abc_12118_new_n617.
* NET  1029  core.real_chip.subckt_0_cpu.abc_12118_new_n616.
* NET  1030  core.real_chip.subckt_0_cpu.abc_12118_new_n615.
* NET  1031  core.real_chip.subckt_0_cpu.abc_12118_new_n614.
* NET  1032  core.real_chip.subckt_0_cpu.abc_12118_new_n613.
* NET  1033  core.real_chip.subckt_0_cpu.abc_12118_new_n612.
* NET  1034  core.real_chip.subckt_0_cpu.abc_12118_new_n611.
* NET  1035  core.real_chip.subckt_0_cpu.abc_12118_new_n610.
* NET  1036  core.real_chip.subckt_0_cpu.abc_12118_new_n609.
* NET  1037  core.real_chip.subckt_0_cpu.abc_12118_new_n608.
* NET  1038  core.real_chip.subckt_0_cpu.abc_12118_new_n607.
* NET  1039  core.real_chip.subckt_0_cpu.abc_12118_new_n606.
* NET  1040  core.real_chip.subckt_0_cpu.abc_12118_new_n605.
* NET  1041  core.real_chip.subckt_0_cpu.abc_12118_new_n604.
* NET  1042  core.real_chip.subckt_0_cpu.abc_12118_new_n603.
* NET  1043  core.real_chip.subckt_0_cpu.abc_12118_new_n602.
* NET  1044  core.real_chip.subckt_0_cpu.abc_12118_new_n601.
* NET  1045  core.real_chip.subckt_0_cpu.abc_12118_new_n600.
* NET  1046  core.real_chip.subckt_0_cpu.abc_12118_new_n599.
* NET  1047  core.real_chip.subckt_0_cpu.abc_12118_new_n598.
* NET  1048  core.real_chip.subckt_0_cpu.abc_12118_new_n597.
* NET  1049  core.real_chip.subckt_0_cpu.abc_12118_new_n596.
* NET  1050  core.real_chip.subckt_0_cpu.abc_12118_new_n595.
* NET  1051  core.real_chip.subckt_0_cpu.abc_12118_new_n594.
* NET  1052  core.real_chip.subckt_0_cpu.abc_12118_new_n593.
* NET  1053  core.real_chip.subckt_0_cpu.abc_12118_new_n592.
* NET  1054  core.real_chip.subckt_0_cpu.abc_12118_new_n591.
* NET  1055  core.real_chip.subckt_0_cpu.abc_12118_new_n590.
* NET  1056  core.real_chip.subckt_0_cpu.abc_12118_new_n589.
* NET  1057  core.real_chip.subckt_0_cpu.abc_12118_new_n588.
* NET  1058  core.real_chip.subckt_0_cpu.abc_12118_new_n587.
* NET  1059  core.real_chip.subckt_0_cpu.abc_12118_new_n586.
* NET  1060  core.real_chip.subckt_0_cpu.abc_12118_new_n585.
* NET  1061  core.real_chip.subckt_0_cpu.abc_12118_new_n584.
* NET  1062  core.real_chip.subckt_0_cpu.abc_12118_new_n583.
* NET  1063  core.real_chip.subckt_0_cpu.abc_12118_new_n582.
* NET  1064  core.real_chip.subckt_0_cpu.abc_12118_new_n581.
* NET  1065  core.real_chip.subckt_0_cpu.abc_12118_new_n580.
* NET  1066  core.real_chip.subckt_0_cpu.abc_12118_new_n579.
* NET  1067  core.real_chip.subckt_0_cpu.abc_12118_new_n578.
* NET  1068  core.real_chip.subckt_0_cpu.abc_12118_new_n577.
* NET  1069  core.real_chip.subckt_0_cpu.abc_12118_new_n576.
* NET  1070  core.real_chip.subckt_0_cpu.abc_12118_new_n575.
* NET  1071  core.real_chip.subckt_0_cpu.abc_12118_new_n574.
* NET  1072  core.real_chip.subckt_0_cpu.abc_12118_new_n573.
* NET  1073  core.real_chip.subckt_0_cpu.abc_12118_new_n572.
* NET  1074  core.real_chip.subckt_0_cpu.abc_12118_new_n571.
* NET  1075  core.real_chip.subckt_0_cpu.abc_12118_new_n570.
* NET  1076  core.real_chip.subckt_0_cpu.abc_12118_new_n569.
* NET  1077  core.real_chip.subckt_0_cpu.abc_12118_new_n568.
* NET  1078  core.real_chip.subckt_0_cpu.abc_12118_new_n567.
* NET  1079  core.real_chip.subckt_0_cpu.abc_12118_new_n566.
* NET  1080  core.real_chip.subckt_0_cpu.abc_12118_new_n565.
* NET  1081  core.real_chip.subckt_0_cpu.abc_12118_new_n564_hfns_2.
* NET  1082  core.real_chip.subckt_0_cpu.abc_12118_new_n564_hfns_1.
* NET  1083  core.real_chip.subckt_0_cpu.abc_12118_new_n564_hfns_0.
* NET  1084  core.real_chip.subckt_0_cpu.abc_12118_new_n564.
* NET  1085  core.real_chip.subckt_0_cpu.abc_12118_new_n563.
* NET  1086  core.real_chip.subckt_0_cpu.abc_12118_new_n562.
* NET  1087  core.real_chip.subckt_0_cpu.abc_12118_new_n561.
* NET  1088  core.real_chip.subckt_0_cpu.abc_12118_new_n560.
* NET  1089  core.real_chip.subckt_0_cpu.abc_12118_new_n559.
* NET  1090  core.real_chip.subckt_0_cpu.abc_12118_new_n558.
* NET  1091  core.real_chip.subckt_0_cpu.abc_12118_new_n557.
* NET  1092  core.real_chip.subckt_0_cpu.abc_12118_new_n556.
* NET  1093  core.real_chip.subckt_0_cpu.abc_12118_new_n555.
* NET  1094  core.real_chip.subckt_0_cpu.abc_12118_new_n554.
* NET  1095  core.real_chip.subckt_0_cpu.abc_12118_new_n553.
* NET  1096  core.real_chip.subckt_0_cpu.abc_12118_new_n552.
* NET  1097  core.real_chip.subckt_0_cpu.abc_12118_new_n551.
* NET  1098  core.real_chip.subckt_0_cpu.abc_12118_new_n550.
* NET  1099  core.real_chip.subckt_0_cpu.abc_12118_new_n549.
* NET  1100  core.real_chip.subckt_0_cpu.abc_12118_new_n548.
* NET  1101  core.real_chip.subckt_0_cpu.abc_12118_new_n547.
* NET  1102  core.real_chip.subckt_0_cpu.abc_12118_new_n546.
* NET  1103  core.real_chip.subckt_0_cpu.abc_12118_new_n545.
* NET  1104  core.real_chip.subckt_0_cpu.abc_12118_new_n544_hfns_3.
* NET  1105  core.real_chip.subckt_0_cpu.abc_12118_new_n544_hfns_2.
* NET  1106  core.real_chip.subckt_0_cpu.abc_12118_new_n544_hfns_1.
* NET  1107  core.real_chip.subckt_0_cpu.abc_12118_new_n544_hfns_0.
* NET  1108  core.real_chip.subckt_0_cpu.abc_12118_new_n544.
* NET  1109  core.real_chip.subckt_0_cpu.abc_12118_new_n543.
* NET  1110  core.real_chip.subckt_0_cpu.abc_12118_new_n542.
* NET  1111  core.real_chip.subckt_0_cpu.abc_12118_new_n541.
* NET  1112  core.real_chip.subckt_0_cpu.abc_12118_new_n540.
* NET  1113  core.real_chip.subckt_0_cpu.abc_12118_new_n539.
* NET  1114  core.real_chip.subckt_0_cpu.abc_12118_new_n538.
* NET  1115  core.real_chip.subckt_0_cpu.abc_12118_new_n537.
* NET  1116  core.real_chip.subckt_0_cpu.abc_12118_new_n536.
* NET  1117  core.real_chip.subckt_0_cpu.abc_12118_new_n535.
* NET  1118  core.real_chip.subckt_0_cpu.abc_12118_new_n534.
* NET  1119  core.real_chip.subckt_0_cpu.abc_12118_new_n533.
* NET  1120  core.real_chip.subckt_0_cpu.abc_12118_new_n532.
* NET  1121  core.real_chip.subckt_0_cpu.abc_12118_new_n531.
* NET  1122  core.real_chip.subckt_0_cpu.abc_12118_new_n530.
* NET  1123  core.real_chip.subckt_0_cpu.abc_12118_new_n529.
* NET  1124  core.real_chip.subckt_0_cpu.abc_12118_new_n528.
* NET  1125  core.real_chip.subckt_0_cpu.abc_12118_new_n527.
* NET  1126  core.real_chip.subckt_0_cpu.abc_12118_new_n526.
* NET  1127  core.real_chip.subckt_0_cpu.abc_12118_new_n525.
* NET  1128  core.real_chip.subckt_0_cpu.abc_12118_new_n524.
* NET  1129  core.real_chip.subckt_0_cpu.abc_12118_new_n523.
* NET  1130  core.real_chip.subckt_0_cpu.abc_12118_new_n522.
* NET  1131  core.real_chip.subckt_0_cpu.abc_12118_new_n521.
* NET  1132  core.real_chip.subckt_0_cpu.abc_12118_new_n520.
* NET  1133  core.real_chip.subckt_0_cpu.abc_12118_new_n519.
* NET  1134  core.real_chip.subckt_0_cpu.abc_12118_new_n518.
* NET  1135  core.real_chip.subckt_0_cpu.abc_12118_new_n517.
* NET  1136  core.real_chip.subckt_0_cpu.abc_12118_new_n516_hfns_2.
* NET  1137  core.real_chip.subckt_0_cpu.abc_12118_new_n516_hfns_1.
* NET  1138  core.real_chip.subckt_0_cpu.abc_12118_new_n516_hfns_0.
* NET  1139  core.real_chip.subckt_0_cpu.abc_12118_new_n516.
* NET  1140  core.real_chip.subckt_0_cpu.abc_12118_new_n515.
* NET  1141  core.real_chip.subckt_0_cpu.abc_12118_new_n514.
* NET  1142  core.real_chip.subckt_0_cpu.abc_12118_new_n513.
* NET  1143  core.real_chip.subckt_0_cpu.abc_12118_new_n512.
* NET  1144  core.real_chip.subckt_0_cpu.abc_12118_new_n511.
* NET  1145  core.real_chip.subckt_0_cpu.abc_12118_new_n510.
* NET  1146  core.real_chip.subckt_0_cpu.abc_12118_new_n509.
* NET  1147  core.real_chip.subckt_0_cpu.abc_12118_new_n508.
* NET  1148  core.real_chip.subckt_0_cpu.abc_12118_new_n507.
* NET  1149  core.real_chip.subckt_0_cpu.abc_12118_new_n506.
* NET  1150  core.real_chip.subckt_0_cpu.abc_12118_new_n505.
* NET  1151  core.real_chip.subckt_0_cpu.abc_12118_new_n504.
* NET  1152  core.real_chip.subckt_0_cpu.abc_12118_new_n503.
* NET  1153  core.real_chip.subckt_0_cpu.abc_12118_new_n502.
* NET  1154  core.real_chip.subckt_0_cpu.abc_12118_new_n501.
* NET  1155  core.real_chip.subckt_0_cpu.abc_12118_new_n500.
* NET  1156  core.real_chip.subckt_0_cpu.abc_12118_new_n499.
* NET  1157  core.real_chip.subckt_0_cpu.abc_12118_new_n498_hfns_2.
* NET  1158  core.real_chip.subckt_0_cpu.abc_12118_new_n498_hfns_1.
* NET  1159  core.real_chip.subckt_0_cpu.abc_12118_new_n498_hfns_0.
* NET  1160  core.real_chip.subckt_0_cpu.abc_12118_new_n498.
* NET  1161  core.real_chip.subckt_0_cpu.abc_12118_new_n497.
* NET  1162  core.real_chip.subckt_0_cpu.abc_12118_new_n496.
* NET  1163  core.real_chip.subckt_0_cpu.abc_12118_new_n495.
* NET  1164  core.real_chip.subckt_0_cpu.abc_12118_new_n494.
* NET  1165  core.real_chip.subckt_0_cpu.abc_12118_new_n493.
* NET  1166  core.real_chip.subckt_0_cpu.abc_12118_new_n492.
* NET  1167  core.real_chip.subckt_0_cpu.abc_12118_new_n491.
* NET  1168  core.real_chip.subckt_0_cpu.abc_12118_new_n490.
* NET  1169  core.real_chip.subckt_0_cpu.abc_12118_new_n489.
* NET  1170  core.real_chip.subckt_0_cpu.abc_12118_new_n488.
* NET  1171  core.real_chip.subckt_0_cpu.abc_12118_new_n487.
* NET  1172  core.real_chip.subckt_0_cpu.abc_12118_new_n486.
* NET  1173  core.real_chip.subckt_0_cpu.abc_12118_new_n485.
* NET  1174  core.real_chip.subckt_0_cpu.abc_12118_new_n484.
* NET  1175  core.real_chip.subckt_0_cpu.abc_12118_new_n483.
* NET  1176  core.real_chip.subckt_0_cpu.abc_12118_new_n482.
* NET  1177  core.real_chip.subckt_0_cpu.abc_12118_new_n481.
* NET  1178  core.real_chip.subckt_0_cpu.abc_12118_new_n480.
* NET  1179  core.real_chip.subckt_0_cpu.abc_12118_new_n479.
* NET  1180  core.real_chip.subckt_0_cpu.abc_12118_new_n478.
* NET  1181  core.real_chip.subckt_0_cpu.abc_12118_new_n477.
* NET  1182  core.real_chip.subckt_0_cpu.abc_12118_new_n476.
* NET  1183  core.real_chip.subckt_0_cpu.abc_12118_new_n475.
* NET  1184  core.real_chip.subckt_0_cpu.abc_12118_new_n474.
* NET  1185  core.real_chip.subckt_0_cpu.abc_12118_new_n473.
* NET  1186  core.real_chip.subckt_0_cpu.abc_12118_new_n472.
* NET  1187  core.real_chip.subckt_0_cpu.abc_12118_new_n471.
* NET  1188  core.real_chip.subckt_0_cpu.abc_12118_new_n470.
* NET  1189  core.real_chip.subckt_0_cpu.abc_12118_new_n469.
* NET  1190  core.real_chip.subckt_0_cpu.abc_12118_new_n468.
* NET  1191  core.real_chip.subckt_0_cpu.abc_12118_new_n467.
* NET  1192  core.real_chip.subckt_0_cpu.abc_12118_new_n466.
* NET  1193  core.real_chip.subckt_0_cpu.abc_12118_new_n465.
* NET  1194  core.real_chip.subckt_0_cpu.abc_12118_new_n464.
* NET  1195  core.real_chip.subckt_0_cpu.abc_12118_new_n463.
* NET  1196  core.real_chip.subckt_0_cpu.abc_12118_new_n462.
* NET  1197  core.real_chip.subckt_0_cpu.abc_12118_new_n461.
* NET  1198  core.real_chip.subckt_0_cpu.abc_12118_new_n460.
* NET  1199  core.real_chip.subckt_0_cpu.abc_12118_new_n459.
* NET  1200  core.real_chip.subckt_0_cpu.abc_12118_new_n458.
* NET  1201  core.real_chip.subckt_0_cpu.abc_12118_new_n457.
* NET  1202  core.real_chip.subckt_0_cpu.abc_12118_new_n456.
* NET  1203  core.real_chip.subckt_0_cpu.abc_12118_new_n455.
* NET  1204  core.real_chip.subckt_0_cpu.abc_12118_new_n454_hfns_2.
* NET  1205  core.real_chip.subckt_0_cpu.abc_12118_new_n454_hfns_1.
* NET  1206  core.real_chip.subckt_0_cpu.abc_12118_new_n454_hfns_0.
* NET  1207  core.real_chip.subckt_0_cpu.abc_12118_new_n454.
* NET  1208  core.real_chip.subckt_0_cpu.abc_12118_new_n453.
* NET  1209  core.real_chip.subckt_0_cpu.abc_12118_new_n452.
* NET  1210  core.real_chip.subckt_0_cpu.abc_12118_new_n451_hfns_2.
* NET  1211  core.real_chip.subckt_0_cpu.abc_12118_new_n451_hfns_1.
* NET  1212  core.real_chip.subckt_0_cpu.abc_12118_new_n451_hfns_0.
* NET  1213  core.real_chip.subckt_0_cpu.abc_12118_new_n451.
* NET  1214  core.real_chip.subckt_0_cpu.abc_12118_new_n450.
* NET  1215  core.real_chip.subckt_0_cpu.abc_12118_new_n449.
* NET  1216  core.real_chip.subckt_0_cpu.abc_12118_new_n448.
* NET  1217  core.real_chip.subckt_0_cpu.abc_12118_new_n447.
* NET  1218  core.real_chip.subckt_0_cpu.abc_12118_new_n446.
* NET  1219  core.real_chip.subckt_0_cpu.abc_12118_new_n445.
* NET  1220  core.real_chip.subckt_0_cpu.abc_12118_new_n444_hfns_2.
* NET  1221  core.real_chip.subckt_0_cpu.abc_12118_new_n444_hfns_1.
* NET  1222  core.real_chip.subckt_0_cpu.abc_12118_new_n444_hfns_0.
* NET  1223  core.real_chip.subckt_0_cpu.abc_12118_new_n444.
* NET  1224  core.real_chip.subckt_0_cpu.abc_12118_new_n443.
* NET  1225  core.real_chip.subckt_0_cpu.abc_12118_new_n442_hfns_2.
* NET  1226  core.real_chip.subckt_0_cpu.abc_12118_new_n442_hfns_1.
* NET  1227  core.real_chip.subckt_0_cpu.abc_12118_new_n442_hfns_0.
* NET  1228  core.real_chip.subckt_0_cpu.abc_12118_new_n442.
* NET  1229  core.real_chip.subckt_0_cpu.abc_12118_new_n441_hfns_2.
* NET  1230  core.real_chip.subckt_0_cpu.abc_12118_new_n441_hfns_1.
* NET  1231  core.real_chip.subckt_0_cpu.abc_12118_new_n441_hfns_0.
* NET  1232  core.real_chip.subckt_0_cpu.abc_12118_new_n441.
* NET  1233  core.real_chip.subckt_0_cpu.abc_12118_new_n440_hfns_2.
* NET  1234  core.real_chip.subckt_0_cpu.abc_12118_new_n440_hfns_1.
* NET  1235  core.real_chip.subckt_0_cpu.abc_12118_new_n440_hfns_0.
* NET  1236  core.real_chip.subckt_0_cpu.abc_12118_new_n440.
* NET  1237  core.real_chip.subckt_0_cpu.abc_12118_new_n439.
* NET  1238  core.real_chip.subckt_0_cpu.abc_12118_new_n438_hfns_4.
* NET  1239  core.real_chip.subckt_0_cpu.abc_12118_new_n438_hfns_3.
* NET  1240  core.real_chip.subckt_0_cpu.abc_12118_new_n438_hfns_2.
* NET  1241  core.real_chip.subckt_0_cpu.abc_12118_new_n438_hfns_1.
* NET  1242  core.real_chip.subckt_0_cpu.abc_12118_new_n438_hfns_0.
* NET  1243  core.real_chip.subckt_0_cpu.abc_12118_new_n438.
* NET  1244  core.real_chip.subckt_0_cpu.abc_12118_new_n436.
* NET  1245  core.real_chip.subckt_0_cpu.abc_12118_new_n434.
* NET  1246  core.real_chip.subckt_0_cpu.abc_12118_new_n432.
* NET  1247  core.real_chip.subckt_0_cpu.abc_12118_new_n430.
* NET  1248  core.real_chip.subckt_0_cpu.abc_12118_new_n428.
* NET  1249  core.real_chip.subckt_0_cpu.abc_12118_new_n426.
* NET  1250  core.real_chip.subckt_0_cpu.abc_12118_new_n424.
* NET  1251  core.real_chip.subckt_0_cpu.abc_12118_new_n422.
* NET  1252  core.real_chip.subckt_0_cpu.abc_12118_new_n421.
* NET  1253  core.real_chip.subckt_0_cpu.abc_12118_new_n420.
* NET  1254  core.real_chip.subckt_0_cpu.abc_12118_new_n419.
* NET  1255  core.real_chip.subckt_0_cpu.abc_12118_new_n418.
* NET  1256  core.real_chip.subckt_0_cpu.abc_12118_new_n417.
* NET  1257  core.real_chip.subckt_0_cpu.abc_12118_new_n416.
* NET  1258  core.real_chip.subckt_0_cpu.abc_12118_new_n415.
* NET  1259  core.real_chip.subckt_0_cpu.abc_12118_new_n414.
* NET  1260  core.real_chip.subckt_0_cpu.abc_12118_new_n413.
* NET  1261  core.real_chip.subckt_0_cpu.abc_12118_new_n412.
* NET  1262  core.real_chip.subckt_0_cpu.abc_12118_new_n411.
* NET  1263  core.real_chip.subckt_0_cpu.abc_12118_new_n410.
* NET  1264  core.real_chip.subckt_0_cpu.abc_12118_new_n409.
* NET  1265  core.real_chip.subckt_0_cpu.abc_12118_new_n408.
* NET  1266  core.real_chip.subckt_0_cpu.abc_12118_new_n407.
* NET  1267  core.real_chip.subckt_0_cpu.abc_12118_new_n406.
* NET  1268  core.real_chip.subckt_0_cpu.abc_12118_new_n405.
* NET  1269  core.real_chip.subckt_0_cpu.abc_12118_new_n404.
* NET  1270  core.real_chip.subckt_0_cpu.abc_12118_new_n403.
* NET  1271  core.real_chip.subckt_0_cpu.abc_12118_new_n402_hfns_2.
* NET  1272  core.real_chip.subckt_0_cpu.abc_12118_new_n402_hfns_1.
* NET  1273  core.real_chip.subckt_0_cpu.abc_12118_new_n402_hfns_0.
* NET  1274  core.real_chip.subckt_0_cpu.abc_12118_new_n402.
* NET  1275  core.real_chip.subckt_0_cpu.abc_12118_new_n401.
* NET  1276  core.real_chip.subckt_0_cpu.abc_12118_new_n400.
* NET  1277  core.real_chip.subckt_0_cpu.abc_12118_new_n399.
* NET  1278  core.real_chip.subckt_0_cpu.abc_12118_new_n398.
* NET  1279  core.real_chip.subckt_0_cpu.abc_12118_new_n397.
* NET  1280  core.real_chip.subckt_0_cpu.abc_12118_new_n396.
* NET  1281  core.real_chip.subckt_0_cpu.abc_12118_new_n395.
* NET  1282  core.real_chip.subckt_0_cpu.abc_12118_new_n394.
* NET  1283  core.real_chip.subckt_0_cpu.abc_12118_new_n393.
* NET  1284  core.real_chip.subckt_0_cpu.abc_12118_new_n392.
* NET  1285  core.real_chip.subckt_0_cpu.abc_12118_new_n391.
* NET  1286  core.real_chip.subckt_0_cpu.abc_12118_new_n390.
* NET  1287  core.real_chip.subckt_0_cpu.abc_12118_new_n389.
* NET  1288  core.real_chip.subckt_0_cpu.abc_12118_new_n388.
* NET  1289  core.real_chip.subckt_0_cpu.abc_12118_new_n387.
* NET  1290  core.real_chip.subckt_0_cpu.abc_12118_new_n386.
* NET  1291  core.real_chip.subckt_0_cpu.abc_12118_new_n385.
* NET  1292  core.real_chip.subckt_0_cpu.abc_12118_new_n384.
* NET  1293  core.real_chip.subckt_0_cpu.abc_12118_new_n383.
* NET  1294  core.real_chip.subckt_0_cpu.abc_12118_new_n382.
* NET  1295  core.real_chip.subckt_0_cpu.abc_12118_new_n381.
* NET  1296  core.real_chip.subckt_0_cpu.abc_12118_new_n380.
* NET  1297  core.real_chip.subckt_0_cpu.abc_12118_new_n379.
* NET  1298  core.real_chip.subckt_0_cpu.abc_12118_new_n378.
* NET  1299  core.real_chip.subckt_0_cpu.abc_12118_new_n377.
* NET  1300  core.real_chip.subckt_0_cpu.abc_12118_new_n376.
* NET  1301  core.real_chip.subckt_0_cpu.abc_12118_new_n375.
* NET  1302  core.real_chip.subckt_0_cpu.abc_12118_new_n374.
* NET  1303  core.real_chip.subckt_0_cpu.abc_12118_new_n373.
* NET  1304  core.real_chip.subckt_0_cpu.abc_12118_new_n372.
* NET  1305  core.real_chip.subckt_0_cpu.abc_12118_new_n371.
* NET  1306  core.real_chip.subckt_0_cpu.abc_12118_new_n370.
* NET  1307  core.real_chip.subckt_0_cpu.abc_12118_new_n369.
* NET  1308  core.real_chip.subckt_0_cpu.abc_12118_new_n368.
* NET  1309  core.real_chip.subckt_0_cpu.abc_12118_new_n367.
* NET  1310  core.real_chip.subckt_0_cpu.abc_12118_new_n366.
* NET  1311  core.real_chip.subckt_0_cpu.abc_12118_new_n365.
* NET  1312  core.real_chip.subckt_0_cpu.abc_12118_new_n364.
* NET  1313  core.real_chip.subckt_0_cpu.abc_12118_new_n363.
* NET  1314  core.real_chip.subckt_0_cpu.abc_12118_new_n362.
* NET  1315  core.real_chip.subckt_0_cpu.abc_12118_new_n361.
* NET  1316  core.real_chip.subckt_0_cpu.abc_12118_new_n360.
* NET  1317  core.real_chip.subckt_0_cpu.abc_12118_new_n359.
* NET  1318  core.real_chip.subckt_0_cpu.abc_12118_new_n358.
* NET  1319  core.real_chip.subckt_0_cpu.abc_12118_new_n357.
* NET  1320  core.real_chip.subckt_0_cpu.abc_12118_new_n356.
* NET  1321  core.real_chip.subckt_0_cpu.abc_12118_new_n355.
* NET  1322  core.real_chip.subckt_0_cpu.abc_12118_new_n354.
* NET  1323  core.real_chip.subckt_0_cpu.abc_12118_new_n353.
* NET  1324  core.real_chip.subckt_0_cpu.abc_12118_new_n352.
* NET  1325  core.real_chip.subckt_0_cpu.abc_12118_new_n351.
* NET  1326  core.real_chip.subckt_0_cpu.abc_12118_new_n350.
* NET  1327  core.real_chip.subckt_0_cpu.abc_12118_new_n349.
* NET  1328  core.real_chip.subckt_0_cpu.abc_12118_new_n348.
* NET  1329  core.real_chip.subckt_0_cpu.abc_12118_new_n347.
* NET  1330  core.real_chip.subckt_0_cpu.abc_12118_new_n346.
* NET  1331  core.real_chip.subckt_0_cpu.abc_12118_new_n345.
* NET  1332  core.real_chip.subckt_0_cpu.abc_12118_new_n344.
* NET  1333  core.real_chip.subckt_0_cpu.abc_12118_new_n343_hfns_2.
* NET  1334  core.real_chip.subckt_0_cpu.abc_12118_new_n343_hfns_1.
* NET  1335  core.real_chip.subckt_0_cpu.abc_12118_new_n343_hfns_0.
* NET  1336  core.real_chip.subckt_0_cpu.abc_12118_new_n343.
* NET  1337  core.real_chip.subckt_0_cpu.abc_12118_new_n342.
* NET  1338  core.real_chip.subckt_0_cpu.abc_12118_new_n341.
* NET  1339  core.real_chip.subckt_0_cpu.abc_12118_new_n340.
* NET  1340  core.real_chip.subckt_0_cpu.abc_12118_new_n339.
* NET  1341  core.real_chip.subckt_0_cpu.abc_12118_new_n338.
* NET  1342  core.real_chip.subckt_0_cpu.abc_12118_new_n337.
* NET  1343  core.real_chip.subckt_0_cpu.abc_12118_new_n336.
* NET  1344  core.real_chip.subckt_0_cpu.abc_12118_new_n335.
* NET  1345  core.real_chip.subckt_0_cpu.abc_12118_new_n1856.
* NET  1346  core.real_chip.subckt_0_cpu.abc_12118_new_n1855.
* NET  1347  core.real_chip.subckt_0_cpu.abc_12118_new_n1854.
* NET  1348  core.real_chip.subckt_0_cpu.abc_12118_new_n1853.
* NET  1349  core.real_chip.subckt_0_cpu.abc_12118_new_n1852.
* NET  1350  core.real_chip.subckt_0_cpu.abc_12118_new_n1851.
* NET  1351  core.real_chip.subckt_0_cpu.abc_12118_new_n1850.
* NET  1352  core.real_chip.subckt_0_cpu.abc_12118_new_n1849.
* NET  1353  core.real_chip.subckt_0_cpu.abc_12118_new_n1847.
* NET  1354  core.real_chip.subckt_0_cpu.abc_12118_new_n1846.
* NET  1355  core.real_chip.subckt_0_cpu.abc_12118_new_n1845.
* NET  1356  core.real_chip.subckt_0_cpu.abc_12118_new_n1844.
* NET  1357  core.real_chip.subckt_0_cpu.abc_12118_new_n1843.
* NET  1358  core.real_chip.subckt_0_cpu.abc_12118_new_n1842.
* NET  1359  core.real_chip.subckt_0_cpu.abc_12118_new_n1841.
* NET  1360  core.real_chip.subckt_0_cpu.abc_12118_new_n1840.
* NET  1361  core.real_chip.subckt_0_cpu.abc_12118_new_n1839.
* NET  1362  core.real_chip.subckt_0_cpu.abc_12118_new_n1838.
* NET  1363  core.real_chip.subckt_0_cpu.abc_12118_new_n1836.
* NET  1364  core.real_chip.subckt_0_cpu.abc_12118_new_n1835.
* NET  1365  core.real_chip.subckt_0_cpu.abc_12118_new_n1834.
* NET  1366  core.real_chip.subckt_0_cpu.abc_12118_new_n1833.
* NET  1367  core.real_chip.subckt_0_cpu.abc_12118_new_n1832.
* NET  1368  core.real_chip.subckt_0_cpu.abc_12118_new_n1831.
* NET  1369  core.real_chip.subckt_0_cpu.abc_12118_new_n1830.
* NET  1370  core.real_chip.subckt_0_cpu.abc_12118_new_n1829.
* NET  1371  core.real_chip.subckt_0_cpu.abc_12118_new_n1828.
* NET  1372  core.real_chip.subckt_0_cpu.abc_12118_new_n1826.
* NET  1373  core.real_chip.subckt_0_cpu.abc_12118_new_n1825.
* NET  1374  core.real_chip.subckt_0_cpu.abc_12118_new_n1824.
* NET  1375  core.real_chip.subckt_0_cpu.abc_12118_new_n1823.
* NET  1376  core.real_chip.subckt_0_cpu.abc_12118_new_n1822.
* NET  1377  core.real_chip.subckt_0_cpu.abc_12118_new_n1821.
* NET  1378  core.real_chip.subckt_0_cpu.abc_12118_new_n1820.
* NET  1379  core.real_chip.subckt_0_cpu.abc_12118_new_n1819.
* NET  1380  core.real_chip.subckt_0_cpu.abc_12118_new_n1818.
* NET  1381  core.real_chip.subckt_0_cpu.abc_12118_new_n1817.
* NET  1382  core.real_chip.subckt_0_cpu.abc_12118_new_n1816.
* NET  1383  core.real_chip.subckt_0_cpu.abc_12118_new_n1814.
* NET  1384  core.real_chip.subckt_0_cpu.abc_12118_new_n1813.
* NET  1385  core.real_chip.subckt_0_cpu.abc_12118_new_n1812.
* NET  1386  core.real_chip.subckt_0_cpu.abc_12118_new_n1811.
* NET  1387  core.real_chip.subckt_0_cpu.abc_12118_new_n1810.
* NET  1388  core.real_chip.subckt_0_cpu.abc_12118_new_n1809.
* NET  1389  core.real_chip.subckt_0_cpu.abc_12118_new_n1808.
* NET  1390  core.real_chip.subckt_0_cpu.abc_12118_new_n1807.
* NET  1391  core.real_chip.subckt_0_cpu.abc_12118_new_n1806.
* NET  1392  core.real_chip.subckt_0_cpu.abc_12118_new_n1805.
* NET  1393  core.real_chip.subckt_0_cpu.abc_12118_new_n1803.
* NET  1394  core.real_chip.subckt_0_cpu.abc_12118_new_n1802.
* NET  1395  core.real_chip.subckt_0_cpu.abc_12118_new_n1801.
* NET  1396  core.real_chip.subckt_0_cpu.abc_12118_new_n1800.
* NET  1397  core.real_chip.subckt_0_cpu.abc_12118_new_n1799.
* NET  1398  core.real_chip.subckt_0_cpu.abc_12118_new_n1798.
* NET  1399  core.real_chip.subckt_0_cpu.abc_12118_new_n1797.
* NET  1400  core.real_chip.subckt_0_cpu.abc_12118_new_n1796.
* NET  1401  core.real_chip.subckt_0_cpu.abc_12118_new_n1795.
* NET  1402  core.real_chip.subckt_0_cpu.abc_12118_new_n1793.
* NET  1403  core.real_chip.subckt_0_cpu.abc_12118_new_n1792.
* NET  1404  core.real_chip.subckt_0_cpu.abc_12118_new_n1791.
* NET  1405  core.real_chip.subckt_0_cpu.abc_12118_new_n1790.
* NET  1406  core.real_chip.subckt_0_cpu.abc_12118_new_n1789.
* NET  1407  core.real_chip.subckt_0_cpu.abc_12118_new_n1788.
* NET  1408  core.real_chip.subckt_0_cpu.abc_12118_new_n1787.
* NET  1409  core.real_chip.subckt_0_cpu.abc_12118_new_n1786.
* NET  1410  core.real_chip.subckt_0_cpu.abc_12118_new_n1785.
* NET  1411  core.real_chip.subckt_0_cpu.abc_12118_new_n1783.
* NET  1412  core.real_chip.subckt_0_cpu.abc_12118_new_n1782.
* NET  1413  core.real_chip.subckt_0_cpu.abc_12118_new_n1781.
* NET  1414  core.real_chip.subckt_0_cpu.abc_12118_new_n1780.
* NET  1415  core.real_chip.subckt_0_cpu.abc_12118_new_n1779.
* NET  1416  core.real_chip.subckt_0_cpu.abc_12118_new_n1778.
* NET  1417  core.real_chip.subckt_0_cpu.abc_12118_new_n1777.
* NET  1418  core.real_chip.subckt_0_cpu.abc_12118_new_n1776.
* NET  1419  core.real_chip.subckt_0_cpu.abc_12118_new_n1775.
* NET  1420  core.real_chip.subckt_0_cpu.abc_12118_new_n1773.
* NET  1421  core.real_chip.subckt_0_cpu.abc_12118_new_n1772.
* NET  1422  core.real_chip.subckt_0_cpu.abc_12118_new_n1771.
* NET  1423  core.real_chip.subckt_0_cpu.abc_12118_new_n1770.
* NET  1424  core.real_chip.subckt_0_cpu.abc_12118_new_n1769.
* NET  1425  core.real_chip.subckt_0_cpu.abc_12118_new_n1768.
* NET  1426  core.real_chip.subckt_0_cpu.abc_12118_new_n1767.
* NET  1427  core.real_chip.subckt_0_cpu.abc_12118_new_n1766.
* NET  1428  core.real_chip.subckt_0_cpu.abc_12118_new_n1765.
* NET  1429  core.real_chip.subckt_0_cpu.abc_12118_new_n1763.
* NET  1430  core.real_chip.subckt_0_cpu.abc_12118_new_n1762.
* NET  1431  core.real_chip.subckt_0_cpu.abc_12118_new_n1761.
* NET  1432  core.real_chip.subckt_0_cpu.abc_12118_new_n1760.
* NET  1433  core.real_chip.subckt_0_cpu.abc_12118_new_n1759.
* NET  1434  core.real_chip.subckt_0_cpu.abc_12118_new_n1758.
* NET  1435  core.real_chip.subckt_0_cpu.abc_12118_new_n1757.
* NET  1436  core.real_chip.subckt_0_cpu.abc_12118_new_n1756.
* NET  1437  core.real_chip.subckt_0_cpu.abc_12118_new_n1754.
* NET  1438  core.real_chip.subckt_0_cpu.abc_12118_new_n1753.
* NET  1439  core.real_chip.subckt_0_cpu.abc_12118_new_n1752.
* NET  1440  core.real_chip.subckt_0_cpu.abc_12118_new_n1751.
* NET  1441  core.real_chip.subckt_0_cpu.abc_12118_new_n1750.
* NET  1442  core.real_chip.subckt_0_cpu.abc_12118_new_n1749.
* NET  1443  core.real_chip.subckt_0_cpu.abc_12118_new_n1748.
* NET  1444  core.real_chip.subckt_0_cpu.abc_12118_new_n1747.
* NET  1445  core.real_chip.subckt_0_cpu.abc_12118_new_n1745.
* NET  1446  core.real_chip.subckt_0_cpu.abc_12118_new_n1744.
* NET  1447  core.real_chip.subckt_0_cpu.abc_12118_new_n1743.
* NET  1448  core.real_chip.subckt_0_cpu.abc_12118_new_n1742.
* NET  1449  core.real_chip.subckt_0_cpu.abc_12118_new_n1741.
* NET  1450  core.real_chip.subckt_0_cpu.abc_12118_new_n1740.
* NET  1451  core.real_chip.subckt_0_cpu.abc_12118_new_n1739.
* NET  1452  core.real_chip.subckt_0_cpu.abc_12118_new_n1738.
* NET  1453  core.real_chip.subckt_0_cpu.abc_12118_new_n1736.
* NET  1454  core.real_chip.subckt_0_cpu.abc_12118_new_n1735.
* NET  1455  core.real_chip.subckt_0_cpu.abc_12118_new_n1734.
* NET  1456  core.real_chip.subckt_0_cpu.abc_12118_new_n1733.
* NET  1457  core.real_chip.subckt_0_cpu.abc_12118_new_n1732.
* NET  1458  core.real_chip.subckt_0_cpu.abc_12118_new_n1731.
* NET  1459  core.real_chip.subckt_0_cpu.abc_12118_new_n1730.
* NET  1460  core.real_chip.subckt_0_cpu.abc_12118_new_n1729.
* NET  1461  core.real_chip.subckt_0_cpu.abc_12118_new_n1727.
* NET  1462  core.real_chip.subckt_0_cpu.abc_12118_new_n1726.
* NET  1463  core.real_chip.subckt_0_cpu.abc_12118_new_n1725.
* NET  1464  core.real_chip.subckt_0_cpu.abc_12118_new_n1724.
* NET  1465  core.real_chip.subckt_0_cpu.abc_12118_new_n1723.
* NET  1466  core.real_chip.subckt_0_cpu.abc_12118_new_n1722.
* NET  1467  core.real_chip.subckt_0_cpu.abc_12118_new_n1721.
* NET  1468  core.real_chip.subckt_0_cpu.abc_12118_new_n1720.
* NET  1469  core.real_chip.subckt_0_cpu.abc_12118_new_n1719.
* NET  1470  core.real_chip.subckt_0_cpu.abc_12118_new_n1718.
* NET  1471  core.real_chip.subckt_0_cpu.abc_12118_new_n1717.
* NET  1472  core.real_chip.subckt_0_cpu.abc_12118_new_n1715.
* NET  1473  core.real_chip.subckt_0_cpu.abc_12118_new_n1714.
* NET  1474  core.real_chip.subckt_0_cpu.abc_12118_new_n1713.
* NET  1475  core.real_chip.subckt_0_cpu.abc_12118_new_n1712.
* NET  1476  core.real_chip.subckt_0_cpu.abc_12118_new_n1711.
* NET  1477  core.real_chip.subckt_0_cpu.abc_12118_new_n1710.
* NET  1478  core.real_chip.subckt_0_cpu.abc_12118_new_n1709.
* NET  1479  core.real_chip.subckt_0_cpu.abc_12118_new_n1708.
* NET  1480  core.real_chip.subckt_0_cpu.abc_12118_new_n1706.
* NET  1481  core.real_chip.subckt_0_cpu.abc_12118_new_n1705.
* NET  1482  core.real_chip.subckt_0_cpu.abc_12118_new_n1704.
* NET  1483  core.real_chip.subckt_0_cpu.abc_12118_new_n1703.
* NET  1484  core.real_chip.subckt_0_cpu.abc_12118_new_n1702.
* NET  1485  core.real_chip.subckt_0_cpu.abc_12118_new_n1701.
* NET  1486  core.real_chip.subckt_0_cpu.abc_12118_new_n1700.
* NET  1487  core.real_chip.subckt_0_cpu.abc_12118_new_n1699.
* NET  1488  core.real_chip.subckt_0_cpu.abc_12118_new_n1698.
* NET  1489  core.real_chip.subckt_0_cpu.abc_12118_new_n1697.
* NET  1490  core.real_chip.subckt_0_cpu.abc_12118_new_n1696.
* NET  1491  core.real_chip.subckt_0_cpu.abc_12118_new_n1695.
* NET  1492  core.real_chip.subckt_0_cpu.abc_12118_new_n1694.
* NET  1493  core.real_chip.subckt_0_cpu.abc_12118_new_n1693.
* NET  1494  core.real_chip.subckt_0_cpu.abc_12118_new_n1692.
* NET  1495  core.real_chip.subckt_0_cpu.abc_12118_new_n1691.
* NET  1496  core.real_chip.subckt_0_cpu.abc_12118_new_n1690.
* NET  1497  core.real_chip.subckt_0_cpu.abc_12118_new_n1689.
* NET  1498  core.real_chip.subckt_0_cpu.abc_12118_new_n1688.
* NET  1499  core.real_chip.subckt_0_cpu.abc_12118_new_n1687.
* NET  1500  core.real_chip.subckt_0_cpu.abc_12118_new_n1686.
* NET  1501  core.real_chip.subckt_0_cpu.abc_12118_new_n1685.
* NET  1502  core.real_chip.subckt_0_cpu.abc_12118_new_n1684.
* NET  1503  core.real_chip.subckt_0_cpu.abc_12118_new_n1667.
* NET  1504  core.real_chip.subckt_0_cpu.abc_12118_new_n1666.
* NET  1505  core.real_chip.subckt_0_cpu.abc_12118_new_n1665.
* NET  1506  core.real_chip.subckt_0_cpu.abc_12118_new_n1664.
* NET  1507  core.real_chip.subckt_0_cpu.abc_12118_new_n1663.
* NET  1508  core.real_chip.subckt_0_cpu.abc_12118_new_n1662.
* NET  1509  core.real_chip.subckt_0_cpu.abc_12118_new_n1661.
* NET  1510  core.real_chip.subckt_0_cpu.abc_12118_new_n1660.
* NET  1511  core.real_chip.subckt_0_cpu.abc_12118_new_n1659.
* NET  1512  core.real_chip.subckt_0_cpu.abc_12118_new_n1658.
* NET  1513  core.real_chip.subckt_0_cpu.abc_12118_new_n1657.
* NET  1514  core.real_chip.subckt_0_cpu.abc_12118_new_n1656.
* NET  1515  core.real_chip.subckt_0_cpu.abc_12118_new_n1655.
* NET  1516  core.real_chip.subckt_0_cpu.abc_12118_new_n1654.
* NET  1517  core.real_chip.subckt_0_cpu.abc_12118_new_n1653.
* NET  1518  core.real_chip.subckt_0_cpu.abc_12118_new_n1652.
* NET  1519  core.real_chip.subckt_0_cpu.abc_12118_new_n1651.
* NET  1520  core.real_chip.subckt_0_cpu.abc_12118_new_n1650.
* NET  1521  core.real_chip.subckt_0_cpu.abc_12118_new_n1649.
* NET  1522  core.real_chip.subckt_0_cpu.abc_12118_new_n1648.
* NET  1523  core.real_chip.subckt_0_cpu.abc_12118_new_n1647.
* NET  1524  core.real_chip.subckt_0_cpu.abc_12118_new_n1646.
* NET  1525  core.real_chip.subckt_0_cpu.abc_12118_new_n1645.
* NET  1526  core.real_chip.subckt_0_cpu.abc_12118_new_n1644.
* NET  1527  core.real_chip.subckt_0_cpu.abc_12118_new_n1643.
* NET  1528  core.real_chip.subckt_0_cpu.abc_12118_new_n1642.
* NET  1529  core.real_chip.subckt_0_cpu.abc_12118_new_n1641.
* NET  1530  core.real_chip.subckt_0_cpu.abc_12118_new_n1640.
* NET  1531  core.real_chip.subckt_0_cpu.abc_12118_new_n1639.
* NET  1532  core.real_chip.subckt_0_cpu.abc_12118_new_n1638.
* NET  1533  core.real_chip.subckt_0_cpu.abc_12118_new_n1637.
* NET  1534  core.real_chip.subckt_0_cpu.abc_12118_new_n1636.
* NET  1535  core.real_chip.subckt_0_cpu.abc_12118_new_n1635.
* NET  1536  core.real_chip.subckt_0_cpu.abc_12118_new_n1634.
* NET  1537  core.real_chip.subckt_0_cpu.abc_12118_new_n1633.
* NET  1538  core.real_chip.subckt_0_cpu.abc_12118_new_n1632.
* NET  1539  core.real_chip.subckt_0_cpu.abc_12118_new_n1631.
* NET  1540  core.real_chip.subckt_0_cpu.abc_12118_new_n1628.
* NET  1541  core.real_chip.subckt_0_cpu.abc_12118_new_n1627.
* NET  1542  core.real_chip.subckt_0_cpu.abc_12118_new_n1626.
* NET  1543  core.real_chip.subckt_0_cpu.abc_12118_new_n1625.
* NET  1544  core.real_chip.subckt_0_cpu.abc_12118_new_n1624.
* NET  1545  core.real_chip.subckt_0_cpu.abc_12118_new_n1623.
* NET  1546  core.real_chip.subckt_0_cpu.abc_12118_new_n1622.
* NET  1547  core.real_chip.subckt_0_cpu.abc_12118_new_n1621.
* NET  1548  core.real_chip.subckt_0_cpu.abc_12118_new_n1620.
* NET  1549  core.real_chip.subckt_0_cpu.abc_12118_new_n1619.
* NET  1550  core.real_chip.subckt_0_cpu.abc_12118_new_n1618.
* NET  1551  core.real_chip.subckt_0_cpu.abc_12118_new_n1617.
* NET  1552  core.real_chip.subckt_0_cpu.abc_12118_new_n1616.
* NET  1553  core.real_chip.subckt_0_cpu.abc_12118_new_n1615.
* NET  1554  core.real_chip.subckt_0_cpu.abc_12118_new_n1613.
* NET  1555  core.real_chip.subckt_0_cpu.abc_12118_new_n1612.
* NET  1556  core.real_chip.subckt_0_cpu.abc_12118_new_n1611.
* NET  1557  core.real_chip.subckt_0_cpu.abc_12118_new_n1610.
* NET  1558  core.real_chip.subckt_0_cpu.abc_12118_new_n1609.
* NET  1559  core.real_chip.subckt_0_cpu.abc_12118_new_n1608.
* NET  1560  core.real_chip.subckt_0_cpu.abc_12118_new_n1607.
* NET  1561  core.real_chip.subckt_0_cpu.abc_12118_new_n1606.
* NET  1562  core.real_chip.subckt_0_cpu.abc_12118_new_n1605.
* NET  1563  core.real_chip.subckt_0_cpu.abc_12118_new_n1603.
* NET  1564  core.real_chip.subckt_0_cpu.abc_12118_new_n1602.
* NET  1565  core.real_chip.subckt_0_cpu.abc_12118_new_n1601.
* NET  1566  core.real_chip.subckt_0_cpu.abc_12118_new_n1600.
* NET  1567  core.real_chip.subckt_0_cpu.abc_12118_new_n1599.
* NET  1568  core.real_chip.subckt_0_cpu.abc_12118_new_n1598.
* NET  1569  core.real_chip.subckt_0_cpu.abc_12118_new_n1597.
* NET  1570  core.real_chip.subckt_0_cpu.abc_12118_new_n1596.
* NET  1571  core.real_chip.subckt_0_cpu.abc_12118_new_n1595.
* NET  1572  core.real_chip.subckt_0_cpu.abc_12118_new_n1594.
* NET  1573  core.real_chip.subckt_0_cpu.abc_12118_new_n1592.
* NET  1574  core.real_chip.subckt_0_cpu.abc_12118_new_n1591.
* NET  1575  core.real_chip.subckt_0_cpu.abc_12118_new_n1590.
* NET  1576  core.real_chip.subckt_0_cpu.abc_12118_new_n1589.
* NET  1577  core.real_chip.subckt_0_cpu.abc_12118_new_n1588.
* NET  1578  core.real_chip.subckt_0_cpu.abc_12118_new_n1586.
* NET  1579  core.real_chip.subckt_0_cpu.abc_12118_new_n1585.
* NET  1580  core.real_chip.subckt_0_cpu.abc_12118_new_n1584.
* NET  1581  core.real_chip.subckt_0_cpu.abc_12118_new_n1583.
* NET  1582  core.real_chip.subckt_0_cpu.abc_12118_new_n1582.
* NET  1583  core.real_chip.subckt_0_cpu.abc_12118_new_n1581.
* NET  1584  core.real_chip.subckt_0_cpu.abc_12118_new_n1580.
* NET  1585  core.real_chip.subckt_0_cpu.abc_12118_new_n1579.
* NET  1586  core.real_chip.subckt_0_cpu.abc_12118_new_n1578.
* NET  1587  core.real_chip.subckt_0_cpu.abc_12118_new_n1576.
* NET  1588  core.real_chip.subckt_0_cpu.abc_12118_new_n1575.
* NET  1589  core.real_chip.subckt_0_cpu.abc_12118_new_n1574.
* NET  1590  core.real_chip.subckt_0_cpu.abc_12118_new_n1573.
* NET  1591  core.real_chip.subckt_0_cpu.abc_12118_new_n1572.
* NET  1592  core.real_chip.subckt_0_cpu.abc_12118_new_n1571.
* NET  1593  core.real_chip.subckt_0_cpu.abc_12118_new_n1570.
* NET  1594  core.real_chip.subckt_0_cpu.abc_12118_new_n1569.
* NET  1595  core.real_chip.subckt_0_cpu.abc_12118_new_n1559.
* NET  1596  core.real_chip.subckt_0_cpu.abc_12118_new_n1558.
* NET  1597  core.real_chip.subckt_0_cpu.abc_12118_new_n1557.
* NET  1598  core.real_chip.subckt_0_cpu.abc_12118_new_n1555.
* NET  1599  core.real_chip.subckt_0_cpu.abc_12118_new_n1554.
* NET  1600  core.real_chip.subckt_0_cpu.abc_12118_new_n1553.
* NET  1601  core.real_chip.subckt_0_cpu.abc_12118_new_n1552.
* NET  1602  core.real_chip.subckt_0_cpu.abc_12118_new_n1551.
* NET  1603  core.real_chip.subckt_0_cpu.abc_12118_new_n1550.
* NET  1604  core.real_chip.subckt_0_cpu.abc_12118_new_n1549.
* NET  1605  core.real_chip.subckt_0_cpu.abc_12118_new_n1548.
* NET  1606  core.real_chip.subckt_0_cpu.abc_12118_new_n1547.
* NET  1607  core.real_chip.subckt_0_cpu.abc_12118_new_n1546.
* NET  1608  core.real_chip.subckt_0_cpu.abc_12118_new_n1545.
* NET  1609  core.real_chip.subckt_0_cpu.abc_12118_new_n1544.
* NET  1610  core.real_chip.subckt_0_cpu.abc_12118_new_n1541.
* NET  1611  core.real_chip.subckt_0_cpu.abc_12118_new_n1540.
* NET  1612  core.real_chip.subckt_0_cpu.abc_12118_new_n1539.
* NET  1613  core.real_chip.subckt_0_cpu.abc_12118_new_n1538.
* NET  1614  core.real_chip.subckt_0_cpu.abc_12118_new_n1537.
* NET  1615  core.real_chip.subckt_0_cpu.abc_12118_new_n1535.
* NET  1616  core.real_chip.subckt_0_cpu.abc_12118_new_n1534.
* NET  1617  core.real_chip.subckt_0_cpu.abc_12118_new_n1533.
* NET  1618  core.real_chip.subckt_0_cpu.abc_12118_new_n1532.
* NET  1619  core.real_chip.subckt_0_cpu.abc_12118_new_n1531.
* NET  1620  core.real_chip.subckt_0_cpu.abc_12118_new_n1529.
* NET  1621  core.real_chip.subckt_0_cpu.abc_12118_new_n1528.
* NET  1622  core.real_chip.subckt_0_cpu.abc_12118_new_n1527.
* NET  1623  core.real_chip.subckt_0_cpu.abc_12118_new_n1526.
* NET  1624  core.real_chip.subckt_0_cpu.abc_12118_new_n1525.
* NET  1625  core.real_chip.subckt_0_cpu.abc_12118_new_n1524.
* NET  1626  core.real_chip.subckt_0_cpu.abc_12118_new_n1522.
* NET  1627  core.real_chip.subckt_0_cpu.abc_12118_new_n1521.
* NET  1628  core.real_chip.subckt_0_cpu.abc_12118_new_n1520.
* NET  1629  core.real_chip.subckt_0_cpu.abc_12118_new_n1519.
* NET  1630  core.real_chip.subckt_0_cpu.abc_12118_new_n1518.
* NET  1631  core.real_chip.subckt_0_cpu.abc_12118_new_n1517.
* NET  1632  core.real_chip.subckt_0_cpu.abc_12118_new_n1516.
* NET  1633  core.real_chip.subckt_0_cpu.abc_12118_new_n1514.
* NET  1634  core.real_chip.subckt_0_cpu.abc_12118_new_n1513.
* NET  1635  core.real_chip.subckt_0_cpu.abc_12118_new_n1512.
* NET  1636  core.real_chip.subckt_0_cpu.abc_12118_new_n1511.
* NET  1637  core.real_chip.subckt_0_cpu.abc_12118_new_n1510.
* NET  1638  core.real_chip.subckt_0_cpu.abc_12118_new_n1508.
* NET  1639  core.real_chip.subckt_0_cpu.abc_12118_new_n1507.
* NET  1640  core.real_chip.subckt_0_cpu.abc_12118_new_n1506.
* NET  1641  core.real_chip.subckt_0_cpu.abc_12118_new_n1505.
* NET  1642  core.real_chip.subckt_0_cpu.abc_12118_new_n1504.
* NET  1643  core.real_chip.subckt_0_cpu.abc_12118_new_n1502.
* NET  1644  core.real_chip.subckt_0_cpu.abc_12118_new_n1499.
* NET  1645  core.real_chip.subckt_0_cpu.abc_12118_new_n1498.
* NET  1646  core.real_chip.subckt_0_cpu.abc_12118_new_n1497.
* NET  1647  core.real_chip.subckt_0_cpu.abc_12118_new_n1496.
* NET  1648  core.real_chip.subckt_0_cpu.abc_12118_new_n1495.
* NET  1649  core.real_chip.subckt_0_cpu.abc_12118_new_n1494.
* NET  1650  core.real_chip.subckt_0_cpu.abc_12118_new_n1491.
* NET  1651  core.real_chip.subckt_0_cpu.abc_12118_new_n1489.
* NET  1652  core.real_chip.subckt_0_cpu.abc_12118_new_n1488.
* NET  1653  core.real_chip.subckt_0_cpu.abc_12118_new_n1487.
* NET  1654  core.real_chip.subckt_0_cpu.abc_12118_new_n1486.
* NET  1655  core.real_chip.subckt_0_cpu.abc_12118_new_n1485.
* NET  1656  core.real_chip.subckt_0_cpu.abc_12118_new_n1484.
* NET  1657  core.real_chip.subckt_0_cpu.abc_12118_new_n1482.
* NET  1658  core.real_chip.subckt_0_cpu.abc_12118_new_n1481.
* NET  1659  core.real_chip.subckt_0_cpu.abc_12118_new_n1478.
* NET  1660  core.real_chip.subckt_0_cpu.abc_12118_new_n1477.
* NET  1661  core.real_chip.subckt_0_cpu.abc_12118_new_n1476.
* NET  1662  core.real_chip.subckt_0_cpu.abc_12118_new_n1475.
* NET  1663  core.real_chip.subckt_0_cpu.abc_12118_new_n1472.
* NET  1664  core.real_chip.subckt_0_cpu.abc_12118_new_n1471.
* NET  1665  core.real_chip.subckt_0_cpu.abc_12118_new_n1470.
* NET  1666  core.real_chip.subckt_0_cpu.abc_12118_new_n1469.
* NET  1667  core.real_chip.subckt_0_cpu.abc_12118_new_n1467.
* NET  1668  core.real_chip.subckt_0_cpu.abc_12118_new_n1466.
* NET  1669  core.real_chip.subckt_0_cpu.abc_12118_new_n1465.
* NET  1670  core.real_chip.subckt_0_cpu.abc_12118_new_n1464.
* NET  1671  core.real_chip.subckt_0_cpu.abc_12118_new_n1463.
* NET  1672  core.real_chip.subckt_0_cpu.abc_12118_new_n1462.
* NET  1673  core.real_chip.subckt_0_cpu.abc_12118_new_n1460.
* NET  1674  core.real_chip.subckt_0_cpu.abc_12118_new_n1459.
* NET  1675  core.real_chip.subckt_0_cpu.abc_12118_new_n1458.
* NET  1676  core.real_chip.subckt_0_cpu.abc_12118_new_n1457.
* NET  1677  core.real_chip.subckt_0_cpu.abc_12118_new_n1456.
* NET  1678  core.real_chip.subckt_0_cpu.abc_12118_new_n1455.
* NET  1679  core.real_chip.subckt_0_cpu.abc_12118_new_n1454.
* NET  1680  core.real_chip.subckt_0_cpu.abc_12118_new_n1453.
* NET  1681  core.real_chip.subckt_0_cpu.abc_12118_new_n1452.
* NET  1682  core.real_chip.subckt_0_cpu.abc_12118_new_n1451.
* NET  1683  core.real_chip.subckt_0_cpu.abc_12118_new_n1450.
* NET  1684  core.real_chip.subckt_0_cpu.abc_12118_new_n1449.
* NET  1685  core.real_chip.subckt_0_cpu.abc_12118_new_n1448.
* NET  1686  core.real_chip.subckt_0_cpu.abc_12118_new_n1447.
* NET  1687  core.real_chip.subckt_0_cpu.abc_12118_new_n1446.
* NET  1688  core.real_chip.subckt_0_cpu.abc_12118_new_n1445.
* NET  1689  core.real_chip.subckt_0_cpu.abc_12118_new_n1444.
* NET  1690  core.real_chip.subckt_0_cpu.abc_12118_new_n1443.
* NET  1691  core.real_chip.subckt_0_cpu.abc_12118_new_n1442.
* NET  1692  core.real_chip.subckt_0_cpu.abc_12118_new_n1441.
* NET  1693  core.real_chip.subckt_0_cpu.abc_12118_new_n1440.
* NET  1694  core.real_chip.subckt_0_cpu.abc_12118_new_n1439.
* NET  1695  core.real_chip.subckt_0_cpu.abc_12118_new_n1437.
* NET  1696  core.real_chip.subckt_0_cpu.abc_12118_new_n1435.
* NET  1697  core.real_chip.subckt_0_cpu.abc_12118_new_n1434.
* NET  1698  core.real_chip.subckt_0_cpu.abc_12118_new_n1433.
* NET  1699  core.real_chip.subckt_0_cpu.abc_12118_new_n1432.
* NET  1700  core.real_chip.subckt_0_cpu.abc_12118_new_n1431.
* NET  1701  core.real_chip.subckt_0_cpu.abc_12118_new_n1429.
* NET  1702  core.real_chip.subckt_0_cpu.abc_12118_new_n1428.
* NET  1703  core.real_chip.subckt_0_cpu.abc_12118_new_n1426.
* NET  1704  core.real_chip.subckt_0_cpu.abc_12118_new_n1425.
* NET  1705  core.real_chip.subckt_0_cpu.abc_12118_new_n1423.
* NET  1706  core.real_chip.subckt_0_cpu.abc_12118_new_n1422.
* NET  1707  core.real_chip.subckt_0_cpu.abc_12118_new_n1420.
* NET  1708  core.real_chip.subckt_0_cpu.abc_12118_new_n1419.
* NET  1709  core.real_chip.subckt_0_cpu.abc_12118_new_n1418.
* NET  1710  core.real_chip.subckt_0_cpu.abc_12118_new_n1416.
* NET  1711  core.real_chip.subckt_0_cpu.abc_12118_new_n1415.
* NET  1712  core.real_chip.subckt_0_cpu.abc_12118_new_n1414.
* NET  1713  core.real_chip.subckt_0_cpu.abc_12118_new_n1412.
* NET  1714  core.real_chip.subckt_0_cpu.abc_12118_new_n1411.
* NET  1715  core.real_chip.subckt_0_cpu.abc_12118_new_n1410.
* NET  1716  core.real_chip.subckt_0_cpu.abc_12118_new_n1408.
* NET  1717  core.real_chip.subckt_0_cpu.abc_12118_new_n1407.
* NET  1718  core.real_chip.subckt_0_cpu.abc_12118_new_n1405.
* NET  1719  core.real_chip.subckt_0_cpu.abc_12118_new_n1404.
* NET  1720  core.real_chip.subckt_0_cpu.abc_12118_new_n1399.
* NET  1721  core.real_chip.subckt_0_cpu.abc_12118_new_n1390.
* NET  1722  core.real_chip.subckt_0_cpu.abc_12118_new_n1381.
* NET  1723  core.real_chip.subckt_0_cpu.abc_12118_new_n1372.
* NET  1724  core.real_chip.subckt_0_cpu.abc_12118_new_n1370.
* NET  1725  core.real_chip.subckt_0_cpu.abc_12118_new_n1369.
* NET  1726  core.real_chip.subckt_0_cpu.abc_12118_new_n1368.
* NET  1727  core.real_chip.subckt_0_cpu.abc_12118_new_n1367.
* NET  1728  core.real_chip.subckt_0_cpu.abc_12118_new_n1365.
* NET  1729  core.real_chip.subckt_0_cpu.abc_12118_new_n1364.
* NET  1730  core.real_chip.subckt_0_cpu.abc_12118_new_n1363.
* NET  1731  core.real_chip.subckt_0_cpu.abc_12118_new_n1362.
* NET  1732  core.real_chip.subckt_0_cpu.abc_12118_new_n1361.
* NET  1733  core.real_chip.subckt_0_cpu.abc_12118_new_n1359.
* NET  1734  core.real_chip.subckt_0_cpu.abc_12118_new_n1358.
* NET  1735  core.real_chip.subckt_0_cpu.abc_12118_new_n1357.
* NET  1736  core.real_chip.subckt_0_cpu.abc_12118_new_n1356.
* NET  1737  core.real_chip.subckt_0_cpu.abc_12118_new_n1355.
* NET  1738  core.real_chip.subckt_0_cpu.abc_12118_new_n1354.
* NET  1739  core.real_chip.subckt_0_cpu.abc_12118_new_n1353.
* NET  1740  core.real_chip.subckt_0_cpu.abc_12118_new_n1352.
* NET  1741  core.real_chip.subckt_0_cpu.abc_12118_new_n1351.
* NET  1742  core.real_chip.subckt_0_cpu.abc_12118_new_n1349.
* NET  1743  core.real_chip.subckt_0_cpu.abc_12118_new_n1347.
* NET  1744  core.real_chip.subckt_0_cpu.abc_12118_new_n1346.
* NET  1745  core.real_chip.subckt_0_cpu.abc_12118_new_n1345.
* NET  1746  core.real_chip.subckt_0_cpu.abc_12118_new_n1344.
* NET  1747  core.real_chip.subckt_0_cpu.abc_12118_new_n1342.
* NET  1748  core.real_chip.subckt_0_cpu.abc_12118_new_n1341.
* NET  1749  core.real_chip.subckt_0_cpu.abc_12118_new_n1340.
* NET  1750  core.real_chip.subckt_0_cpu.abc_12118_new_n1339.
* NET  1751  core.real_chip.subckt_0_cpu.abc_12118_new_n1338.
* NET  1752  core.real_chip.subckt_0_cpu.abc_12118_new_n1336.
* NET  1753  core.real_chip.subckt_0_cpu.abc_12118_new_n1335.
* NET  1754  core.real_chip.subckt_0_cpu.abc_12118_new_n1334.
* NET  1755  core.real_chip.subckt_0_cpu.abc_12118_new_n1333.
* NET  1756  core.real_chip.subckt_0_cpu.abc_12118_new_n1332.
* NET  1757  core.real_chip.subckt_0_cpu.abc_12118_new_n1331.
* NET  1758  core.real_chip.subckt_0_cpu.abc_12118_new_n1330.
* NET  1759  core.real_chip.subckt_0_cpu.abc_12118_new_n1329.
* NET  1760  core.real_chip.subckt_0_cpu.abc_12118_new_n1328.
* NET  1761  core.real_chip.subckt_0_cpu.abc_12118_new_n1326.
* NET  1762  core.real_chip.subckt_0_cpu.abc_12118_new_n1325.
* NET  1763  core.real_chip.subckt_0_cpu.abc_12118_new_n1324.
* NET  1764  core.real_chip.subckt_0_cpu.abc_12118_new_n1323.
* NET  1765  core.real_chip.subckt_0_cpu.abc_12118_new_n1322.
* NET  1766  core.real_chip.subckt_0_cpu.abc_12118_new_n1321.
* NET  1767  core.real_chip.subckt_0_cpu.abc_12118_new_n1320.
* NET  1768  core.real_chip.subckt_0_cpu.abc_12118_new_n1319.
* NET  1769  core.real_chip.subckt_0_cpu.abc_12118_new_n1314.
* NET  1770  core.real_chip.subckt_0_cpu.abc_12118_new_n1313.
* NET  1771  core.real_chip.subckt_0_cpu.abc_12118_new_n1312.
* NET  1772  core.real_chip.subckt_0_cpu.abc_12118_new_n1311.
* NET  1773  core.real_chip.subckt_0_cpu.abc_12118_new_n1310.
* NET  1774  core.real_chip.subckt_0_cpu.abc_12118_new_n1308.
* NET  1775  core.real_chip.subckt_0_cpu.abc_12118_new_n1307.
* NET  1776  core.real_chip.subckt_0_cpu.abc_12118_new_n1306.
* NET  1777  core.real_chip.subckt_0_cpu.abc_12118_new_n1305.
* NET  1778  core.real_chip.subckt_0_cpu.abc_12118_new_n1303.
* NET  1779  core.real_chip.subckt_0_cpu.abc_12118_new_n1302.
* NET  1780  core.real_chip.subckt_0_cpu.abc_12118_new_n1301.
* NET  1781  core.real_chip.subckt_0_cpu.abc_12118_new_n1300.
* NET  1782  core.real_chip.subckt_0_cpu.abc_12118_new_n1298.
* NET  1783  core.real_chip.subckt_0_cpu.abc_12118_new_n1297.
* NET  1784  core.real_chip.subckt_0_cpu.abc_12118_new_n1296.
* NET  1785  core.real_chip.subckt_0_cpu.abc_12118_new_n1295.
* NET  1786  core.real_chip.subckt_0_cpu.abc_12118_new_n1294.
* NET  1787  core.real_chip.subckt_0_cpu.abc_12118_new_n1292.
* NET  1788  core.real_chip.subckt_0_cpu.abc_12118_new_n1291.
* NET  1789  core.real_chip.subckt_0_cpu.abc_12118_new_n1290.
* NET  1790  core.real_chip.subckt_0_cpu.abc_12118_new_n1289.
* NET  1791  core.real_chip.subckt_0_cpu.abc_12118_new_n1288.
* NET  1792  core.real_chip.subckt_0_cpu.abc_12118_new_n1286.
* NET  1793  core.real_chip.subckt_0_cpu.abc_12118_new_n1285.
* NET  1794  core.real_chip.subckt_0_cpu.abc_12118_new_n1284.
* NET  1795  core.real_chip.subckt_0_cpu.abc_12118_new_n1283.
* NET  1796  core.real_chip.subckt_0_cpu.abc_12118_new_n1281.
* NET  1797  core.real_chip.subckt_0_cpu.abc_12118_new_n1280.
* NET  1798  core.real_chip.subckt_0_cpu.abc_12118_new_n1279.
* NET  1799  core.real_chip.subckt_0_cpu.abc_12118_new_n1278.
* NET  1800  core.real_chip.subckt_0_cpu.abc_12118_new_n1276.
* NET  1801  core.real_chip.subckt_0_cpu.abc_12118_new_n1275.
* NET  1802  core.real_chip.subckt_0_cpu.abc_12118_new_n1274.
* NET  1803  core.real_chip.subckt_0_cpu.abc_12118_new_n1273.
* NET  1804  core.real_chip.subckt_0_cpu.abc_12118_new_n1272.
* NET  1805  core.real_chip.subckt_0_cpu.abc_12118_new_n1271.
* NET  1806  core.real_chip.subckt_0_cpu.abc_12118_new_n1269.
* NET  1807  core.real_chip.subckt_0_cpu.abc_12118_new_n1268.
* NET  1808  core.real_chip.subckt_0_cpu.abc_12118_new_n1267.
* NET  1809  core.real_chip.subckt_0_cpu.abc_12118_new_n1266.
* NET  1810  core.real_chip.subckt_0_cpu.abc_12118_new_n1265.
* NET  1811  core.real_chip.subckt_0_cpu.abc_12118_new_n1264.
* NET  1812  core.real_chip.subckt_0_cpu.abc_12118_new_n1263.
* NET  1813  core.real_chip.subckt_0_cpu.abc_12118_new_n1261.
* NET  1814  core.real_chip.subckt_0_cpu.abc_12118_new_n1260.
* NET  1815  core.real_chip.subckt_0_cpu.abc_12118_new_n1259.
* NET  1816  core.real_chip.subckt_0_cpu.abc_12118_new_n1258.
* NET  1817  core.real_chip.subckt_0_cpu.abc_12118_new_n1257.
* NET  1818  core.real_chip.subckt_0_cpu.abc_12118_new_n1256.
* NET  1819  core.real_chip.subckt_0_cpu.abc_12118_new_n1255.
* NET  1820  core.real_chip.subckt_0_cpu.abc_12118_new_n1253.
* NET  1821  core.real_chip.subckt_0_cpu.abc_12118_new_n1252.
* NET  1822  core.real_chip.subckt_0_cpu.abc_12118_new_n1251.
* NET  1823  core.real_chip.subckt_0_cpu.abc_12118_new_n1250.
* NET  1824  core.real_chip.subckt_0_cpu.abc_12118_new_n1249.
* NET  1825  core.real_chip.subckt_0_cpu.abc_12118_new_n1248.
* NET  1826  core.real_chip.subckt_0_cpu.abc_12118_new_n1247.
* NET  1827  core.real_chip.subckt_0_cpu.abc_12118_new_n1245.
* NET  1828  core.real_chip.subckt_0_cpu.abc_12118_new_n1244.
* NET  1829  core.real_chip.subckt_0_cpu.abc_12118_new_n1243.
* NET  1830  core.real_chip.subckt_0_cpu.abc_12118_new_n1242.
* NET  1831  core.real_chip.subckt_0_cpu.abc_12118_new_n1241.
* NET  1832  core.real_chip.subckt_0_cpu.abc_12118_new_n1240.
* NET  1833  core.real_chip.subckt_0_cpu.abc_12118_new_n1239.
* NET  1834  core.real_chip.subckt_0_cpu.abc_12118_new_n1237.
* NET  1835  core.real_chip.subckt_0_cpu.abc_12118_new_n1236.
* NET  1836  core.real_chip.subckt_0_cpu.abc_12118_new_n1235.
* NET  1837  core.real_chip.subckt_0_cpu.abc_12118_new_n1234.
* NET  1838  core.real_chip.subckt_0_cpu.abc_12118_new_n1233.
* NET  1839  core.real_chip.subckt_0_cpu.abc_12118_new_n1232.
* NET  1840  core.real_chip.subckt_0_cpu.abc_12118_new_n1230.
* NET  1841  core.real_chip.subckt_0_cpu.abc_12118_new_n1229.
* NET  1842  core.real_chip.subckt_0_cpu.abc_12118_new_n1228.
* NET  1843  core.real_chip.subckt_0_cpu.abc_12118_new_n1227.
* NET  1844  core.real_chip.subckt_0_cpu.abc_12118_new_n1226.
* NET  1845  core.real_chip.subckt_0_cpu.abc_12118_new_n1225.
* NET  1846  core.real_chip.subckt_0_cpu.abc_12118_new_n1224.
* NET  1847  core.real_chip.subckt_0_cpu.abc_12118_new_n1222.
* NET  1848  core.real_chip.subckt_0_cpu.abc_12118_new_n1221.
* NET  1849  core.real_chip.subckt_0_cpu.abc_12118_new_n1220.
* NET  1850  core.real_chip.subckt_0_cpu.abc_12118_new_n1219.
* NET  1851  core.real_chip.subckt_0_cpu.abc_12118_new_n1218.
* NET  1852  core.real_chip.subckt_0_cpu.abc_12118_new_n1217.
* NET  1853  core.real_chip.subckt_0_cpu.abc_12118_new_n1216.
* NET  1854  core.real_chip.subckt_0_cpu.abc_12118_new_n1214.
* NET  1855  core.real_chip.subckt_0_cpu.abc_12118_new_n1213.
* NET  1856  core.real_chip.subckt_0_cpu.abc_12118_new_n1212.
* NET  1857  core.real_chip.subckt_0_cpu.abc_12118_new_n1211.
* NET  1858  core.real_chip.subckt_0_cpu.abc_12118_new_n1210.
* NET  1859  core.real_chip.subckt_0_cpu.abc_12118_new_n1209.
* NET  1860  core.real_chip.subckt_0_cpu.abc_12118_new_n1208.
* NET  1861  core.real_chip.subckt_0_cpu.abc_12118_new_n1207.
* NET  1862  core.real_chip.subckt_0_cpu.abc_12118_new_n1206.
* NET  1863  core.real_chip.subckt_0_cpu.abc_12118_new_n1205.
* NET  1864  core.real_chip.subckt_0_cpu.abc_12118_new_n1204.
* NET  1865  core.real_chip.subckt_0_cpu.abc_12118_new_n1203.
* NET  1866  core.real_chip.subckt_0_cpu.abc_12118_new_n1202.
* NET  1867  core.real_chip.subckt_0_cpu.abc_12118_new_n1201.
* NET  1868  core.real_chip.subckt_0_cpu.abc_12118_new_n1200.
* NET  1869  core.real_chip.subckt_0_cpu.abc_12118_new_n1199.
* NET  1870  core.real_chip.subckt_0_cpu.abc_12118_new_n1198.
* NET  1871  core.real_chip.subckt_0_cpu.abc_12118_new_n1197.
* NET  1872  core.real_chip.subckt_0_cpu.abc_12118_new_n1196.
* NET  1873  core.real_chip.subckt_0_cpu.abc_12118_new_n1195_hfns_2.
* NET  1874  core.real_chip.subckt_0_cpu.abc_12118_new_n1195_hfns_1.
* NET  1875  core.real_chip.subckt_0_cpu.abc_12118_new_n1195_hfns_0.
* NET  1876  core.real_chip.subckt_0_cpu.abc_12118_new_n1195.
* NET  1877  core.real_chip.subckt_0_cpu.abc_12118_new_n1194.
* NET  1878  core.real_chip.subckt_0_cpu.abc_12118_new_n1193.
* NET  1879  core.real_chip.subckt_0_cpu.abc_12118_new_n1192.
* NET  1880  core.real_chip.subckt_0_cpu.abc_12118_new_n1191.
* NET  1881  core.real_chip.subckt_0_cpu.abc_12118_new_n1190.
* NET  1882  core.real_chip.subckt_0_cpu.abc_12118_new_n1189.
* NET  1883  core.real_chip.subckt_0_cpu.abc_12118_new_n1188.
* NET  1884  core.real_chip.subckt_0_cpu.abc_12118_new_n1186.
* NET  1885  core.real_chip.subckt_0_cpu.abc_12118_new_n1185.
* NET  1886  core.real_chip.subckt_0_cpu.abc_12118_new_n1184.
* NET  1887  core.real_chip.subckt_0_cpu.abc_12118_new_n1183.
* NET  1888  core.real_chip.subckt_0_cpu.abc_12118_new_n1182.
* NET  1889  core.real_chip.subckt_0_cpu.abc_12118_new_n1181.
* NET  1890  core.real_chip.subckt_0_cpu.abc_12118_new_n1179.
* NET  1891  core.real_chip.subckt_0_cpu.abc_12118_new_n1178.
* NET  1892  core.real_chip.subckt_0_cpu.abc_12118_new_n1177.
* NET  1893  core.real_chip.subckt_0_cpu.abc_12118_new_n1176.
* NET  1894  core.real_chip.subckt_0_cpu.abc_12118_new_n1175.
* NET  1895  core.real_chip.subckt_0_cpu.abc_12118_new_n1174.
* NET  1896  core.real_chip.subckt_0_cpu.abc_12118_new_n1172.
* NET  1897  core.real_chip.subckt_0_cpu.abc_12118_new_n1171.
* NET  1898  core.real_chip.subckt_0_cpu.abc_12118_new_n1170.
* NET  1899  core.real_chip.subckt_0_cpu.abc_12118_new_n1169.
* NET  1900  core.real_chip.subckt_0_cpu.abc_12118_new_n1168.
* NET  1901  core.real_chip.subckt_0_cpu.abc_12118_new_n1166.
* NET  1902  core.real_chip.subckt_0_cpu.abc_12118_new_n1165.
* NET  1903  core.real_chip.subckt_0_cpu.abc_12118_new_n1164.
* NET  1904  core.real_chip.subckt_0_cpu.abc_12118_new_n1163.
* NET  1905  core.real_chip.subckt_0_cpu.abc_12118_new_n1162.
* NET  1906  core.real_chip.subckt_0_cpu.abc_12118_new_n1161.
* NET  1907  core.real_chip.subckt_0_cpu.abc_12118_new_n1160.
* NET  1908  core.real_chip.subckt_0_cpu.abc_12118_new_n1158.
* NET  1909  core.real_chip.subckt_0_cpu.abc_12118_new_n1157.
* NET  1910  core.real_chip.subckt_0_cpu.abc_12118_new_n1156.
* NET  1911  core.real_chip.subckt_0_cpu.abc_12118_new_n1155.
* NET  1912  core.real_chip.subckt_0_cpu.abc_12118_new_n1154.
* NET  1913  core.real_chip.subckt_0_cpu.abc_12118_new_n1153.
* NET  1914  core.real_chip.subckt_0_cpu.abc_12118_new_n1151.
* NET  1915  core.real_chip.subckt_0_cpu.abc_12118_new_n1150.
* NET  1916  core.real_chip.subckt_0_cpu.abc_12118_new_n1149.
* NET  1917  core.real_chip.subckt_0_cpu.abc_12118_new_n1148.
* NET  1918  core.real_chip.subckt_0_cpu.abc_12118_new_n1147.
* NET  1919  core.real_chip.subckt_0_cpu.abc_12118_new_n1146.
* NET  1920  core.real_chip.subckt_0_cpu.abc_12118_new_n1144.
* NET  1921  core.real_chip.subckt_0_cpu.abc_12118_new_n1143.
* NET  1922  core.real_chip.subckt_0_cpu.abc_12118_new_n1142.
* NET  1923  core.real_chip.subckt_0_cpu.abc_12118_new_n1141.
* NET  1924  core.real_chip.subckt_0_cpu.abc_12118_new_n1140.
* NET  1925  core.real_chip.subckt_0_cpu.abc_12118_new_n1139.
* NET  1926  core.real_chip.subckt_0_cpu.abc_12118_new_n1137.
* NET  1927  core.real_chip.subckt_0_cpu.abc_12118_new_n1136.
* NET  1928  core.real_chip.subckt_0_cpu.abc_12118_new_n1135.
* NET  1929  core.real_chip.subckt_0_cpu.abc_12118_new_n1134.
* NET  1930  core.real_chip.subckt_0_cpu.abc_12118_new_n1133.
* NET  1931  core.real_chip.subckt_0_cpu.abc_12118_new_n1132.
* NET  1932  core.real_chip.subckt_0_cpu.abc_12118_new_n1131.
* NET  1933  core.real_chip.subckt_0_cpu.abc_12118_new_n1130.
* NET  1934  core.real_chip.subckt_0_cpu.abc_12118_new_n1129.
* NET  1935  core.real_chip.subckt_0_cpu.abc_12118_new_n1128.
* NET  1936  core.real_chip.subckt_0_cpu.abc_12118_new_n1127.
* NET  1937  core.real_chip.subckt_0_cpu.abc_12118_new_n1125.
* NET  1938  core.real_chip.subckt_0_cpu.abc_12118_new_n1124.
* NET  1939  core.real_chip.subckt_0_cpu.abc_12118_new_n1123.
* NET  1940  core.real_chip.subckt_0_cpu.abc_12118_new_n1122.
* NET  1941  core.real_chip.subckt_0_cpu.abc_12118_new_n1121.
* NET  1942  core.real_chip.subckt_0_cpu.abc_12118_new_n1118.
* NET  1943  core.real_chip.subckt_0_cpu.abc_12118_new_n1117.
* NET  1944  core.real_chip.subckt_0_cpu.abc_12118_new_n1116.
* NET  1945  core.real_chip.subckt_0_cpu.abc_12118_new_n1114.
* NET  1946  core.real_chip.subckt_0_cpu.abc_12118_new_n1112.
* NET  1947  core.real_chip.subckt_0_cpu.abc_12118_new_n1111.
* NET  1948  core.real_chip.subckt_0_cpu.abc_12118_new_n1110.
* NET  1949  core.real_chip.subckt_0_cpu.abc_12118_new_n1108.
* NET  1950  core.real_chip.subckt_0_cpu.abc_12118_new_n1107.
* NET  1951  core.real_chip.subckt_0_cpu.abc_12118_new_n1106.
* NET  1952  core.real_chip.subckt_0_cpu.abc_12118_new_n1105.
* NET  1953  core.real_chip.subckt_0_cpu.abc_12118_new_n1104.
* NET  1954  core.real_chip.subckt_0_cpu.abc_12118_new_n1103.
* NET  1955  core.real_chip.subckt_0_cpu.abc_12118_new_n1102.
* NET  1956  core.real_chip.subckt_0_cpu.abc_12118_new_n1101.
* NET  1957  core.real_chip.subckt_0_cpu.abc_12118_new_n1100.
* NET  1958  core.real_chip.subckt_0_cpu.abc_12118_new_n1099.
* NET  1959  core.real_chip.subckt_0_cpu.abc_12118_new_n1098.
* NET  1960  core.real_chip.subckt_0_cpu.abc_12118_new_n1096.
* NET  1961  core.real_chip.subckt_0_cpu.abc_12118_new_n1095.
* NET  1962  core.real_chip.subckt_0_cpu.abc_12118_new_n1094.
* NET  1963  core.real_chip.subckt_0_cpu.abc_12118_new_n1093.
* NET  1964  core.real_chip.subckt_0_cpu.abc_12118_new_n1092.
* NET  1965  core.real_chip.subckt_0_cpu.abc_12118_new_n1091.
* NET  1966  core.real_chip.subckt_0_cpu.abc_12118_new_n1090.
* NET  1967  core.real_chip.subckt_0_cpu.abc_12118_new_n1089.
* NET  1968  core.real_chip.subckt_0_cpu.abc_12118_new_n1088.
* NET  1969  core.real_chip.subckt_0_cpu.abc_12118_new_n1087.
* NET  1970  core.real_chip.subckt_0_cpu.abc_12118_new_n1086.
* NET  1971  core.real_chip.subckt_0_cpu.abc_12118_new_n1084.
* NET  1972  core.real_chip.subckt_0_cpu.abc_12118_new_n1083.
* NET  1973  core.real_chip.subckt_0_cpu.abc_12118_new_n1082.
* NET  1974  core.real_chip.subckt_0_cpu.abc_12118_new_n1081.
* NET  1975  core.real_chip.subckt_0_cpu.abc_12118_new_n1080.
* NET  1976  core.real_chip.subckt_0_cpu.abc_12118_new_n1079.
* NET  1977  core.real_chip.subckt_0_cpu.abc_12118_new_n1078.
* NET  1978  core.real_chip.subckt_0_cpu.abc_12118_new_n1077.
* NET  1979  core.real_chip.subckt_0_cpu.abc_12118_new_n1076.
* NET  1980  core.real_chip.subckt_0_cpu.abc_12118_new_n1075.
* NET  1981  core.real_chip.subckt_0_cpu.abc_12118_new_n1074.
* NET  1982  core.real_chip.subckt_0_cpu.abc_12118_new_n1073.
* NET  1983  core.real_chip.subckt_0_cpu.abc_12118_new_n1071.
* NET  1984  core.real_chip.subckt_0_cpu.abc_12118_new_n1070.
* NET  1985  core.real_chip.subckt_0_cpu.abc_12118_new_n1069.
* NET  1986  core.real_chip.subckt_0_cpu.abc_12118_new_n1068.
* NET  1987  core.real_chip.subckt_0_cpu.abc_12118_new_n1067.
* NET  1988  core.real_chip.subckt_0_cpu.abc_12118_new_n1066.
* NET  1989  core.real_chip.subckt_0_cpu.abc_12118_new_n1065.
* NET  1990  core.real_chip.subckt_0_cpu.abc_12118_new_n1064.
* NET  1991  core.real_chip.subckt_0_cpu.abc_12118_new_n1063.
* NET  1992  core.real_chip.subckt_0_cpu.abc_12118_new_n1062.
* NET  1993  core.real_chip.subckt_0_cpu.abc_12118_new_n1061.
* NET  1994  core.real_chip.subckt_0_cpu.abc_12118_new_n1059.
* NET  1995  core.real_chip.subckt_0_cpu.abc_12118_new_n1058.
* NET  1996  core.real_chip.subckt_0_cpu.abc_12118_new_n1057.
* NET  1997  core.real_chip.subckt_0_cpu.abc_12118_new_n1056.
* NET  1998  core.real_chip.subckt_0_cpu.abc_12118_new_n1055.
* NET  1999  core.real_chip.subckt_0_cpu.abc_12118_new_n1054.
* NET  2000  core.real_chip.subckt_0_cpu.abc_12118_new_n1053.
* NET  2001  core.real_chip.subckt_0_cpu.abc_12118_new_n1052.
* NET  2002  core.real_chip.subckt_0_cpu.abc_12118_new_n1051.
* NET  2003  core.real_chip.subckt_0_cpu.abc_12118_new_n1050.
* NET  2004  core.real_chip.subckt_0_cpu.abc_12118_new_n1049.
* NET  2005  core.real_chip.subckt_0_cpu.abc_12118_new_n1047.
* NET  2006  core.real_chip.subckt_0_cpu.abc_12118_new_n1046.
* NET  2007  core.real_chip.subckt_0_cpu.abc_12118_new_n1045.
* NET  2008  core.real_chip.subckt_0_cpu.abc_12118_new_n1044.
* NET  2009  core.real_chip.subckt_0_cpu.abc_12118_new_n1043.
* NET  2010  core.real_chip.subckt_0_cpu.abc_12118_new_n1042.
* NET  2011  core.real_chip.subckt_0_cpu.abc_12118_new_n1041.
* NET  2012  core.real_chip.subckt_0_cpu.abc_12118_new_n1040.
* NET  2013  core.real_chip.subckt_0_cpu.abc_12118_new_n1039.
* NET  2014  core.real_chip.subckt_0_cpu.abc_12118_new_n1038.
* NET  2015  core.real_chip.subckt_0_cpu.abc_12118_new_n1037.
* NET  2016  core.real_chip.subckt_0_cpu.abc_12118_new_n1036.
* NET  2017  core.real_chip.subckt_0_cpu.abc_12118_new_n1034.
* NET  2018  core.real_chip.subckt_0_cpu.abc_12118_new_n1033.
* NET  2019  core.real_chip.subckt_0_cpu.abc_12118_new_n1032.
* NET  2020  core.real_chip.subckt_0_cpu.abc_12118_new_n1031.
* NET  2021  core.real_chip.subckt_0_cpu.abc_12118_new_n1030.
* NET  2022  core.real_chip.subckt_0_cpu.abc_12118_new_n1029.
* NET  2023  core.real_chip.subckt_0_cpu.abc_12118_new_n1028.
* NET  2024  core.real_chip.subckt_0_cpu.abc_12118_new_n1027.
* NET  2025  core.real_chip.subckt_0_cpu.abc_12118_new_n1026.
* NET  2026  core.real_chip.subckt_0_cpu.abc_12118_new_n1025.
* NET  2027  core.real_chip.subckt_0_cpu.abc_12118_new_n1024.
* NET  2028  core.real_chip.subckt_0_cpu.abc_12118_new_n1023.
* NET  2029  core.real_chip.subckt_0_cpu.abc_12118_new_n1021.
* NET  2030  core.real_chip.subckt_0_cpu.abc_12118_new_n1020.
* NET  2031  core.real_chip.subckt_0_cpu.abc_12118_new_n1019.
* NET  2032  core.real_chip.subckt_0_cpu.abc_12118_new_n1018.
* NET  2033  core.real_chip.subckt_0_cpu.abc_12118_new_n1017.
* NET  2034  core.real_chip.subckt_0_cpu.abc_12118_new_n1016.
* NET  2035  core.real_chip.subckt_0_cpu.abc_12118_new_n1015.
* NET  2036  core.real_chip.subckt_0_cpu.abc_12118_new_n1014.
* NET  2037  core.real_chip.subckt_0_cpu.abc_12118_new_n1013.
* NET  2038  core.real_chip.subckt_0_cpu.abc_12118_new_n1012.
* NET  2039  core.real_chip.subckt_0_cpu.abc_12118_new_n1011.
* NET  2040  core.real_chip.subckt_0_cpu.abc_12118_new_n1010.
* NET  2041  core.real_chip.subckt_0_cpu.abc_12118_new_n1009.
* NET  2042  core.real_chip.subckt_0_cpu.abc_12118_new_n1008.
* NET  2043  core.real_chip.subckt_0_cpu.abc_12118_new_n1007.
* NET  2044  core.real_chip.subckt_0_cpu.abc_12118_new_n1006.
* NET  2045  core.real_chip.subckt_0_cpu.abc_12118_new_n1005.
* NET  2046  core.real_chip.subckt_0_cpu.abc_12118_new_n1004.
* NET  2047  core.real_chip.subckt_0_cpu.abc_12118_new_n1003.
* NET  2048  core.real_chip.subckt_0_cpu.abc_12118_new_n1002.
* NET  2049  core.real_chip.subckt_0_cpu.abc_12118_new_n1001.
* NET  2050  core.real_chip.subckt_0_cpu.abc_12118_new_n1000.
* NET  2051  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11881.
* NET  2052  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11879.
* NET  2053  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11877.
* NET  2054  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11875.
* NET  2055  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11873.
* NET  2056  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11871.
* NET  2057  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11869.
* NET  2058  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11867.
* NET  2059  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11865.
* NET  2060  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11863.
* NET  2061  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11861.
* NET  2062  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11859.
* NET  2063  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11857.
* NET  2064  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11855.
* NET  2065  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11853.
* NET  2066  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11851.
* NET  2067  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11849.
* NET  2068  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11847.
* NET  2069  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11845.
* NET  2070  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11843.
* NET  2071  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11841.
* NET  2072  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11839.
* NET  2073  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11837.
* NET  2074  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11835.
* NET  2075  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11833.
* NET  2076  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11831.
* NET  2077  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11829.
* NET  2078  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11827.
* NET  2079  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11825.
* NET  2080  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11823.
* NET  2081  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11821.
* NET  2082  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11819.
* NET  2083  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11817.
* NET  2084  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11815.
* NET  2085  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11813.
* NET  2086  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11811.
* NET  2087  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11809.
* NET  2088  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11807.
* NET  2089  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11803.
* NET  2090  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11801.
* NET  2091  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11799.
* NET  2092  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11797.
* NET  2093  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11795.
* NET  2094  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11793.
* NET  2095  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11791.
* NET  2096  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11789.
* NET  2097  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11787.
* NET  2098  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11785.
* NET  2099  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11781.
* NET  2100  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11779.
* NET  2101  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11775.
* NET  2102  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11773.
* NET  2103  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11771.
* NET  2104  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11769.
* NET  2105  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11767.
* NET  2106  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11765.
* NET  2107  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11763.
* NET  2108  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11761.
* NET  2109  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11759.
* NET  2110  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11757.
* NET  2111  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11755.
* NET  2112  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11753.
* NET  2113  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11749.
* NET  2114  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11747.
* NET  2115  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11745.
* NET  2116  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11743.
* NET  2117  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11741.
* NET  2118  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11739.
* NET  2119  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11737.
* NET  2120  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11735.
* NET  2121  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11733.
* NET  2122  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11731.
* NET  2123  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11729.
* NET  2124  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11727.
* NET  2125  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11725.
* NET  2126  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11723.
* NET  2127  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11721.
* NET  2128  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11719.
* NET  2129  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11717.
* NET  2130  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11715.
* NET  2131  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11713.
* NET  2132  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11711.
* NET  2133  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11709.
* NET  2134  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11705.
* NET  2135  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11703.
* NET  2136  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11701.
* NET  2137  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11699.
* NET  2138  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11697.
* NET  2139  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11695.
* NET  2140  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11693.
* NET  2141  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11691.
* NET  2142  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11689.
* NET  2143  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11687.
* NET  2144  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11685.
* NET  2145  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11683.
* NET  2146  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11681.
* NET  2147  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11679.
* NET  2148  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11677.
* NET  2149  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11675.
* NET  2150  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11673.
* NET  2151  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11671.
* NET  2152  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11669.
* NET  2153  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11667.
* NET  2154  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11665.
* NET  2155  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11663.
* NET  2156  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11661.
* NET  2157  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11659.
* NET  2158  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11657.
* NET  2159  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11655.
* NET  2160  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11653.
* NET  2161  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11651.
* NET  2162  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11649.
* NET  2163  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11647.
* NET  2164  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11645.
* NET  2165  core.real_chip.subckt_0_cpu.abc_12118_auto_rtlil_cc_2515_muxgate_11643.
* NET  2166  core.real_chip.subckt_0_cpu.abc_12118_abc_9840_and_cpu_syncreset_v_575_83_y.
* NET  2167  core.one_37.
* NET  2168  core.one_36.
* NET  2169  core.one_35.
* NET  2170  core.one_34.
* NET  2171  core.one_33.
* NET  2172  core.one_32.
* NET  2173  core.one_31.
* NET  2174  core.one_30.
* NET  2175  blockagenet.

xspare_buffer_40 0 1 136 140 buf_x4
xspare_buffer_41 0 1 135 140 buf_x4
xspare_buffer_42 0 1 134 140 buf_x4
xspare_buffer_43 0 1 90 92 buf_x4
xspare_buffer_44 0 1 133 140 buf_x4
xspare_buffer_45 0 1 132 140 buf_x4
xspare_buffer_46 0 1 131 140 buf_x4
xspare_buffer_47 0 1 89 92 buf_x4
xspare_buffer_48 0 1 130 140 buf_x4
xspare_buffer_49 0 1 129 140 buf_x4
xspare_feed_60 0 1 decap_w0
xspare_feed_61 0 1 decap_w0
xspare_feed_62 0 1 decap_w0
xspare_feed_63 0 1 decap_w0
xspare_feed_64 0 1 decap_w0
xspare_feed_65 0 1 decap_w0
xspare_feed_66 0 1 decap_w0
xspare_feed_67 0 1 decap_w0
xspare_feed_68 0 1 decap_w0
xspare_feed_69 0 1 decap_w0
xspare_buffer_50 0 1 128 140 buf_x4
xspare_buffer_51 0 1 88 92 buf_x4
xspare_buffer_52 0 1 126 127 buf_x4
xspare_buffer_53 0 1 125 127 buf_x4
xspare_buffer_54 0 1 124 127 buf_x4
xspare_buffer_55 0 1 86 87 buf_x4
xspare_buffer_56 0 1 123 127 buf_x4
xspare_buffer_57 0 1 122 127 buf_x4
xspare_buffer_58 0 1 121 127 buf_x4
xspare_buffer_59 0 1 85 87 buf_x4
xspare_feed_70 0 1 decap_w0
xspare_feed_71 0 1 decap_w0
xspare_feed_72 0 1 decap_w0
xspare_feed_73 0 1 decap_w0
xspare_feed_74 0 1 decap_w0
xspare_feed_75 0 1 decap_w0
xspare_feed_76 0 1 decap_w0
xspare_feed_77 0 1 decap_w0
xspare_feed_78 0 1 decap_w0
xspare_feed_79 0 1 decap_w0
xspare_feed_89 0 1 tie
xspare_feed_88 0 1 tie
xspare_feed_87 0 1 decap_w0
xspare_feed_86 0 1 tie
xspare_feed_85 0 1 tie
xspare_feed_84 0 1 decap_w0
xspare_feed_83 0 1 decap_w0
xspare_feed_82 0 1 decap_w0
xspare_feed_81 0 1 decap_w0
xspare_feed_80 0 1 decap_w0
xspare_buffer_60 0 1 120 127 buf_x4
xspare_buffer_61 0 1 119 127 buf_x4
xspare_buffer_62 0 1 118 127 buf_x4
xspare_buffer_63 0 1 84 87 buf_x4
xspare_buffer_64 0 1 117 127 buf_x4
xspare_buffer_65 0 1 116 127 buf_x4
xspare_buffer_66 0 1 115 127 buf_x4
xspare_buffer_67 0 1 83 87 buf_x4
xspare_buffer_68 0 1 113 114 buf_x4
xspare_buffer_69 0 1 112 114 buf_x4
xspare_feed_99 0 1 decap_w0
xspare_feed_98 0 1 tie
xspare_feed_97 0 1 tie
xspare_feed_96 0 1 decap_w0
xspare_feed_95 0 1 tie
xspare_feed_94 0 1 tie
xspare_feed_93 0 1 decap_w0
xspare_feed_92 0 1 tie
xspare_feed_91 0 1 tie
xspare_feed_90 0 1 decap_w0
xspare_buffer_70 0 1 111 114 buf_x4
xspare_buffer_71 0 1 81 82 buf_x4
xspare_buffer_72 0 1 110 114 buf_x4
xspare_buffer_73 0 1 109 114 buf_x4
xspare_buffer_74 0 1 108 114 buf_x4
xspare_buffer_75 0 1 80 82 buf_x4
xspare_buffer_76 0 1 107 114 buf_x4
xspare_buffer_77 0 1 106 114 buf_x4
xspare_buffer_78 0 1 105 114 buf_x4
xspare_buffer_79 0 1 79 82 buf_x4
xspare_buffer_83 0 1 78 82 buf_x4
xspare_buffer_82 0 1 102 114 buf_x4
xspare_buffer_81 0 1 103 114 buf_x4
xspare_buffer_80 0 1 104 114 buf_x4
xspare_buffer_8 0 1 140 154 buf_x4
xspare_buffer_7 0 1 97 98 buf_x4
xspare_buffer_0 0 1 154 192 buf_x4
xspare_buffer_3 0 1 98 171 buf_x4
xspare_buffer_4 0 1 153 154 buf_x4
xspare_feed_10 0 1 decap_w0
xspare_feed_11 0 1 decap_w0
xspare_feed_12 0 1 decap_w0
xspare_feed_13 0 1 decap_w0
xspare_feed_14 0 1 decap_w0
xspare_feed_15 0 1 decap_w0
xspare_feed_16 0 1 decap_w0
xspare_feed_17 0 1 decap_w0
xspare_feed_18 0 1 decap_w0
xspare_feed_19 0 1 decap_w0
xspare_feed_20 0 1 decap_w0
xspare_feed_29 0 1 decap_w0
xspare_feed_28 0 1 decap_w0
xspare_feed_27 0 1 decap_w0
xspare_feed_26 0 1 decap_w0
xspare_feed_25 0 1 decap_w0
xspare_feed_24 0 1 decap_w0
xspare_feed_23 0 1 decap_w0
xspare_feed_22 0 1 decap_w0
xspare_feed_21 0 1 decap_w0
xspare_feed_9 0 1 decap_w0
xspare_feed_8 0 1 decap_w0
xspare_feed_7 0 1 decap_w0
xspare_feed_6 0 1 decap_w0
xspare_feed_5 0 1 decap_w0
xcore 0 1 2 3 4 5 6 7 8 9 10 11 12 13 14 15 16 17 18 19 20 21 22 23 24 25 26 27 28 29 30 31 32 33 34 35 36 37 38 39 40 41 42 43 44 45 46 47 48 49 50 51 52 53 54 55 56 57 58 59 60 61 62 63 64 65 66 67 68 69 70 71 72 73 74 75 76 77 83 84 86 94 99 100 101 104 107 110 117 120 126 130 133 136 139 143 146 149 152 155 156 157 158 159 160 161 162 163 164 165 166 167 168 169 170 171 172 173 174 175 176 177 178 179 180 181 182 183 184 185 186 187 188 189 190 191 192 273 274 275 276 464 465 466 467 468 469 470 471 472 473 474 475 476 478 479 481 519 520 521 522 616 617 618 620 1006 1007 1008 1009 1081 1082 1083 1084 1104 1105 1106 1107 1108 1136 1137 1138 1139 1157 1158 1159 1160 1204 1205 1206 1207 1210 1211 1212 1213 1220 1221 1222 1223 1225 1226 1227 1228 1229 1230 1231 1232 1233 1234 1235 1236 1238 1239 1240 1241 1242 1243 1271 1272 1273 1274 1333 1334 1335 1336 1873 1874 1875 1876 arlet6502_harness_cts
xspare_feed_0 0 1 decap_w0
xspare_feed_1 0 1 decap_w0
xspare_feed_2 0 1 decap_w0
xspare_feed_3 0 1 decap_w0
xspare_feed_4 0 1 decap_w0
xspare_buffer_11 0 1 92 98 buf_x4
xspare_buffer_12 0 1 127 154 buf_x4
xspare_buffer_15 0 1 87 98 buf_x4
xspare_buffer_16 0 1 114 154 buf_x4
xspare_buffer_19 0 1 82 98 buf_x4
xspare_feed_39 0 1 decap_w0
xspare_feed_38 0 1 decap_w0
xspare_feed_37 0 1 decap_w0
xspare_feed_36 0 1 decap_w0
xspare_feed_35 0 1 decap_w0
xspare_feed_34 0 1 decap_w0
xspare_feed_33 0 1 decap_w0
xspare_feed_32 0 1 decap_w0
xspare_feed_31 0 1 decap_w0
xspare_feed_30 0 1 decap_w0
xspare_buffer_29 0 1 145 153 buf_x4
xspare_buffer_28 0 1 146 153 buf_x4
xspare_buffer_27 0 1 95 97 buf_x4
xspare_buffer_26 0 1 147 153 buf_x4
xspare_buffer_25 0 1 148 153 buf_x4
xspare_buffer_24 0 1 149 153 buf_x4
xspare_buffer_23 0 1 96 97 buf_x4
xspare_buffer_22 0 1 150 153 buf_x4
xspare_buffer_21 0 1 151 153 buf_x4
xspare_buffer_20 0 1 152 153 buf_x4
xspare_feed_109 0 1 tie
xspare_feed_108 0 1 decap_w0
xspare_feed_107 0 1 tie
xspare_feed_106 0 1 tie
xspare_feed_105 0 1 decap_w0
xspare_feed_104 0 1 tie
xspare_feed_103 0 1 tie
xspare_feed_102 0 1 decap_w0
xspare_feed_101 0 1 tie
xspare_feed_100 0 1 tie
xspare_feed_40 0 1 decap_w0
xspare_feed_41 0 1 decap_w0
xspare_feed_42 0 1 decap_w0
xspare_feed_43 0 1 decap_w0
xspare_feed_44 0 1 decap_w0
xspare_feed_45 0 1 decap_w0
xspare_feed_46 0 1 decap_w0
xspare_feed_47 0 1 decap_w0
xspare_feed_48 0 1 decap_w0
xspare_feed_49 0 1 decap_w0
xspare_buffer_37 0 1 138 140 buf_x4
xspare_buffer_36 0 1 139 140 buf_x4
xspare_buffer_35 0 1 93 97 buf_x4
xspare_buffer_34 0 1 141 153 buf_x4
xspare_buffer_33 0 1 142 153 buf_x4
xspare_buffer_32 0 1 143 153 buf_x4
xspare_buffer_31 0 1 94 97 buf_x4
xspare_buffer_30 0 1 144 153 buf_x4
xspare_feed_113 0 1 tie
xspare_feed_112 0 1 tie
xspare_feed_111 0 1 decap_w0
xspare_feed_110 0 1 tie
xspare_buffer_39 0 1 91 92 buf_x4
xspare_buffer_38 0 1 137 140 buf_x4
xspare_feed_50 0 1 decap_w0
xspare_feed_51 0 1 decap_w0
xspare_feed_52 0 1 decap_w0
xspare_feed_53 0 1 decap_w0
xspare_feed_54 0 1 decap_w0
xspare_feed_55 0 1 decap_w0
xspare_feed_56 0 1 decap_w0
xspare_feed_57 0 1 decap_w0
xspare_feed_58 0 1 decap_w0
xspare_feed_59 0 1 decap_w0
.ends corona_cts
