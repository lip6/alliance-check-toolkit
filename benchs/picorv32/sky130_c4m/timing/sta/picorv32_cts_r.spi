.include /users/cao/mariem/coriolis-2.x/src/alliance-check-toolkit/pdkmaster/C4M.Sky130/libs.ref/StdCellLib/spice/StdCellLib.spi
* Coriolis Structural SPICE Driver
* Generated on Apr 22, 2024, 14:01
* Cell/Subckt "picorv32_cts_r".
*
* INTERF vss
* INTERF vdd
* INTERF trap
* INTERF trace_valid
* INTERF trace_data[9]
* INTERF trace_data[8]
* INTERF trace_data[7]
* INTERF trace_data[6]
* INTERF trace_data[5]
* INTERF trace_data[4]
* INTERF trace_data[35]
* INTERF trace_data[34]
* INTERF trace_data[33]
* INTERF trace_data[32]
* INTERF trace_data[31]
* INTERF trace_data[30]
* INTERF trace_data[3]
* INTERF trace_data[29]
* INTERF trace_data[28]
* INTERF trace_data[27]
* INTERF trace_data[26]
* INTERF trace_data[25]
* INTERF trace_data[24]
* INTERF trace_data[23]
* INTERF trace_data[22]
* INTERF trace_data[21]
* INTERF trace_data[20]
* INTERF trace_data[2]
* INTERF trace_data[19]
* INTERF trace_data[18]
* INTERF trace_data[17]
* INTERF trace_data[16]
* INTERF trace_data[15]
* INTERF trace_data[14]
* INTERF trace_data[13]
* INTERF trace_data[12]
* INTERF trace_data[11]
* INTERF trace_data[10]
* INTERF trace_data[1]
* INTERF trace_data[0]
* INTERF resetn
* INTERF pcpi_wr
* INTERF pcpi_wait
* INTERF pcpi_valid
* INTERF pcpi_rs2[9]
* INTERF pcpi_rs2[8]
* INTERF pcpi_rs2[31]
* INTERF pcpi_rs2[30]
* INTERF pcpi_rs2[29]
* INTERF pcpi_rs2[28]
* INTERF pcpi_rs2[27]
* INTERF pcpi_rs2[26]
* INTERF pcpi_rs2[25]
* INTERF pcpi_rs2[24]
* INTERF pcpi_rs2[23]
* INTERF pcpi_rs2[22]
* INTERF pcpi_rs2[21]
* INTERF pcpi_rs2[20]
* INTERF pcpi_rs2[19]
* INTERF pcpi_rs2[18]
* INTERF pcpi_rs2[17]
* INTERF pcpi_rs2[16]
* INTERF pcpi_rs2[15]
* INTERF pcpi_rs2[14]
* INTERF pcpi_rs2[13]
* INTERF pcpi_rs2[12]
* INTERF pcpi_rs2[11]
* INTERF pcpi_rs2[10]
* INTERF pcpi_rs1[9]
* INTERF pcpi_rs1[8]
* INTERF pcpi_rs1[7]
* INTERF pcpi_rs1[6]
* INTERF pcpi_rs1[5]
* INTERF pcpi_rs1[4]
* INTERF pcpi_rs1[31]
* INTERF pcpi_rs1[30]
* INTERF pcpi_rs1[3]
* INTERF pcpi_rs1[29]
* INTERF pcpi_rs1[28]
* INTERF pcpi_rs1[27]
* INTERF pcpi_rs1[26]
* INTERF pcpi_rs1[25]
* INTERF pcpi_rs1[24]
* INTERF pcpi_rs1[23]
* INTERF pcpi_rs1[22]
* INTERF pcpi_rs1[21]
* INTERF pcpi_rs1[20]
* INTERF pcpi_rs1[2]
* INTERF pcpi_rs1[19]
* INTERF pcpi_rs1[18]
* INTERF pcpi_rs1[17]
* INTERF pcpi_rs1[16]
* INTERF pcpi_rs1[15]
* INTERF pcpi_rs1[14]
* INTERF pcpi_rs1[13]
* INTERF pcpi_rs1[12]
* INTERF pcpi_rs1[11]
* INTERF pcpi_rs1[10]
* INTERF pcpi_rs1[1]
* INTERF pcpi_rs1[0]
* INTERF pcpi_ready
* INTERF pcpi_rd[9]
* INTERF pcpi_rd[8]
* INTERF pcpi_rd[7]
* INTERF pcpi_rd[6]
* INTERF pcpi_rd[5]
* INTERF pcpi_rd[4]
* INTERF pcpi_rd[31]
* INTERF pcpi_rd[30]
* INTERF pcpi_rd[3]
* INTERF pcpi_rd[29]
* INTERF pcpi_rd[28]
* INTERF pcpi_rd[27]
* INTERF pcpi_rd[26]
* INTERF pcpi_rd[25]
* INTERF pcpi_rd[24]
* INTERF pcpi_rd[23]
* INTERF pcpi_rd[22]
* INTERF pcpi_rd[21]
* INTERF pcpi_rd[20]
* INTERF pcpi_rd[2]
* INTERF pcpi_rd[19]
* INTERF pcpi_rd[18]
* INTERF pcpi_rd[17]
* INTERF pcpi_rd[16]
* INTERF pcpi_rd[15]
* INTERF pcpi_rd[14]
* INTERF pcpi_rd[13]
* INTERF pcpi_rd[12]
* INTERF pcpi_rd[11]
* INTERF pcpi_rd[10]
* INTERF pcpi_rd[1]
* INTERF pcpi_rd[0]
* INTERF pcpi_insn[9]
* INTERF pcpi_insn[8]
* INTERF pcpi_insn[7]
* INTERF pcpi_insn[6]
* INTERF pcpi_insn[5]
* INTERF pcpi_insn[4]
* INTERF pcpi_insn[31]
* INTERF pcpi_insn[30]
* INTERF pcpi_insn[3]
* INTERF pcpi_insn[29]
* INTERF pcpi_insn[28]
* INTERF pcpi_insn[27]
* INTERF pcpi_insn[26]
* INTERF pcpi_insn[25]
* INTERF pcpi_insn[24]
* INTERF pcpi_insn[23]
* INTERF pcpi_insn[22]
* INTERF pcpi_insn[21]
* INTERF pcpi_insn[20]
* INTERF pcpi_insn[2]
* INTERF pcpi_insn[19]
* INTERF pcpi_insn[18]
* INTERF pcpi_insn[17]
* INTERF pcpi_insn[16]
* INTERF pcpi_insn[15]
* INTERF pcpi_insn[14]
* INTERF pcpi_insn[13]
* INTERF pcpi_insn[12]
* INTERF pcpi_insn[11]
* INTERF pcpi_insn[10]
* INTERF pcpi_insn[1]
* INTERF pcpi_insn[0]
* INTERF mem_wstrb[3]
* INTERF mem_wstrb[2]
* INTERF mem_wstrb[1]
* INTERF mem_wstrb[0]
* INTERF mem_wdata[9]
* INTERF mem_wdata[8]
* INTERF mem_wdata[7]
* INTERF mem_wdata[6]
* INTERF mem_wdata[5]
* INTERF mem_wdata[4]
* INTERF mem_wdata[31]
* INTERF mem_wdata[30]
* INTERF mem_wdata[3]
* INTERF mem_wdata[29]
* INTERF mem_wdata[28]
* INTERF mem_wdata[27]
* INTERF mem_wdata[26]
* INTERF mem_wdata[25]
* INTERF mem_wdata[24]
* INTERF mem_wdata[23]
* INTERF mem_wdata[22]
* INTERF mem_wdata[21]
* INTERF mem_wdata[20]
* INTERF mem_wdata[2]
* INTERF mem_wdata[19]
* INTERF mem_wdata[18]
* INTERF mem_wdata[17]
* INTERF mem_wdata[16]
* INTERF mem_wdata[15]
* INTERF mem_wdata[14]
* INTERF mem_wdata[13]
* INTERF mem_wdata[12]
* INTERF mem_wdata[11]
* INTERF mem_wdata[10]
* INTERF mem_wdata[1]
* INTERF mem_wdata[0]
* INTERF mem_valid
* INTERF mem_ready
* INTERF mem_rdata[9]
* INTERF mem_rdata[8]
* INTERF mem_rdata[7]
* INTERF mem_rdata[6]
* INTERF mem_rdata[5]
* INTERF mem_rdata[4]
* INTERF mem_rdata[31]
* INTERF mem_rdata[30]
* INTERF mem_rdata[3]
* INTERF mem_rdata[29]
* INTERF mem_rdata[28]
* INTERF mem_rdata[27]
* INTERF mem_rdata[26]
* INTERF mem_rdata[25]
* INTERF mem_rdata[24]
* INTERF mem_rdata[23]
* INTERF mem_rdata[22]
* INTERF mem_rdata[21]
* INTERF mem_rdata[20]
* INTERF mem_rdata[2]
* INTERF mem_rdata[19]
* INTERF mem_rdata[18]
* INTERF mem_rdata[17]
* INTERF mem_rdata[16]
* INTERF mem_rdata[15]
* INTERF mem_rdata[14]
* INTERF mem_rdata[13]
* INTERF mem_rdata[12]
* INTERF mem_rdata[11]
* INTERF mem_rdata[10]
* INTERF mem_rdata[1]
* INTERF mem_rdata[0]
* INTERF mem_la_wstrb[3]
* INTERF mem_la_wstrb[2]
* INTERF mem_la_wstrb[1]
* INTERF mem_la_wstrb[0]
* INTERF mem_la_write
* INTERF mem_la_wdata[9]
* INTERF mem_la_wdata[8]
* INTERF mem_la_wdata[7]
* INTERF mem_la_wdata[6]
* INTERF mem_la_wdata[5]
* INTERF mem_la_wdata[4]
* INTERF mem_la_wdata[31]
* INTERF mem_la_wdata[30]
* INTERF mem_la_wdata[3]
* INTERF mem_la_wdata[29]
* INTERF mem_la_wdata[28]
* INTERF mem_la_wdata[27]
* INTERF mem_la_wdata[26]
* INTERF mem_la_wdata[25]
* INTERF mem_la_wdata[24]
* INTERF mem_la_wdata[23]
* INTERF mem_la_wdata[22]
* INTERF mem_la_wdata[21]
* INTERF mem_la_wdata[20]
* INTERF mem_la_wdata[2]
* INTERF mem_la_wdata[19]
* INTERF mem_la_wdata[18]
* INTERF mem_la_wdata[17]
* INTERF mem_la_wdata[16]
* INTERF mem_la_wdata[15]
* INTERF mem_la_wdata[14]
* INTERF mem_la_wdata[13]
* INTERF mem_la_wdata[12]
* INTERF mem_la_wdata[11]
* INTERF mem_la_wdata[10]
* INTERF mem_la_wdata[1]
* INTERF mem_la_wdata[0]
* INTERF mem_la_read
* INTERF mem_la_addr[9]
* INTERF mem_la_addr[8]
* INTERF mem_la_addr[7]
* INTERF mem_la_addr[6]
* INTERF mem_la_addr[5]
* INTERF mem_la_addr[4]
* INTERF mem_la_addr[31]
* INTERF mem_la_addr[30]
* INTERF mem_la_addr[3]
* INTERF mem_la_addr[29]
* INTERF mem_la_addr[28]
* INTERF mem_la_addr[27]
* INTERF mem_la_addr[26]
* INTERF mem_la_addr[25]
* INTERF mem_la_addr[24]
* INTERF mem_la_addr[23]
* INTERF mem_la_addr[22]
* INTERF mem_la_addr[21]
* INTERF mem_la_addr[20]
* INTERF mem_la_addr[2]
* INTERF mem_la_addr[19]
* INTERF mem_la_addr[18]
* INTERF mem_la_addr[17]
* INTERF mem_la_addr[16]
* INTERF mem_la_addr[15]
* INTERF mem_la_addr[14]
* INTERF mem_la_addr[13]
* INTERF mem_la_addr[12]
* INTERF mem_la_addr[11]
* INTERF mem_la_addr[10]
* INTERF mem_la_addr[1]
* INTERF mem_la_addr[0]
* INTERF mem_instr
* INTERF mem_addr[9]
* INTERF mem_addr[8]
* INTERF mem_addr[7]
* INTERF mem_addr[6]
* INTERF mem_addr[5]
* INTERF mem_addr[4]
* INTERF mem_addr[31]
* INTERF mem_addr[30]
* INTERF mem_addr[3]
* INTERF mem_addr[29]
* INTERF mem_addr[28]
* INTERF mem_addr[27]
* INTERF mem_addr[26]
* INTERF mem_addr[25]
* INTERF mem_addr[24]
* INTERF mem_addr[23]
* INTERF mem_addr[22]
* INTERF mem_addr[21]
* INTERF mem_addr[20]
* INTERF mem_addr[2]
* INTERF mem_addr[19]
* INTERF mem_addr[18]
* INTERF mem_addr[17]
* INTERF mem_addr[16]
* INTERF mem_addr[15]
* INTERF mem_addr[14]
* INTERF mem_addr[13]
* INTERF mem_addr[12]
* INTERF mem_addr[11]
* INTERF mem_addr[10]
* INTERF mem_addr[1]
* INTERF mem_addr[0]
* INTERF irq[9]
* INTERF irq[8]
* INTERF irq[7]
* INTERF irq[6]
* INTERF irq[5]
* INTERF irq[4]
* INTERF irq[31]
* INTERF irq[30]
* INTERF irq[3]
* INTERF irq[29]
* INTERF irq[28]
* INTERF irq[27]
* INTERF irq[26]
* INTERF irq[25]
* INTERF irq[24]
* INTERF irq[23]
* INTERF irq[22]
* INTERF irq[21]
* INTERF irq[20]
* INTERF irq[2]
* INTERF irq[19]
* INTERF irq[18]
* INTERF irq[17]
* INTERF irq[16]
* INTERF irq[15]
* INTERF irq[14]
* INTERF irq[13]
* INTERF irq[12]
* INTERF irq[11]
* INTERF irq[10]
* INTERF irq[1]
* INTERF irq[0]
* INTERF eoi[9]
* INTERF eoi[8]
* INTERF eoi[7]
* INTERF eoi[6]
* INTERF eoi[5]
* INTERF eoi[4]
* INTERF eoi[31]
* INTERF eoi[30]
* INTERF eoi[3]
* INTERF eoi[29]
* INTERF eoi[28]
* INTERF eoi[27]
* INTERF eoi[26]
* INTERF eoi[25]
* INTERF eoi[24]
* INTERF eoi[23]
* INTERF eoi[22]
* INTERF eoi[21]
* INTERF eoi[20]
* INTERF eoi[2]
* INTERF eoi[19]
* INTERF eoi[18]
* INTERF eoi[17]
* INTERF eoi[16]
* INTERF eoi[15]
* INTERF eoi[14]
* INTERF eoi[13]
* INTERF eoi[12]
* INTERF eoi[11]
* INTERF eoi[10]
* INTERF eoi[1]
* INTERF eoi[0]
* INTERF clk

* Terminal models (aka standard cells) used througout all the hierarchy.
*.include tie.spi
*.include decap_w0.spi
*.include buf_x4.spi
*.include nor4_x0.spi
*.include o2_x2.spi
*.include nand2_x0.spi
*.include a2_x2.spi
*.include oa22_x2.spi
*.include nand3_x0.spi
*.include mx2_x2.spi
*.include sff1_x4.spi
*.include ao22_x2.spi
*.include a3_x2.spi
*.include nxr2_x1.spi
*.include nor3_x0.spi
*.include xr2_x1.spi
*.include mx3_x2.spi
*.include nand4_x0.spi
*.include nor2_x0.spi
*.include inv_x0.spi
*.include a4_x2.spi
*.include o3_x2.spi
*.include o4_x2.spi
*.include buf_x1.spi
*.include zero_x1.spi

* Non-terminal models (part of the user's design hierarchy).

.subckt picorv32_cts_r 0 1 2 3 4 5 6 7 8 9 10 11 12 13 14 15 16 17 18 19 20 21 22 23 24 25 26 27 28 29 30 31 32 33 34 35 36 37 38 39 56 188 189 190 191 192 193 194 195 196 197 198 199 200 201 202 203 204 205 206 207 208 209 210 211 212 213 214 218 219 220 221 222 223 224 225 226 227 228 229 230 231 232 233 234 235 236 237 238 239 240 241 242 243 244 245 246 247 248 249 250 251 252 253 254 255 256 257 258 259 260 261 262 263 264 265 266 267 268 269 270 271 272 273 274 275 276 277 278 279 280 281 282 283 284 285 286 287 288 289 290 291 292 293 294 295 296 297 298 299 300 301 302 303 304 305 306 307 308 309 310 311 312 313 314 322 323 324 325 332 333 334 335 336 337 338 339 340 341 342 343 344 345 346 347 348 349 350 351 352 353 354 355 356 357 358 359 360 361 362 363 364 367 400 401 402 403 404 405 406 407 408 409 410 411 412 413 414 415 416 417 418 419 420 421 422 423 424 425 426 427 428 429 430 431 432 433 434 435 436 437 438 439 440 441 442 443 444 445 446 447 448 449 450 451 452 453 454 455 456 457 458 459 460 461 462 463 464 465 466 467 468 469 470 471 472 473 474 475 476 477 478 479 480 481 482 483 484 485 486 487 488 489 490 491 492 493 494 495 496 497 498 499 500 501 502 507 508 509 510 511 512 513 514 515 516 517 518 519 520 521 522 523 524 525 526 527 528 529 530 531 532 533 534 535 536 537 538 580 581 582 583 584 585 586 587 588 589 590 591 592 593 594 595 596 597 598 599 600 601 602 603 604 605 606 607 608 609 610 611 667 668 669 670 671 672 673 674 675 676 677 678 679 680 681 682 683 684 685 686 687 688 689 690 691 692 693 694 695 696 697 698 2255
* NET     0 = vss
* NET     1 = vdd
* NET     2 = trap
* NET     3 = trace_valid
* NET     4 = trace_data[9]
* NET     5 = trace_data[8]
* NET     6 = trace_data[7]
* NET     7 = trace_data[6]
* NET     8 = trace_data[5]
* NET     9 = trace_data[4]
* NET    10 = trace_data[35]
* NET    11 = trace_data[34]
* NET    12 = trace_data[33]
* NET    13 = trace_data[32]
* NET    14 = trace_data[31]
* NET    15 = trace_data[30]
* NET    16 = trace_data[3]
* NET    17 = trace_data[29]
* NET    18 = trace_data[28]
* NET    19 = trace_data[27]
* NET    20 = trace_data[26]
* NET    21 = trace_data[25]
* NET    22 = trace_data[24]
* NET    23 = trace_data[23]
* NET    24 = trace_data[22]
* NET    25 = trace_data[21]
* NET    26 = trace_data[20]
* NET    27 = trace_data[2]
* NET    28 = trace_data[19]
* NET    29 = trace_data[18]
* NET    30 = trace_data[17]
* NET    31 = trace_data[16]
* NET    32 = trace_data[15]
* NET    33 = trace_data[14]
* NET    34 = trace_data[13]
* NET    35 = trace_data[12]
* NET    36 = trace_data[11]
* NET    37 = trace_data[10]
* NET    38 = trace_data[1]
* NET    39 = trace_data[0]
* NET    40 = resetn_hfns_9
* NET    41 = resetn_hfns_8
* NET    42 = resetn_hfns_7
* NET    43 = resetn_hfns_6
* NET    44 = resetn_hfns_5
* NET    45 = resetn_hfns_4
* NET    46 = resetn_hfns_3
* NET    47 = resetn_hfns_2
* NET    48 = resetn_hfns_15
* NET    49 = resetn_hfns_14
* NET    50 = resetn_hfns_13
* NET    51 = resetn_hfns_12
* NET    52 = resetn_hfns_11
* NET    53 = resetn_hfns_10
* NET    54 = resetn_hfns_1
* NET    55 = resetn_hfns_0
* NET    56 = resetn
* NET    57 = reg_sh[4]
* NET    58 = reg_sh[3]
* NET    59 = reg_sh[2]
* NET    60 = reg_sh[1]
* NET    61 = reg_sh[0]
* NET    62 = reg_pc[9]
* NET    63 = reg_pc[8]
* NET    64 = reg_pc[7]
* NET    65 = reg_pc[6]
* NET    66 = reg_pc[5]
* NET    67 = reg_pc[4]
* NET    68 = reg_pc[31]
* NET    69 = reg_pc[30]
* NET    70 = reg_pc[3]
* NET    71 = reg_pc[29]
* NET    72 = reg_pc[28]
* NET    73 = reg_pc[27]
* NET    74 = reg_pc[26]
* NET    75 = reg_pc[25]
* NET    76 = reg_pc[24]
* NET    77 = reg_pc[23]
* NET    78 = reg_pc[22]
* NET    79 = reg_pc[21]
* NET    80 = reg_pc[20]
* NET    81 = reg_pc[2]
* NET    82 = reg_pc[19]
* NET    83 = reg_pc[18]
* NET    84 = reg_pc[17]
* NET    85 = reg_pc[16]
* NET    86 = reg_pc[15]
* NET    87 = reg_pc[14]
* NET    88 = reg_pc[13]
* NET    89 = reg_pc[12]
* NET    90 = reg_pc[11]
* NET    91 = reg_pc[10]
* NET    92 = reg_pc[1]
* NET    93 = reg_out[9]
* NET    94 = reg_out[8]
* NET    95 = reg_out[7]
* NET    96 = reg_out[6]
* NET    97 = reg_out[5]
* NET    98 = reg_out[4]
* NET    99 = reg_out[31]
* NET   100 = reg_out[30]
* NET   101 = reg_out[3]
* NET   102 = reg_out[29]
* NET   103 = reg_out[28]
* NET   104 = reg_out[27]
* NET   105 = reg_out[26]
* NET   106 = reg_out[25]
* NET   107 = reg_out[24]
* NET   108 = reg_out[23]
* NET   109 = reg_out[22]
* NET   110 = reg_out[21]
* NET   111 = reg_out[20]
* NET   112 = reg_out[2]
* NET   113 = reg_out[19]
* NET   114 = reg_out[18]
* NET   115 = reg_out[17]
* NET   116 = reg_out[16]
* NET   117 = reg_out[15]
* NET   118 = reg_out[14]
* NET   119 = reg_out[13]
* NET   120 = reg_out[12]
* NET   121 = reg_out[11]
* NET   122 = reg_out[10]
* NET   123 = reg_out[1]
* NET   124 = reg_out[0]
* NET   125 = reg_next_pc[9]
* NET   126 = reg_next_pc[8]
* NET   127 = reg_next_pc[7]
* NET   128 = reg_next_pc[6]
* NET   129 = reg_next_pc[5]
* NET   130 = reg_next_pc[4]
* NET   131 = reg_next_pc[31]
* NET   132 = reg_next_pc[30]
* NET   133 = reg_next_pc[3]
* NET   134 = reg_next_pc[29]
* NET   135 = reg_next_pc[28]
* NET   136 = reg_next_pc[27]
* NET   137 = reg_next_pc[26]
* NET   138 = reg_next_pc[25]
* NET   139 = reg_next_pc[24]
* NET   140 = reg_next_pc[23]
* NET   141 = reg_next_pc[22]
* NET   142 = reg_next_pc[21]
* NET   143 = reg_next_pc[20]
* NET   144 = reg_next_pc[2]
* NET   145 = reg_next_pc[19]
* NET   146 = reg_next_pc[18]
* NET   147 = reg_next_pc[17]
* NET   148 = reg_next_pc[16]
* NET   149 = reg_next_pc[15]
* NET   150 = reg_next_pc[14]
* NET   151 = reg_next_pc[13]
* NET   152 = reg_next_pc[12]
* NET   153 = reg_next_pc[11]
* NET   154 = reg_next_pc[10]
* NET   155 = reg_next_pc[1]
* NET   156 = procmux_1296_y[9]
* NET   157 = procmux_1296_y[8]
* NET   158 = procmux_1296_y[7]
* NET   159 = procmux_1296_y[6]
* NET   160 = procmux_1296_y[5]
* NET   161 = procmux_1296_y[4]
* NET   162 = procmux_1296_y[31]
* NET   163 = procmux_1296_y[30]
* NET   164 = procmux_1296_y[3]
* NET   165 = procmux_1296_y[29]
* NET   166 = procmux_1296_y[28]
* NET   167 = procmux_1296_y[27]
* NET   168 = procmux_1296_y[26]
* NET   169 = procmux_1296_y[25]
* NET   170 = procmux_1296_y[24]
* NET   171 = procmux_1296_y[23]
* NET   172 = procmux_1296_y[22]
* NET   173 = procmux_1296_y[21]
* NET   174 = procmux_1296_y[20]
* NET   175 = procmux_1296_y[2]
* NET   176 = procmux_1296_y[19]
* NET   177 = procmux_1296_y[18]
* NET   178 = procmux_1296_y[17]
* NET   179 = procmux_1296_y[16]
* NET   180 = procmux_1296_y[15]
* NET   181 = procmux_1296_y[14]
* NET   182 = procmux_1296_y[13]
* NET   183 = procmux_1296_y[12]
* NET   184 = procmux_1296_y[11]
* NET   185 = procmux_1296_y[10]
* NET   186 = procmux_1296_y[1]
* NET   187 = procmux_1296_y[0]
* NET   188 = pcpi_wr
* NET   189 = pcpi_wait
* NET   190 = pcpi_valid
* NET   191 = pcpi_rs2[9]
* NET   192 = pcpi_rs2[8]
* NET   193 = pcpi_rs2[31]
* NET   194 = pcpi_rs2[30]
* NET   195 = pcpi_rs2[29]
* NET   196 = pcpi_rs2[28]
* NET   197 = pcpi_rs2[27]
* NET   198 = pcpi_rs2[26]
* NET   199 = pcpi_rs2[25]
* NET   200 = pcpi_rs2[24]
* NET   201 = pcpi_rs2[23]
* NET   202 = pcpi_rs2[22]
* NET   203 = pcpi_rs2[21]
* NET   204 = pcpi_rs2[20]
* NET   205 = pcpi_rs2[19]
* NET   206 = pcpi_rs2[18]
* NET   207 = pcpi_rs2[17]
* NET   208 = pcpi_rs2[16]
* NET   209 = pcpi_rs2[15]
* NET   210 = pcpi_rs2[14]
* NET   211 = pcpi_rs2[13]
* NET   212 = pcpi_rs2[12]
* NET   213 = pcpi_rs2[11]
* NET   214 = pcpi_rs2[10]
* NET   215 = pcpi_rs1_bit1_hfns_2
* NET   216 = pcpi_rs1_bit1_hfns_1
* NET   217 = pcpi_rs1_bit1_hfns_0
* NET   218 = pcpi_rs1[9]
* NET   219 = pcpi_rs1[8]
* NET   220 = pcpi_rs1[7]
* NET   221 = pcpi_rs1[6]
* NET   222 = pcpi_rs1[5]
* NET   223 = pcpi_rs1[4]
* NET   224 = pcpi_rs1[31]
* NET   225 = pcpi_rs1[30]
* NET   226 = pcpi_rs1[3]
* NET   227 = pcpi_rs1[29]
* NET   228 = pcpi_rs1[28]
* NET   229 = pcpi_rs1[27]
* NET   230 = pcpi_rs1[26]
* NET   231 = pcpi_rs1[25]
* NET   232 = pcpi_rs1[24]
* NET   233 = pcpi_rs1[23]
* NET   234 = pcpi_rs1[22]
* NET   235 = pcpi_rs1[21]
* NET   236 = pcpi_rs1[20]
* NET   237 = pcpi_rs1[2]
* NET   238 = pcpi_rs1[19]
* NET   239 = pcpi_rs1[18]
* NET   240 = pcpi_rs1[17]
* NET   241 = pcpi_rs1[16]
* NET   242 = pcpi_rs1[15]
* NET   243 = pcpi_rs1[14]
* NET   244 = pcpi_rs1[13]
* NET   245 = pcpi_rs1[12]
* NET   246 = pcpi_rs1[11]
* NET   247 = pcpi_rs1[10]
* NET   248 = pcpi_rs1[1]
* NET   249 = pcpi_rs1[0]
* NET   250 = pcpi_ready
* NET   251 = pcpi_rd[9]
* NET   252 = pcpi_rd[8]
* NET   253 = pcpi_rd[7]
* NET   254 = pcpi_rd[6]
* NET   255 = pcpi_rd[5]
* NET   256 = pcpi_rd[4]
* NET   257 = pcpi_rd[31]
* NET   258 = pcpi_rd[30]
* NET   259 = pcpi_rd[3]
* NET   260 = pcpi_rd[29]
* NET   261 = pcpi_rd[28]
* NET   262 = pcpi_rd[27]
* NET   263 = pcpi_rd[26]
* NET   264 = pcpi_rd[25]
* NET   265 = pcpi_rd[24]
* NET   266 = pcpi_rd[23]
* NET   267 = pcpi_rd[22]
* NET   268 = pcpi_rd[21]
* NET   269 = pcpi_rd[20]
* NET   270 = pcpi_rd[2]
* NET   271 = pcpi_rd[19]
* NET   272 = pcpi_rd[18]
* NET   273 = pcpi_rd[17]
* NET   274 = pcpi_rd[16]
* NET   275 = pcpi_rd[15]
* NET   276 = pcpi_rd[14]
* NET   277 = pcpi_rd[13]
* NET   278 = pcpi_rd[12]
* NET   279 = pcpi_rd[11]
* NET   280 = pcpi_rd[10]
* NET   281 = pcpi_rd[1]
* NET   282 = pcpi_rd[0]
* NET   283 = pcpi_insn[9]
* NET   284 = pcpi_insn[8]
* NET   285 = pcpi_insn[7]
* NET   286 = pcpi_insn[6]
* NET   287 = pcpi_insn[5]
* NET   288 = pcpi_insn[4]
* NET   289 = pcpi_insn[31]
* NET   290 = pcpi_insn[30]
* NET   291 = pcpi_insn[3]
* NET   292 = pcpi_insn[29]
* NET   293 = pcpi_insn[28]
* NET   294 = pcpi_insn[27]
* NET   295 = pcpi_insn[26]
* NET   296 = pcpi_insn[25]
* NET   297 = pcpi_insn[24]
* NET   298 = pcpi_insn[23]
* NET   299 = pcpi_insn[22]
* NET   300 = pcpi_insn[21]
* NET   301 = pcpi_insn[20]
* NET   302 = pcpi_insn[2]
* NET   303 = pcpi_insn[19]
* NET   304 = pcpi_insn[18]
* NET   305 = pcpi_insn[17]
* NET   306 = pcpi_insn[16]
* NET   307 = pcpi_insn[15]
* NET   308 = pcpi_insn[14]
* NET   309 = pcpi_insn[13]
* NET   310 = pcpi_insn[12]
* NET   311 = pcpi_insn[11]
* NET   312 = pcpi_insn[10]
* NET   313 = pcpi_insn[1]
* NET   314 = pcpi_insn[0]
* NET   315 = n0_reg_sh_4_0_4
* NET   316 = n0_reg_sh_4_0_3
* NET   317 = n0_reg_sh_4_0_2
* NET   318 = n0_is_sltiu_bltu_sltu_0_0
* NET   319 = n0_is_slti_blt_slt_0_0
* NET   320 = n0_is_lui_auipc_jal_0_0
* NET   321 = n0_decoder_trigger_0_0
* NET   322 = mem_wstrb[3]
* NET   323 = mem_wstrb[2]
* NET   324 = mem_wstrb[1]
* NET   325 = mem_wstrb[0]
* NET   326 = mem_wordsize_bit2_hfns_2
* NET   327 = mem_wordsize_bit2_hfns_1
* NET   328 = mem_wordsize_bit2_hfns_0
* NET   329 = mem_wordsize[2]
* NET   330 = mem_wordsize[1]
* NET   331 = mem_wordsize[0]
* NET   332 = mem_wdata[9]
* NET   333 = mem_wdata[8]
* NET   334 = mem_wdata[7]
* NET   335 = mem_wdata[6]
* NET   336 = mem_wdata[5]
* NET   337 = mem_wdata[4]
* NET   338 = mem_wdata[31]
* NET   339 = mem_wdata[30]
* NET   340 = mem_wdata[3]
* NET   341 = mem_wdata[29]
* NET   342 = mem_wdata[28]
* NET   343 = mem_wdata[27]
* NET   344 = mem_wdata[26]
* NET   345 = mem_wdata[25]
* NET   346 = mem_wdata[24]
* NET   347 = mem_wdata[23]
* NET   348 = mem_wdata[22]
* NET   349 = mem_wdata[21]
* NET   350 = mem_wdata[20]
* NET   351 = mem_wdata[2]
* NET   352 = mem_wdata[19]
* NET   353 = mem_wdata[18]
* NET   354 = mem_wdata[17]
* NET   355 = mem_wdata[16]
* NET   356 = mem_wdata[15]
* NET   357 = mem_wdata[14]
* NET   358 = mem_wdata[13]
* NET   359 = mem_wdata[12]
* NET   360 = mem_wdata[11]
* NET   361 = mem_wdata[10]
* NET   362 = mem_wdata[1]
* NET   363 = mem_wdata[0]
* NET   364 = mem_valid
* NET   365 = mem_state[1]
* NET   366 = mem_state[0]
* NET   367 = mem_ready
* NET   368 = mem_rdata_q[9]
* NET   369 = mem_rdata_q[8]
* NET   370 = mem_rdata_q[7]
* NET   371 = mem_rdata_q[6]
* NET   372 = mem_rdata_q[5]
* NET   373 = mem_rdata_q[4]
* NET   374 = mem_rdata_q[31]
* NET   375 = mem_rdata_q[30]
* NET   376 = mem_rdata_q[3]
* NET   377 = mem_rdata_q[29]
* NET   378 = mem_rdata_q[28]
* NET   379 = mem_rdata_q[27]
* NET   380 = mem_rdata_q[26]
* NET   381 = mem_rdata_q[25]
* NET   382 = mem_rdata_q[24]
* NET   383 = mem_rdata_q[23]
* NET   384 = mem_rdata_q[22]
* NET   385 = mem_rdata_q[21]
* NET   386 = mem_rdata_q[20]
* NET   387 = mem_rdata_q[2]
* NET   388 = mem_rdata_q[19]
* NET   389 = mem_rdata_q[18]
* NET   390 = mem_rdata_q[17]
* NET   391 = mem_rdata_q[16]
* NET   392 = mem_rdata_q[15]
* NET   393 = mem_rdata_q[14]
* NET   394 = mem_rdata_q[13]
* NET   395 = mem_rdata_q[12]
* NET   396 = mem_rdata_q[11]
* NET   397 = mem_rdata_q[10]
* NET   398 = mem_rdata_q[1]
* NET   399 = mem_rdata_q[0]
* NET   400 = mem_rdata[9]
* NET   401 = mem_rdata[8]
* NET   402 = mem_rdata[7]
* NET   403 = mem_rdata[6]
* NET   404 = mem_rdata[5]
* NET   405 = mem_rdata[4]
* NET   406 = mem_rdata[31]
* NET   407 = mem_rdata[30]
* NET   408 = mem_rdata[3]
* NET   409 = mem_rdata[29]
* NET   410 = mem_rdata[28]
* NET   411 = mem_rdata[27]
* NET   412 = mem_rdata[26]
* NET   413 = mem_rdata[25]
* NET   414 = mem_rdata[24]
* NET   415 = mem_rdata[23]
* NET   416 = mem_rdata[22]
* NET   417 = mem_rdata[21]
* NET   418 = mem_rdata[20]
* NET   419 = mem_rdata[2]
* NET   420 = mem_rdata[19]
* NET   421 = mem_rdata[18]
* NET   422 = mem_rdata[17]
* NET   423 = mem_rdata[16]
* NET   424 = mem_rdata[15]
* NET   425 = mem_rdata[14]
* NET   426 = mem_rdata[13]
* NET   427 = mem_rdata[12]
* NET   428 = mem_rdata[11]
* NET   429 = mem_rdata[10]
* NET   430 = mem_rdata[1]
* NET   431 = mem_rdata[0]
* NET   432 = mem_la_wstrb[3]
* NET   433 = mem_la_wstrb[2]
* NET   434 = mem_la_wstrb[1]
* NET   435 = mem_la_wstrb[0]
* NET   436 = mem_la_write
* NET   437 = mem_la_wdata[9]
* NET   438 = mem_la_wdata[8]
* NET   439 = mem_la_wdata[7]
* NET   440 = mem_la_wdata[6]
* NET   441 = mem_la_wdata[5]
* NET   442 = mem_la_wdata[4]
* NET   443 = mem_la_wdata[31]
* NET   444 = mem_la_wdata[30]
* NET   445 = mem_la_wdata[3]
* NET   446 = mem_la_wdata[29]
* NET   447 = mem_la_wdata[28]
* NET   448 = mem_la_wdata[27]
* NET   449 = mem_la_wdata[26]
* NET   450 = mem_la_wdata[25]
* NET   451 = mem_la_wdata[24]
* NET   452 = mem_la_wdata[23]
* NET   453 = mem_la_wdata[22]
* NET   454 = mem_la_wdata[21]
* NET   455 = mem_la_wdata[20]
* NET   456 = mem_la_wdata[2]
* NET   457 = mem_la_wdata[19]
* NET   458 = mem_la_wdata[18]
* NET   459 = mem_la_wdata[17]
* NET   460 = mem_la_wdata[16]
* NET   461 = mem_la_wdata[15]
* NET   462 = mem_la_wdata[14]
* NET   463 = mem_la_wdata[13]
* NET   464 = mem_la_wdata[12]
* NET   465 = mem_la_wdata[11]
* NET   466 = mem_la_wdata[10]
* NET   467 = mem_la_wdata[1]
* NET   468 = mem_la_wdata[0]
* NET   469 = mem_la_read
* NET   470 = mem_la_addr[9]
* NET   471 = mem_la_addr[8]
* NET   472 = mem_la_addr[7]
* NET   473 = mem_la_addr[6]
* NET   474 = mem_la_addr[5]
* NET   475 = mem_la_addr[4]
* NET   476 = mem_la_addr[31]
* NET   477 = mem_la_addr[30]
* NET   478 = mem_la_addr[3]
* NET   479 = mem_la_addr[29]
* NET   480 = mem_la_addr[28]
* NET   481 = mem_la_addr[27]
* NET   482 = mem_la_addr[26]
* NET   483 = mem_la_addr[25]
* NET   484 = mem_la_addr[24]
* NET   485 = mem_la_addr[23]
* NET   486 = mem_la_addr[22]
* NET   487 = mem_la_addr[21]
* NET   488 = mem_la_addr[20]
* NET   489 = mem_la_addr[2]
* NET   490 = mem_la_addr[19]
* NET   491 = mem_la_addr[18]
* NET   492 = mem_la_addr[17]
* NET   493 = mem_la_addr[16]
* NET   494 = mem_la_addr[15]
* NET   495 = mem_la_addr[14]
* NET   496 = mem_la_addr[13]
* NET   497 = mem_la_addr[12]
* NET   498 = mem_la_addr[11]
* NET   499 = mem_la_addr[10]
* NET   500 = mem_la_addr[1]
* NET   501 = mem_la_addr[0]
* NET   502 = mem_instr
* NET   503 = mem_do_wdata
* NET   504 = mem_do_rinst
* NET   505 = mem_do_rdata
* NET   506 = mem_do_prefetch
* NET   507 = mem_addr[9]
* NET   508 = mem_addr[8]
* NET   509 = mem_addr[7]
* NET   510 = mem_addr[6]
* NET   511 = mem_addr[5]
* NET   512 = mem_addr[4]
* NET   513 = mem_addr[31]
* NET   514 = mem_addr[30]
* NET   515 = mem_addr[3]
* NET   516 = mem_addr[29]
* NET   517 = mem_addr[28]
* NET   518 = mem_addr[27]
* NET   519 = mem_addr[26]
* NET   520 = mem_addr[25]
* NET   521 = mem_addr[24]
* NET   522 = mem_addr[23]
* NET   523 = mem_addr[22]
* NET   524 = mem_addr[21]
* NET   525 = mem_addr[20]
* NET   526 = mem_addr[2]
* NET   527 = mem_addr[19]
* NET   528 = mem_addr[18]
* NET   529 = mem_addr[17]
* NET   530 = mem_addr[16]
* NET   531 = mem_addr[15]
* NET   532 = mem_addr[14]
* NET   533 = mem_addr[13]
* NET   534 = mem_addr[12]
* NET   535 = mem_addr[11]
* NET   536 = mem_addr[10]
* NET   537 = mem_addr[1]
* NET   538 = mem_addr[0]
* NET   539 = latched_store_hfns_2
* NET   540 = latched_store_hfns_1
* NET   541 = latched_store_hfns_0
* NET   542 = latched_store
* NET   543 = latched_stalu_hfns_4
* NET   544 = latched_stalu_hfns_3
* NET   545 = latched_stalu_hfns_2
* NET   546 = latched_stalu_hfns_1
* NET   547 = latched_stalu_hfns_0
* NET   548 = latched_stalu
* NET   549 = latched_rd_bit2_hfns_2
* NET   550 = latched_rd_bit2_hfns_1
* NET   551 = latched_rd_bit2_hfns_0
* NET   552 = latched_rd[4]
* NET   553 = latched_rd[3]
* NET   554 = latched_rd[2]
* NET   555 = latched_rd[1]
* NET   556 = latched_rd[0]
* NET   557 = latched_is_lh
* NET   558 = latched_is_lb
* NET   559 = latched_branch
* NET   560 = is_sltiu_bltu_sltu
* NET   561 = is_slti_blt_slt
* NET   562 = is_slli_srli_srai
* NET   563 = is_sll_srl_sra
* NET   564 = is_sb_sh_sw
* NET   565 = is_lui_auipc_jal_hfns_4
* NET   566 = is_lui_auipc_jal_hfns_3
* NET   567 = is_lui_auipc_jal_hfns_2
* NET   568 = is_lui_auipc_jal_hfns_1
* NET   569 = is_lui_auipc_jal_hfns_0
* NET   570 = is_lui_auipc_jal
* NET   571 = is_lb_lh_lw_lbu_lhu
* NET   572 = is_jalr_addi_slti_sltiu_xori_ori_andi_hfns_2
* NET   573 = is_jalr_addi_slti_sltiu_xori_ori_andi_hfns_1
* NET   574 = is_jalr_addi_slti_sltiu_xori_ori_andi_hfns_0
* NET   575 = is_jalr_addi_slti_sltiu_xori_ori_andi
* NET   576 = is_compare
* NET   577 = is_beq_bne_blt_bge_bltu_bgeu
* NET   578 = is_alu_reg_reg
* NET   579 = is_alu_reg_imm
* NET   580 = irq[9]
* NET   581 = irq[8]
* NET   582 = irq[7]
* NET   583 = irq[6]
* NET   584 = irq[5]
* NET   585 = irq[4]
* NET   586 = irq[31]
* NET   587 = irq[30]
* NET   588 = irq[3]
* NET   589 = irq[29]
* NET   590 = irq[28]
* NET   591 = irq[27]
* NET   592 = irq[26]
* NET   593 = irq[25]
* NET   594 = irq[24]
* NET   595 = irq[23]
* NET   596 = irq[22]
* NET   597 = irq[21]
* NET   598 = irq[20]
* NET   599 = irq[2]
* NET   600 = irq[19]
* NET   601 = irq[18]
* NET   602 = irq[17]
* NET   603 = irq[16]
* NET   604 = irq[15]
* NET   605 = irq[14]
* NET   606 = irq[13]
* NET   607 = irq[12]
* NET   608 = irq[11]
* NET   609 = irq[10]
* NET   610 = irq[1]
* NET   611 = irq[0]
* NET   612 = instr_xori
* NET   613 = instr_xor
* NET   614 = instr_sw
* NET   615 = instr_sub
* NET   616 = instr_srli
* NET   617 = instr_srl
* NET   618 = instr_srai
* NET   619 = instr_sra
* NET   620 = instr_sltu
* NET   621 = instr_sltiu
* NET   622 = instr_slti
* NET   623 = instr_slt
* NET   624 = instr_slli
* NET   625 = instr_sll
* NET   626 = instr_sh
* NET   627 = instr_sb
* NET   628 = instr_rdinstrh_hfns_2
* NET   629 = instr_rdinstrh_hfns_1
* NET   630 = instr_rdinstrh_hfns_0
* NET   631 = instr_rdinstrh
* NET   632 = instr_rdinstr_hfns_2
* NET   633 = instr_rdinstr_hfns_1
* NET   634 = instr_rdinstr_hfns_0
* NET   635 = instr_rdinstr
* NET   636 = instr_rdcycleh_hfns_2
* NET   637 = instr_rdcycleh_hfns_1
* NET   638 = instr_rdcycleh_hfns_0
* NET   639 = instr_rdcycleh
* NET   640 = instr_rdcycle
* NET   641 = instr_ori
* NET   642 = instr_or
* NET   643 = instr_lw
* NET   644 = instr_lui
* NET   645 = instr_lhu
* NET   646 = instr_lh
* NET   647 = instr_lbu
* NET   648 = instr_lb
* NET   649 = instr_jalr
* NET   650 = instr_jal_hfns_3
* NET   651 = instr_jal_hfns_2
* NET   652 = instr_jal_hfns_1
* NET   653 = instr_jal_hfns_0
* NET   654 = instr_jal
* NET   655 = instr_fence
* NET   656 = instr_bne
* NET   657 = instr_bltu
* NET   658 = instr_blt
* NET   659 = instr_bgeu
* NET   660 = instr_bge
* NET   661 = instr_beq
* NET   662 = instr_auipc
* NET   663 = instr_andi
* NET   664 = instr_and
* NET   665 = instr_addi
* NET   666 = instr_add
* NET   667 = eoi[9]
* NET   668 = eoi[8]
* NET   669 = eoi[7]
* NET   670 = eoi[6]
* NET   671 = eoi[5]
* NET   672 = eoi[4]
* NET   673 = eoi[31]
* NET   674 = eoi[30]
* NET   675 = eoi[3]
* NET   676 = eoi[29]
* NET   677 = eoi[28]
* NET   678 = eoi[27]
* NET   679 = eoi[26]
* NET   680 = eoi[25]
* NET   681 = eoi[24]
* NET   682 = eoi[23]
* NET   683 = eoi[22]
* NET   684 = eoi[21]
* NET   685 = eoi[20]
* NET   686 = eoi[2]
* NET   687 = eoi[19]
* NET   688 = eoi[18]
* NET   689 = eoi[17]
* NET   690 = eoi[16]
* NET   691 = eoi[15]
* NET   692 = eoi[14]
* NET   693 = eoi[13]
* NET   694 = eoi[12]
* NET   695 = eoi[11]
* NET   696 = eoi[10]
* NET   697 = eoi[1]
* NET   698 = eoi[0]
* NET   699 = decoder_trigger_hfns_4
* NET   700 = decoder_trigger_hfns_3
* NET   701 = decoder_trigger_hfns_2
* NET   702 = decoder_trigger_hfns_1
* NET   703 = decoder_trigger_hfns_0
* NET   704 = decoder_trigger
* NET   705 = decoder_pseudo_trigger_hfns_2
* NET   706 = decoder_pseudo_trigger_hfns_1
* NET   707 = decoder_pseudo_trigger_hfns_0
* NET   708 = decoder_pseudo_trigger
* NET   709 = decoded_rs2[3]
* NET   710 = decoded_rs2[2]
* NET   711 = decoded_rs2[1]
* NET   712 = decoded_rs2[0]
* NET   713 = decoded_rs1[3]
* NET   714 = decoded_rs1[2]
* NET   715 = decoded_rs1[1]
* NET   716 = decoded_rs1[0]
* NET   717 = decoded_rd[4]
* NET   718 = decoded_rd[3]
* NET   719 = decoded_rd[2]
* NET   720 = decoded_rd[1]
* NET   721 = decoded_rd[0]
* NET   722 = decoded_imm_j_9
* NET   723 = decoded_imm_j_8
* NET   724 = decoded_imm_j_7
* NET   725 = decoded_imm_j_6
* NET   726 = decoded_imm_j_5
* NET   727 = decoded_imm_j_4
* NET   728 = decoded_imm_j_20_hfns_2
* NET   729 = decoded_imm_j_20_hfns_1
* NET   730 = decoded_imm_j_20_hfns_0
* NET   731 = decoded_imm_j_20
* NET   732 = decoded_imm_j_19
* NET   733 = decoded_imm_j_14
* NET   734 = decoded_imm_j_13
* NET   735 = decoded_imm_j_12
* NET   736 = decoded_imm_j_10
* NET   737 = decoded_imm[9]
* NET   738 = decoded_imm[8]
* NET   739 = decoded_imm[7]
* NET   740 = decoded_imm[6]
* NET   741 = decoded_imm[5]
* NET   742 = decoded_imm[4]
* NET   743 = decoded_imm[31]
* NET   744 = decoded_imm[30]
* NET   745 = decoded_imm[3]
* NET   746 = decoded_imm[29]
* NET   747 = decoded_imm[28]
* NET   748 = decoded_imm[27]
* NET   749 = decoded_imm[26]
* NET   750 = decoded_imm[25]
* NET   751 = decoded_imm[24]
* NET   752 = decoded_imm[23]
* NET   753 = decoded_imm[22]
* NET   754 = decoded_imm[21]
* NET   755 = decoded_imm[20]
* NET   756 = decoded_imm[2]
* NET   757 = decoded_imm[19]
* NET   758 = decoded_imm[18]
* NET   759 = decoded_imm[17]
* NET   760 = decoded_imm[16]
* NET   761 = decoded_imm[15]
* NET   762 = decoded_imm[14]
* NET   763 = decoded_imm[13]
* NET   764 = decoded_imm[12]
* NET   765 = decoded_imm[11]
* NET   766 = decoded_imm[10]
* NET   767 = decoded_imm[1]
* NET   768 = decoded_imm[0]
* NET   769 = cpuregs_rdreg_1_q_4_hfns_3
* NET   770 = cpuregs_rdreg_1_q_4_hfns_2
* NET   771 = cpuregs_rdreg_1_q_4_hfns_1
* NET   772 = cpuregs_rdreg_1_q_4_hfns_0
* NET   773 = cpuregs_rdreg_1_q_4
* NET   774 = cpuregs_rdreg_1_q_3_hfns_2
* NET   775 = cpuregs_rdreg_1_q_3_hfns_1
* NET   776 = cpuregs_rdreg_1_q_3_hfns_0
* NET   777 = cpuregs_rdreg_1_q_3
* NET   778 = cpuregs_rdreg_1_q_2_hfns_6
* NET   779 = cpuregs_rdreg_1_q_2_hfns_5
* NET   780 = cpuregs_rdreg_1_q_2_hfns_4
* NET   781 = cpuregs_rdreg_1_q_2_hfns_3
* NET   782 = cpuregs_rdreg_1_q_2_hfns_2
* NET   783 = cpuregs_rdreg_1_q_2_hfns_1
* NET   784 = cpuregs_rdreg_1_q_2_hfns_0
* NET   785 = cpuregs_rdreg_1_q_2
* NET   786 = cpuregs_rdreg_1_q_1_hfns_5
* NET   787 = cpuregs_rdreg_1_q_1_hfns_4
* NET   788 = cpuregs_rdreg_1_q_1_hfns_3
* NET   789 = cpuregs_rdreg_1_q_1_hfns_2
* NET   790 = cpuregs_rdreg_1_q_1_hfns_1
* NET   791 = cpuregs_rdreg_1_q_1_hfns_0
* NET   792 = cpuregs_rdreg_1_q_1
* NET   793 = cpuregs_rdreg_1_q_0_hfns_9
* NET   794 = cpuregs_rdreg_1_q_0_hfns_8
* NET   795 = cpuregs_rdreg_1_q_0_hfns_7
* NET   796 = cpuregs_rdreg_1_q_0_hfns_6
* NET   797 = cpuregs_rdreg_1_q_0_hfns_5
* NET   798 = cpuregs_rdreg_1_q_0_hfns_4
* NET   799 = cpuregs_rdreg_1_q_0_hfns_3
* NET   800 = cpuregs_rdreg_1_q_0_hfns_28
* NET   801 = cpuregs_rdreg_1_q_0_hfns_27
* NET   802 = cpuregs_rdreg_1_q_0_hfns_26
* NET   803 = cpuregs_rdreg_1_q_0_hfns_25
* NET   804 = cpuregs_rdreg_1_q_0_hfns_24
* NET   805 = cpuregs_rdreg_1_q_0_hfns_23
* NET   806 = cpuregs_rdreg_1_q_0_hfns_22
* NET   807 = cpuregs_rdreg_1_q_0_hfns_21
* NET   808 = cpuregs_rdreg_1_q_0_hfns_20
* NET   809 = cpuregs_rdreg_1_q_0_hfns_2
* NET   810 = cpuregs_rdreg_1_q_0_hfns_19
* NET   811 = cpuregs_rdreg_1_q_0_hfns_18
* NET   812 = cpuregs_rdreg_1_q_0_hfns_17
* NET   813 = cpuregs_rdreg_1_q_0_hfns_16
* NET   814 = cpuregs_rdreg_1_q_0_hfns_15
* NET   815 = cpuregs_rdreg_1_q_0_hfns_14
* NET   816 = cpuregs_rdreg_1_q_0_hfns_13
* NET   817 = cpuregs_rdreg_1_q_0_hfns_12
* NET   818 = cpuregs_rdreg_1_q_0_hfns_11
* NET   819 = cpuregs_rdreg_1_q_0_hfns_10
* NET   820 = cpuregs_rdreg_1_q_0_hfns_1
* NET   821 = cpuregs_rdreg_1_q_0_hfns_0
* NET   822 = cpuregs_rdreg_1_q_0
* NET   823 = cpuregs_rdreg_0_q_4
* NET   824 = cpuregs_rdreg_0_q_3_hfns_4
* NET   825 = cpuregs_rdreg_0_q_3_hfns_3
* NET   826 = cpuregs_rdreg_0_q_3_hfns_2
* NET   827 = cpuregs_rdreg_0_q_3_hfns_1
* NET   828 = cpuregs_rdreg_0_q_3_hfns_0
* NET   829 = cpuregs_rdreg_0_q_3
* NET   830 = cpuregs_rdreg_0_q_2
* NET   831 = cpuregs_rdreg_0_q_1_hfns_5
* NET   832 = cpuregs_rdreg_0_q_1_hfns_4
* NET   833 = cpuregs_rdreg_0_q_1_hfns_3
* NET   834 = cpuregs_rdreg_0_q_1_hfns_2
* NET   835 = cpuregs_rdreg_0_q_1_hfns_1
* NET   836 = cpuregs_rdreg_0_q_1_hfns_0
* NET   837 = cpuregs_rdreg_0_q_1
* NET   838 = cpuregs_rdreg_0_q_0_hfns_9
* NET   839 = cpuregs_rdreg_0_q_0_hfns_8
* NET   840 = cpuregs_rdreg_0_q_0_hfns_7
* NET   841 = cpuregs_rdreg_0_q_0_hfns_6
* NET   842 = cpuregs_rdreg_0_q_0_hfns_5
* NET   843 = cpuregs_rdreg_0_q_0_hfns_4
* NET   844 = cpuregs_rdreg_0_q_0_hfns_3
* NET   845 = cpuregs_rdreg_0_q_0_hfns_28
* NET   846 = cpuregs_rdreg_0_q_0_hfns_27
* NET   847 = cpuregs_rdreg_0_q_0_hfns_26
* NET   848 = cpuregs_rdreg_0_q_0_hfns_25
* NET   849 = cpuregs_rdreg_0_q_0_hfns_24
* NET   850 = cpuregs_rdreg_0_q_0_hfns_23
* NET   851 = cpuregs_rdreg_0_q_0_hfns_22
* NET   852 = cpuregs_rdreg_0_q_0_hfns_21
* NET   853 = cpuregs_rdreg_0_q_0_hfns_20
* NET   854 = cpuregs_rdreg_0_q_0_hfns_2
* NET   855 = cpuregs_rdreg_0_q_0_hfns_19
* NET   856 = cpuregs_rdreg_0_q_0_hfns_18
* NET   857 = cpuregs_rdreg_0_q_0_hfns_17
* NET   858 = cpuregs_rdreg_0_q_0_hfns_16
* NET   859 = cpuregs_rdreg_0_q_0_hfns_15
* NET   860 = cpuregs_rdreg_0_q_0_hfns_14
* NET   861 = cpuregs_rdreg_0_q_0_hfns_13
* NET   862 = cpuregs_rdreg_0_q_0_hfns_12
* NET   863 = cpuregs_rdreg_0_q_0_hfns_11
* NET   864 = cpuregs_rdreg_0_q_0_hfns_10
* NET   865 = cpuregs_rdreg_0_q_0_hfns_1
* NET   866 = cpuregs_rdreg_0_q_0_hfns_0
* NET   867 = cpuregs_rdreg_0_q_0
* NET   868 = cpuregs_9_9
* NET   869 = cpuregs_9_8
* NET   870 = cpuregs_9_7
* NET   871 = cpuregs_9_6
* NET   872 = cpuregs_9_5
* NET   873 = cpuregs_9_4
* NET   874 = cpuregs_9_31
* NET   875 = cpuregs_9_30
* NET   876 = cpuregs_9_3
* NET   877 = cpuregs_9_29
* NET   878 = cpuregs_9_28
* NET   879 = cpuregs_9_27
* NET   880 = cpuregs_9_26
* NET   881 = cpuregs_9_25
* NET   882 = cpuregs_9_24
* NET   883 = cpuregs_9_23
* NET   884 = cpuregs_9_22
* NET   885 = cpuregs_9_21
* NET   886 = cpuregs_9_20
* NET   887 = cpuregs_9_2
* NET   888 = cpuregs_9_19
* NET   889 = cpuregs_9_18
* NET   890 = cpuregs_9_17
* NET   891 = cpuregs_9_16
* NET   892 = cpuregs_9_15
* NET   893 = cpuregs_9_14
* NET   894 = cpuregs_9_13
* NET   895 = cpuregs_9_12
* NET   896 = cpuregs_9_11
* NET   897 = cpuregs_9_10
* NET   898 = cpuregs_9_1
* NET   899 = cpuregs_9_0
* NET   900 = cpuregs_8_9
* NET   901 = cpuregs_8_8
* NET   902 = cpuregs_8_7
* NET   903 = cpuregs_8_6
* NET   904 = cpuregs_8_5
* NET   905 = cpuregs_8_4
* NET   906 = cpuregs_8_31
* NET   907 = cpuregs_8_30
* NET   908 = cpuregs_8_3
* NET   909 = cpuregs_8_29
* NET   910 = cpuregs_8_28
* NET   911 = cpuregs_8_27
* NET   912 = cpuregs_8_26
* NET   913 = cpuregs_8_25
* NET   914 = cpuregs_8_24
* NET   915 = cpuregs_8_23
* NET   916 = cpuregs_8_22
* NET   917 = cpuregs_8_21
* NET   918 = cpuregs_8_20
* NET   919 = cpuregs_8_2
* NET   920 = cpuregs_8_19
* NET   921 = cpuregs_8_18
* NET   922 = cpuregs_8_17
* NET   923 = cpuregs_8_16
* NET   924 = cpuregs_8_15
* NET   925 = cpuregs_8_14
* NET   926 = cpuregs_8_13
* NET   927 = cpuregs_8_12
* NET   928 = cpuregs_8_11
* NET   929 = cpuregs_8_10
* NET   930 = cpuregs_8_1
* NET   931 = cpuregs_8_0
* NET   932 = cpuregs_7_9
* NET   933 = cpuregs_7_8
* NET   934 = cpuregs_7_7
* NET   935 = cpuregs_7_6
* NET   936 = cpuregs_7_5
* NET   937 = cpuregs_7_4
* NET   938 = cpuregs_7_31
* NET   939 = cpuregs_7_30
* NET   940 = cpuregs_7_3
* NET   941 = cpuregs_7_29
* NET   942 = cpuregs_7_28
* NET   943 = cpuregs_7_27
* NET   944 = cpuregs_7_26
* NET   945 = cpuregs_7_25
* NET   946 = cpuregs_7_24
* NET   947 = cpuregs_7_23
* NET   948 = cpuregs_7_22
* NET   949 = cpuregs_7_21
* NET   950 = cpuregs_7_20
* NET   951 = cpuregs_7_2
* NET   952 = cpuregs_7_19
* NET   953 = cpuregs_7_18
* NET   954 = cpuregs_7_17
* NET   955 = cpuregs_7_16
* NET   956 = cpuregs_7_15
* NET   957 = cpuregs_7_14
* NET   958 = cpuregs_7_13
* NET   959 = cpuregs_7_12
* NET   960 = cpuregs_7_11
* NET   961 = cpuregs_7_10
* NET   962 = cpuregs_7_1
* NET   963 = cpuregs_7_0
* NET   964 = cpuregs_6_9
* NET   965 = cpuregs_6_8
* NET   966 = cpuregs_6_7
* NET   967 = cpuregs_6_6
* NET   968 = cpuregs_6_5
* NET   969 = cpuregs_6_4
* NET   970 = cpuregs_6_31
* NET   971 = cpuregs_6_30
* NET   972 = cpuregs_6_3
* NET   973 = cpuregs_6_29
* NET   974 = cpuregs_6_28
* NET   975 = cpuregs_6_27
* NET   976 = cpuregs_6_26
* NET   977 = cpuregs_6_25
* NET   978 = cpuregs_6_24
* NET   979 = cpuregs_6_23
* NET   980 = cpuregs_6_22
* NET   981 = cpuregs_6_21
* NET   982 = cpuregs_6_20
* NET   983 = cpuregs_6_2
* NET   984 = cpuregs_6_19
* NET   985 = cpuregs_6_18
* NET   986 = cpuregs_6_17
* NET   987 = cpuregs_6_16
* NET   988 = cpuregs_6_15
* NET   989 = cpuregs_6_14
* NET   990 = cpuregs_6_13
* NET   991 = cpuregs_6_12
* NET   992 = cpuregs_6_11
* NET   993 = cpuregs_6_10
* NET   994 = cpuregs_6_1
* NET   995 = cpuregs_6_0
* NET   996 = cpuregs_5_9
* NET   997 = cpuregs_5_8
* NET   998 = cpuregs_5_7
* NET   999 = cpuregs_5_6
* NET  1000 = cpuregs_5_5
* NET  1001 = cpuregs_5_4
* NET  1002 = cpuregs_5_31
* NET  1003 = cpuregs_5_30
* NET  1004 = cpuregs_5_3
* NET  1005 = cpuregs_5_29
* NET  1006 = cpuregs_5_28
* NET  1007 = cpuregs_5_27
* NET  1008 = cpuregs_5_26
* NET  1009 = cpuregs_5_25
* NET  1010 = cpuregs_5_24
* NET  1011 = cpuregs_5_23
* NET  1012 = cpuregs_5_22
* NET  1013 = cpuregs_5_21
* NET  1014 = cpuregs_5_20
* NET  1015 = cpuregs_5_2
* NET  1016 = cpuregs_5_19
* NET  1017 = cpuregs_5_18
* NET  1018 = cpuregs_5_17
* NET  1019 = cpuregs_5_16
* NET  1020 = cpuregs_5_15
* NET  1021 = cpuregs_5_14
* NET  1022 = cpuregs_5_13
* NET  1023 = cpuregs_5_12
* NET  1024 = cpuregs_5_11
* NET  1025 = cpuregs_5_10
* NET  1026 = cpuregs_5_1
* NET  1027 = cpuregs_5_0
* NET  1028 = cpuregs_4_9
* NET  1029 = cpuregs_4_8
* NET  1030 = cpuregs_4_7
* NET  1031 = cpuregs_4_6
* NET  1032 = cpuregs_4_5
* NET  1033 = cpuregs_4_4
* NET  1034 = cpuregs_4_31
* NET  1035 = cpuregs_4_30
* NET  1036 = cpuregs_4_3
* NET  1037 = cpuregs_4_29
* NET  1038 = cpuregs_4_28
* NET  1039 = cpuregs_4_27
* NET  1040 = cpuregs_4_26
* NET  1041 = cpuregs_4_25
* NET  1042 = cpuregs_4_24
* NET  1043 = cpuregs_4_23
* NET  1044 = cpuregs_4_22
* NET  1045 = cpuregs_4_21
* NET  1046 = cpuregs_4_20
* NET  1047 = cpuregs_4_2
* NET  1048 = cpuregs_4_19
* NET  1049 = cpuregs_4_18
* NET  1050 = cpuregs_4_17
* NET  1051 = cpuregs_4_16
* NET  1052 = cpuregs_4_15
* NET  1053 = cpuregs_4_14
* NET  1054 = cpuregs_4_13
* NET  1055 = cpuregs_4_12
* NET  1056 = cpuregs_4_11
* NET  1057 = cpuregs_4_10
* NET  1058 = cpuregs_4_1
* NET  1059 = cpuregs_4_0
* NET  1060 = cpuregs_3_9
* NET  1061 = cpuregs_3_8
* NET  1062 = cpuregs_3_7
* NET  1063 = cpuregs_3_6
* NET  1064 = cpuregs_3_5
* NET  1065 = cpuregs_3_4
* NET  1066 = cpuregs_3_31
* NET  1067 = cpuregs_3_30
* NET  1068 = cpuregs_3_3
* NET  1069 = cpuregs_3_29
* NET  1070 = cpuregs_3_28
* NET  1071 = cpuregs_3_27
* NET  1072 = cpuregs_3_26
* NET  1073 = cpuregs_3_25
* NET  1074 = cpuregs_3_24
* NET  1075 = cpuregs_3_23
* NET  1076 = cpuregs_3_22
* NET  1077 = cpuregs_3_21
* NET  1078 = cpuregs_3_20
* NET  1079 = cpuregs_3_2
* NET  1080 = cpuregs_3_19
* NET  1081 = cpuregs_3_18
* NET  1082 = cpuregs_3_17
* NET  1083 = cpuregs_3_16
* NET  1084 = cpuregs_3_15
* NET  1085 = cpuregs_3_14
* NET  1086 = cpuregs_3_13
* NET  1087 = cpuregs_3_12
* NET  1088 = cpuregs_3_11
* NET  1089 = cpuregs_3_10
* NET  1090 = cpuregs_3_1
* NET  1091 = cpuregs_3_0
* NET  1092 = cpuregs_31_9
* NET  1093 = cpuregs_31_8
* NET  1094 = cpuregs_31_7
* NET  1095 = cpuregs_31_6
* NET  1096 = cpuregs_31_5
* NET  1097 = cpuregs_31_4
* NET  1098 = cpuregs_31_31
* NET  1099 = cpuregs_31_30
* NET  1100 = cpuregs_31_3
* NET  1101 = cpuregs_31_29
* NET  1102 = cpuregs_31_28
* NET  1103 = cpuregs_31_27
* NET  1104 = cpuregs_31_26
* NET  1105 = cpuregs_31_25
* NET  1106 = cpuregs_31_24
* NET  1107 = cpuregs_31_23
* NET  1108 = cpuregs_31_22
* NET  1109 = cpuregs_31_21
* NET  1110 = cpuregs_31_20
* NET  1111 = cpuregs_31_2
* NET  1112 = cpuregs_31_19
* NET  1113 = cpuregs_31_18
* NET  1114 = cpuregs_31_17
* NET  1115 = cpuregs_31_16
* NET  1116 = cpuregs_31_15
* NET  1117 = cpuregs_31_14
* NET  1118 = cpuregs_31_13
* NET  1119 = cpuregs_31_12
* NET  1120 = cpuregs_31_11
* NET  1121 = cpuregs_31_10
* NET  1122 = cpuregs_31_1
* NET  1123 = cpuregs_31_0
* NET  1124 = cpuregs_30_9
* NET  1125 = cpuregs_30_8
* NET  1126 = cpuregs_30_7
* NET  1127 = cpuregs_30_6
* NET  1128 = cpuregs_30_5
* NET  1129 = cpuregs_30_4
* NET  1130 = cpuregs_30_31
* NET  1131 = cpuregs_30_30
* NET  1132 = cpuregs_30_3
* NET  1133 = cpuregs_30_29
* NET  1134 = cpuregs_30_28
* NET  1135 = cpuregs_30_27
* NET  1136 = cpuregs_30_26
* NET  1137 = cpuregs_30_25
* NET  1138 = cpuregs_30_24
* NET  1139 = cpuregs_30_23
* NET  1140 = cpuregs_30_22
* NET  1141 = cpuregs_30_21
* NET  1142 = cpuregs_30_20
* NET  1143 = cpuregs_30_2
* NET  1144 = cpuregs_30_19
* NET  1145 = cpuregs_30_18
* NET  1146 = cpuregs_30_17
* NET  1147 = cpuregs_30_16
* NET  1148 = cpuregs_30_15
* NET  1149 = cpuregs_30_14
* NET  1150 = cpuregs_30_13
* NET  1151 = cpuregs_30_12
* NET  1152 = cpuregs_30_11
* NET  1153 = cpuregs_30_10
* NET  1154 = cpuregs_30_1
* NET  1155 = cpuregs_30_0
* NET  1156 = cpuregs_2_9
* NET  1157 = cpuregs_2_8
* NET  1158 = cpuregs_2_7
* NET  1159 = cpuregs_2_6
* NET  1160 = cpuregs_2_5
* NET  1161 = cpuregs_2_4
* NET  1162 = cpuregs_2_31
* NET  1163 = cpuregs_2_30
* NET  1164 = cpuregs_2_3
* NET  1165 = cpuregs_2_29
* NET  1166 = cpuregs_2_28
* NET  1167 = cpuregs_2_27
* NET  1168 = cpuregs_2_26
* NET  1169 = cpuregs_2_25
* NET  1170 = cpuregs_2_24
* NET  1171 = cpuregs_2_23
* NET  1172 = cpuregs_2_22
* NET  1173 = cpuregs_2_21
* NET  1174 = cpuregs_2_20
* NET  1175 = cpuregs_2_2
* NET  1176 = cpuregs_2_19
* NET  1177 = cpuregs_2_18
* NET  1178 = cpuregs_2_17
* NET  1179 = cpuregs_2_16
* NET  1180 = cpuregs_2_15
* NET  1181 = cpuregs_2_14
* NET  1182 = cpuregs_2_13
* NET  1183 = cpuregs_2_12
* NET  1184 = cpuregs_2_11
* NET  1185 = cpuregs_2_10
* NET  1186 = cpuregs_2_1
* NET  1187 = cpuregs_2_0
* NET  1188 = cpuregs_29_9
* NET  1189 = cpuregs_29_8
* NET  1190 = cpuregs_29_7
* NET  1191 = cpuregs_29_6
* NET  1192 = cpuregs_29_5
* NET  1193 = cpuregs_29_4
* NET  1194 = cpuregs_29_31
* NET  1195 = cpuregs_29_30
* NET  1196 = cpuregs_29_3
* NET  1197 = cpuregs_29_29
* NET  1198 = cpuregs_29_28
* NET  1199 = cpuregs_29_27
* NET  1200 = cpuregs_29_26
* NET  1201 = cpuregs_29_25
* NET  1202 = cpuregs_29_24
* NET  1203 = cpuregs_29_23
* NET  1204 = cpuregs_29_22
* NET  1205 = cpuregs_29_21
* NET  1206 = cpuregs_29_20
* NET  1207 = cpuregs_29_2
* NET  1208 = cpuregs_29_19
* NET  1209 = cpuregs_29_18
* NET  1210 = cpuregs_29_17
* NET  1211 = cpuregs_29_16
* NET  1212 = cpuregs_29_15
* NET  1213 = cpuregs_29_14
* NET  1214 = cpuregs_29_13
* NET  1215 = cpuregs_29_12
* NET  1216 = cpuregs_29_11
* NET  1217 = cpuregs_29_10
* NET  1218 = cpuregs_29_1
* NET  1219 = cpuregs_29_0
* NET  1220 = cpuregs_28_9
* NET  1221 = cpuregs_28_8
* NET  1222 = cpuregs_28_7
* NET  1223 = cpuregs_28_6
* NET  1224 = cpuregs_28_5
* NET  1225 = cpuregs_28_4
* NET  1226 = cpuregs_28_31
* NET  1227 = cpuregs_28_30
* NET  1228 = cpuregs_28_3
* NET  1229 = cpuregs_28_29
* NET  1230 = cpuregs_28_28
* NET  1231 = cpuregs_28_27
* NET  1232 = cpuregs_28_26
* NET  1233 = cpuregs_28_25
* NET  1234 = cpuregs_28_24
* NET  1235 = cpuregs_28_23
* NET  1236 = cpuregs_28_22
* NET  1237 = cpuregs_28_21
* NET  1238 = cpuregs_28_20
* NET  1239 = cpuregs_28_2
* NET  1240 = cpuregs_28_19
* NET  1241 = cpuregs_28_18
* NET  1242 = cpuregs_28_17
* NET  1243 = cpuregs_28_16
* NET  1244 = cpuregs_28_15
* NET  1245 = cpuregs_28_14
* NET  1246 = cpuregs_28_13
* NET  1247 = cpuregs_28_12
* NET  1248 = cpuregs_28_11
* NET  1249 = cpuregs_28_10
* NET  1250 = cpuregs_28_1
* NET  1251 = cpuregs_28_0
* NET  1252 = cpuregs_27_9
* NET  1253 = cpuregs_27_8
* NET  1254 = cpuregs_27_7
* NET  1255 = cpuregs_27_6
* NET  1256 = cpuregs_27_5
* NET  1257 = cpuregs_27_4
* NET  1258 = cpuregs_27_31
* NET  1259 = cpuregs_27_30
* NET  1260 = cpuregs_27_3
* NET  1261 = cpuregs_27_29
* NET  1262 = cpuregs_27_28
* NET  1263 = cpuregs_27_27
* NET  1264 = cpuregs_27_26
* NET  1265 = cpuregs_27_25
* NET  1266 = cpuregs_27_24
* NET  1267 = cpuregs_27_23
* NET  1268 = cpuregs_27_22
* NET  1269 = cpuregs_27_21
* NET  1270 = cpuregs_27_20
* NET  1271 = cpuregs_27_2
* NET  1272 = cpuregs_27_19
* NET  1273 = cpuregs_27_18
* NET  1274 = cpuregs_27_17
* NET  1275 = cpuregs_27_16
* NET  1276 = cpuregs_27_15
* NET  1277 = cpuregs_27_14
* NET  1278 = cpuregs_27_13
* NET  1279 = cpuregs_27_12
* NET  1280 = cpuregs_27_11
* NET  1281 = cpuregs_27_10
* NET  1282 = cpuregs_27_1
* NET  1283 = cpuregs_27_0
* NET  1284 = cpuregs_26_9
* NET  1285 = cpuregs_26_8
* NET  1286 = cpuregs_26_7
* NET  1287 = cpuregs_26_6
* NET  1288 = cpuregs_26_5
* NET  1289 = cpuregs_26_4
* NET  1290 = cpuregs_26_31
* NET  1291 = cpuregs_26_30
* NET  1292 = cpuregs_26_3
* NET  1293 = cpuregs_26_29
* NET  1294 = cpuregs_26_28
* NET  1295 = cpuregs_26_27
* NET  1296 = cpuregs_26_26
* NET  1297 = cpuregs_26_25
* NET  1298 = cpuregs_26_24
* NET  1299 = cpuregs_26_23
* NET  1300 = cpuregs_26_22
* NET  1301 = cpuregs_26_21
* NET  1302 = cpuregs_26_20
* NET  1303 = cpuregs_26_2
* NET  1304 = cpuregs_26_19
* NET  1305 = cpuregs_26_18
* NET  1306 = cpuregs_26_17
* NET  1307 = cpuregs_26_16
* NET  1308 = cpuregs_26_15
* NET  1309 = cpuregs_26_14
* NET  1310 = cpuregs_26_13
* NET  1311 = cpuregs_26_12
* NET  1312 = cpuregs_26_11
* NET  1313 = cpuregs_26_10
* NET  1314 = cpuregs_26_1
* NET  1315 = cpuregs_26_0
* NET  1316 = cpuregs_25_9
* NET  1317 = cpuregs_25_8
* NET  1318 = cpuregs_25_7
* NET  1319 = cpuregs_25_6
* NET  1320 = cpuregs_25_5
* NET  1321 = cpuregs_25_4
* NET  1322 = cpuregs_25_31
* NET  1323 = cpuregs_25_30
* NET  1324 = cpuregs_25_3
* NET  1325 = cpuregs_25_29
* NET  1326 = cpuregs_25_28
* NET  1327 = cpuregs_25_27
* NET  1328 = cpuregs_25_26
* NET  1329 = cpuregs_25_25
* NET  1330 = cpuregs_25_24
* NET  1331 = cpuregs_25_23
* NET  1332 = cpuregs_25_22
* NET  1333 = cpuregs_25_21
* NET  1334 = cpuregs_25_20
* NET  1335 = cpuregs_25_2
* NET  1336 = cpuregs_25_19
* NET  1337 = cpuregs_25_18
* NET  1338 = cpuregs_25_17
* NET  1339 = cpuregs_25_16
* NET  1340 = cpuregs_25_15
* NET  1341 = cpuregs_25_14
* NET  1342 = cpuregs_25_13
* NET  1343 = cpuregs_25_12
* NET  1344 = cpuregs_25_11
* NET  1345 = cpuregs_25_10
* NET  1346 = cpuregs_25_1
* NET  1347 = cpuregs_25_0
* NET  1348 = cpuregs_24_9
* NET  1349 = cpuregs_24_8
* NET  1350 = cpuregs_24_7
* NET  1351 = cpuregs_24_6
* NET  1352 = cpuregs_24_5
* NET  1353 = cpuregs_24_4
* NET  1354 = cpuregs_24_31
* NET  1355 = cpuregs_24_30
* NET  1356 = cpuregs_24_3
* NET  1357 = cpuregs_24_29
* NET  1358 = cpuregs_24_28
* NET  1359 = cpuregs_24_27
* NET  1360 = cpuregs_24_26
* NET  1361 = cpuregs_24_25
* NET  1362 = cpuregs_24_24
* NET  1363 = cpuregs_24_23
* NET  1364 = cpuregs_24_22
* NET  1365 = cpuregs_24_21
* NET  1366 = cpuregs_24_20
* NET  1367 = cpuregs_24_2
* NET  1368 = cpuregs_24_19
* NET  1369 = cpuregs_24_18
* NET  1370 = cpuregs_24_17
* NET  1371 = cpuregs_24_16
* NET  1372 = cpuregs_24_15
* NET  1373 = cpuregs_24_14
* NET  1374 = cpuregs_24_13
* NET  1375 = cpuregs_24_12
* NET  1376 = cpuregs_24_11
* NET  1377 = cpuregs_24_10
* NET  1378 = cpuregs_24_1
* NET  1379 = cpuregs_24_0
* NET  1380 = cpuregs_23_9
* NET  1381 = cpuregs_23_8
* NET  1382 = cpuregs_23_7
* NET  1383 = cpuregs_23_6
* NET  1384 = cpuregs_23_5
* NET  1385 = cpuregs_23_4
* NET  1386 = cpuregs_23_31
* NET  1387 = cpuregs_23_30
* NET  1388 = cpuregs_23_3
* NET  1389 = cpuregs_23_29
* NET  1390 = cpuregs_23_28
* NET  1391 = cpuregs_23_27
* NET  1392 = cpuregs_23_26
* NET  1393 = cpuregs_23_25
* NET  1394 = cpuregs_23_24
* NET  1395 = cpuregs_23_23
* NET  1396 = cpuregs_23_22
* NET  1397 = cpuregs_23_21
* NET  1398 = cpuregs_23_20
* NET  1399 = cpuregs_23_2
* NET  1400 = cpuregs_23_19
* NET  1401 = cpuregs_23_18
* NET  1402 = cpuregs_23_17
* NET  1403 = cpuregs_23_16
* NET  1404 = cpuregs_23_15
* NET  1405 = cpuregs_23_14
* NET  1406 = cpuregs_23_13
* NET  1407 = cpuregs_23_12
* NET  1408 = cpuregs_23_11
* NET  1409 = cpuregs_23_10
* NET  1410 = cpuregs_23_1
* NET  1411 = cpuregs_23_0
* NET  1412 = cpuregs_22_9
* NET  1413 = cpuregs_22_8
* NET  1414 = cpuregs_22_7
* NET  1415 = cpuregs_22_6
* NET  1416 = cpuregs_22_5
* NET  1417 = cpuregs_22_4
* NET  1418 = cpuregs_22_31
* NET  1419 = cpuregs_22_30
* NET  1420 = cpuregs_22_3
* NET  1421 = cpuregs_22_29
* NET  1422 = cpuregs_22_28
* NET  1423 = cpuregs_22_27
* NET  1424 = cpuregs_22_26
* NET  1425 = cpuregs_22_25
* NET  1426 = cpuregs_22_24
* NET  1427 = cpuregs_22_23
* NET  1428 = cpuregs_22_22
* NET  1429 = cpuregs_22_21
* NET  1430 = cpuregs_22_20
* NET  1431 = cpuregs_22_2
* NET  1432 = cpuregs_22_19
* NET  1433 = cpuregs_22_18
* NET  1434 = cpuregs_22_17
* NET  1435 = cpuregs_22_16
* NET  1436 = cpuregs_22_15
* NET  1437 = cpuregs_22_14
* NET  1438 = cpuregs_22_13
* NET  1439 = cpuregs_22_12
* NET  1440 = cpuregs_22_11
* NET  1441 = cpuregs_22_10
* NET  1442 = cpuregs_22_1
* NET  1443 = cpuregs_22_0
* NET  1444 = cpuregs_21_9
* NET  1445 = cpuregs_21_8
* NET  1446 = cpuregs_21_7
* NET  1447 = cpuregs_21_6
* NET  1448 = cpuregs_21_5
* NET  1449 = cpuregs_21_4
* NET  1450 = cpuregs_21_31
* NET  1451 = cpuregs_21_30
* NET  1452 = cpuregs_21_3
* NET  1453 = cpuregs_21_29
* NET  1454 = cpuregs_21_28
* NET  1455 = cpuregs_21_27
* NET  1456 = cpuregs_21_26
* NET  1457 = cpuregs_21_25
* NET  1458 = cpuregs_21_24
* NET  1459 = cpuregs_21_23
* NET  1460 = cpuregs_21_22
* NET  1461 = cpuregs_21_21
* NET  1462 = cpuregs_21_20
* NET  1463 = cpuregs_21_2
* NET  1464 = cpuregs_21_19
* NET  1465 = cpuregs_21_18
* NET  1466 = cpuregs_21_17
* NET  1467 = cpuregs_21_16
* NET  1468 = cpuregs_21_15
* NET  1469 = cpuregs_21_14
* NET  1470 = cpuregs_21_13
* NET  1471 = cpuregs_21_12
* NET  1472 = cpuregs_21_11
* NET  1473 = cpuregs_21_10
* NET  1474 = cpuregs_21_1
* NET  1475 = cpuregs_21_0
* NET  1476 = cpuregs_20_9
* NET  1477 = cpuregs_20_8
* NET  1478 = cpuregs_20_7
* NET  1479 = cpuregs_20_6
* NET  1480 = cpuregs_20_5
* NET  1481 = cpuregs_20_4
* NET  1482 = cpuregs_20_31
* NET  1483 = cpuregs_20_30
* NET  1484 = cpuregs_20_3
* NET  1485 = cpuregs_20_29
* NET  1486 = cpuregs_20_28
* NET  1487 = cpuregs_20_27
* NET  1488 = cpuregs_20_26
* NET  1489 = cpuregs_20_25
* NET  1490 = cpuregs_20_24
* NET  1491 = cpuregs_20_23
* NET  1492 = cpuregs_20_22
* NET  1493 = cpuregs_20_21
* NET  1494 = cpuregs_20_20
* NET  1495 = cpuregs_20_2
* NET  1496 = cpuregs_20_19
* NET  1497 = cpuregs_20_18
* NET  1498 = cpuregs_20_17
* NET  1499 = cpuregs_20_16
* NET  1500 = cpuregs_20_15
* NET  1501 = cpuregs_20_14
* NET  1502 = cpuregs_20_13
* NET  1503 = cpuregs_20_12
* NET  1504 = cpuregs_20_11
* NET  1505 = cpuregs_20_10
* NET  1506 = cpuregs_20_1
* NET  1507 = cpuregs_20_0
* NET  1508 = cpuregs_1_9
* NET  1509 = cpuregs_1_8
* NET  1510 = cpuregs_1_7
* NET  1511 = cpuregs_1_6
* NET  1512 = cpuregs_1_5
* NET  1513 = cpuregs_1_4
* NET  1514 = cpuregs_1_31
* NET  1515 = cpuregs_1_30
* NET  1516 = cpuregs_1_3
* NET  1517 = cpuregs_1_29
* NET  1518 = cpuregs_1_28
* NET  1519 = cpuregs_1_27
* NET  1520 = cpuregs_1_26
* NET  1521 = cpuregs_1_25
* NET  1522 = cpuregs_1_24
* NET  1523 = cpuregs_1_23
* NET  1524 = cpuregs_1_22
* NET  1525 = cpuregs_1_21
* NET  1526 = cpuregs_1_20
* NET  1527 = cpuregs_1_2
* NET  1528 = cpuregs_1_19
* NET  1529 = cpuregs_1_18
* NET  1530 = cpuregs_1_17
* NET  1531 = cpuregs_1_16
* NET  1532 = cpuregs_1_15
* NET  1533 = cpuregs_1_14
* NET  1534 = cpuregs_1_13
* NET  1535 = cpuregs_1_12
* NET  1536 = cpuregs_1_11
* NET  1537 = cpuregs_1_10
* NET  1538 = cpuregs_1_1
* NET  1539 = cpuregs_1_0
* NET  1540 = cpuregs_19_9
* NET  1541 = cpuregs_19_8
* NET  1542 = cpuregs_19_7
* NET  1543 = cpuregs_19_6
* NET  1544 = cpuregs_19_5
* NET  1545 = cpuregs_19_4
* NET  1546 = cpuregs_19_31
* NET  1547 = cpuregs_19_30
* NET  1548 = cpuregs_19_3
* NET  1549 = cpuregs_19_29
* NET  1550 = cpuregs_19_28
* NET  1551 = cpuregs_19_27
* NET  1552 = cpuregs_19_26
* NET  1553 = cpuregs_19_25
* NET  1554 = cpuregs_19_24
* NET  1555 = cpuregs_19_23
* NET  1556 = cpuregs_19_22
* NET  1557 = cpuregs_19_21
* NET  1558 = cpuregs_19_20
* NET  1559 = cpuregs_19_2
* NET  1560 = cpuregs_19_19
* NET  1561 = cpuregs_19_18
* NET  1562 = cpuregs_19_17
* NET  1563 = cpuregs_19_16
* NET  1564 = cpuregs_19_15
* NET  1565 = cpuregs_19_14
* NET  1566 = cpuregs_19_13
* NET  1567 = cpuregs_19_12
* NET  1568 = cpuregs_19_11
* NET  1569 = cpuregs_19_10
* NET  1570 = cpuregs_19_1
* NET  1571 = cpuregs_19_0
* NET  1572 = cpuregs_18_9
* NET  1573 = cpuregs_18_8
* NET  1574 = cpuregs_18_7
* NET  1575 = cpuregs_18_6
* NET  1576 = cpuregs_18_5
* NET  1577 = cpuregs_18_4
* NET  1578 = cpuregs_18_31
* NET  1579 = cpuregs_18_30
* NET  1580 = cpuregs_18_3
* NET  1581 = cpuregs_18_29
* NET  1582 = cpuregs_18_28
* NET  1583 = cpuregs_18_27
* NET  1584 = cpuregs_18_26
* NET  1585 = cpuregs_18_25
* NET  1586 = cpuregs_18_24
* NET  1587 = cpuregs_18_23
* NET  1588 = cpuregs_18_22
* NET  1589 = cpuregs_18_21
* NET  1590 = cpuregs_18_20
* NET  1591 = cpuregs_18_2
* NET  1592 = cpuregs_18_19
* NET  1593 = cpuregs_18_18
* NET  1594 = cpuregs_18_17
* NET  1595 = cpuregs_18_16
* NET  1596 = cpuregs_18_15
* NET  1597 = cpuregs_18_14
* NET  1598 = cpuregs_18_13
* NET  1599 = cpuregs_18_12
* NET  1600 = cpuregs_18_11
* NET  1601 = cpuregs_18_10
* NET  1602 = cpuregs_18_1
* NET  1603 = cpuregs_18_0
* NET  1604 = cpuregs_17_9
* NET  1605 = cpuregs_17_8
* NET  1606 = cpuregs_17_7
* NET  1607 = cpuregs_17_6
* NET  1608 = cpuregs_17_5
* NET  1609 = cpuregs_17_4
* NET  1610 = cpuregs_17_31
* NET  1611 = cpuregs_17_30
* NET  1612 = cpuregs_17_3
* NET  1613 = cpuregs_17_29
* NET  1614 = cpuregs_17_28
* NET  1615 = cpuregs_17_27
* NET  1616 = cpuregs_17_26
* NET  1617 = cpuregs_17_25
* NET  1618 = cpuregs_17_24
* NET  1619 = cpuregs_17_23
* NET  1620 = cpuregs_17_22
* NET  1621 = cpuregs_17_21
* NET  1622 = cpuregs_17_20
* NET  1623 = cpuregs_17_2
* NET  1624 = cpuregs_17_19
* NET  1625 = cpuregs_17_18
* NET  1626 = cpuregs_17_17
* NET  1627 = cpuregs_17_16
* NET  1628 = cpuregs_17_15
* NET  1629 = cpuregs_17_14
* NET  1630 = cpuregs_17_13
* NET  1631 = cpuregs_17_12
* NET  1632 = cpuregs_17_11
* NET  1633 = cpuregs_17_10
* NET  1634 = cpuregs_17_1
* NET  1635 = cpuregs_17_0
* NET  1636 = cpuregs_16_9
* NET  1637 = cpuregs_16_8
* NET  1638 = cpuregs_16_7
* NET  1639 = cpuregs_16_6
* NET  1640 = cpuregs_16_5
* NET  1641 = cpuregs_16_4
* NET  1642 = cpuregs_16_31
* NET  1643 = cpuregs_16_30
* NET  1644 = cpuregs_16_3
* NET  1645 = cpuregs_16_29
* NET  1646 = cpuregs_16_28
* NET  1647 = cpuregs_16_27
* NET  1648 = cpuregs_16_26
* NET  1649 = cpuregs_16_25
* NET  1650 = cpuregs_16_24
* NET  1651 = cpuregs_16_23
* NET  1652 = cpuregs_16_22
* NET  1653 = cpuregs_16_21
* NET  1654 = cpuregs_16_20
* NET  1655 = cpuregs_16_2
* NET  1656 = cpuregs_16_19
* NET  1657 = cpuregs_16_18
* NET  1658 = cpuregs_16_17
* NET  1659 = cpuregs_16_16
* NET  1660 = cpuregs_16_15
* NET  1661 = cpuregs_16_14
* NET  1662 = cpuregs_16_13
* NET  1663 = cpuregs_16_12
* NET  1664 = cpuregs_16_11
* NET  1665 = cpuregs_16_10
* NET  1666 = cpuregs_16_1
* NET  1667 = cpuregs_16_0
* NET  1668 = cpuregs_15_9
* NET  1669 = cpuregs_15_8
* NET  1670 = cpuregs_15_7
* NET  1671 = cpuregs_15_6
* NET  1672 = cpuregs_15_5
* NET  1673 = cpuregs_15_4
* NET  1674 = cpuregs_15_31
* NET  1675 = cpuregs_15_30
* NET  1676 = cpuregs_15_3
* NET  1677 = cpuregs_15_29
* NET  1678 = cpuregs_15_28
* NET  1679 = cpuregs_15_27
* NET  1680 = cpuregs_15_26
* NET  1681 = cpuregs_15_25
* NET  1682 = cpuregs_15_24
* NET  1683 = cpuregs_15_23
* NET  1684 = cpuregs_15_22
* NET  1685 = cpuregs_15_21
* NET  1686 = cpuregs_15_20
* NET  1687 = cpuregs_15_2
* NET  1688 = cpuregs_15_19
* NET  1689 = cpuregs_15_18
* NET  1690 = cpuregs_15_17
* NET  1691 = cpuregs_15_16
* NET  1692 = cpuregs_15_15
* NET  1693 = cpuregs_15_14
* NET  1694 = cpuregs_15_13
* NET  1695 = cpuregs_15_12
* NET  1696 = cpuregs_15_11
* NET  1697 = cpuregs_15_10
* NET  1698 = cpuregs_15_1
* NET  1699 = cpuregs_15_0
* NET  1700 = cpuregs_14_9
* NET  1701 = cpuregs_14_8
* NET  1702 = cpuregs_14_7
* NET  1703 = cpuregs_14_6
* NET  1704 = cpuregs_14_5
* NET  1705 = cpuregs_14_4
* NET  1706 = cpuregs_14_31
* NET  1707 = cpuregs_14_30
* NET  1708 = cpuregs_14_3
* NET  1709 = cpuregs_14_29
* NET  1710 = cpuregs_14_28
* NET  1711 = cpuregs_14_27
* NET  1712 = cpuregs_14_26
* NET  1713 = cpuregs_14_25
* NET  1714 = cpuregs_14_24
* NET  1715 = cpuregs_14_23
* NET  1716 = cpuregs_14_22
* NET  1717 = cpuregs_14_21
* NET  1718 = cpuregs_14_20
* NET  1719 = cpuregs_14_2
* NET  1720 = cpuregs_14_19
* NET  1721 = cpuregs_14_18
* NET  1722 = cpuregs_14_17
* NET  1723 = cpuregs_14_16
* NET  1724 = cpuregs_14_15
* NET  1725 = cpuregs_14_14
* NET  1726 = cpuregs_14_13
* NET  1727 = cpuregs_14_12
* NET  1728 = cpuregs_14_11
* NET  1729 = cpuregs_14_10
* NET  1730 = cpuregs_14_1
* NET  1731 = cpuregs_14_0
* NET  1732 = cpuregs_13_9
* NET  1733 = cpuregs_13_8
* NET  1734 = cpuregs_13_7
* NET  1735 = cpuregs_13_6
* NET  1736 = cpuregs_13_5
* NET  1737 = cpuregs_13_4
* NET  1738 = cpuregs_13_31
* NET  1739 = cpuregs_13_30
* NET  1740 = cpuregs_13_3
* NET  1741 = cpuregs_13_29
* NET  1742 = cpuregs_13_28
* NET  1743 = cpuregs_13_27
* NET  1744 = cpuregs_13_26
* NET  1745 = cpuregs_13_25
* NET  1746 = cpuregs_13_24
* NET  1747 = cpuregs_13_23
* NET  1748 = cpuregs_13_22
* NET  1749 = cpuregs_13_21
* NET  1750 = cpuregs_13_20
* NET  1751 = cpuregs_13_2
* NET  1752 = cpuregs_13_19
* NET  1753 = cpuregs_13_18
* NET  1754 = cpuregs_13_17
* NET  1755 = cpuregs_13_16
* NET  1756 = cpuregs_13_15
* NET  1757 = cpuregs_13_14
* NET  1758 = cpuregs_13_13
* NET  1759 = cpuregs_13_12
* NET  1760 = cpuregs_13_11
* NET  1761 = cpuregs_13_10
* NET  1762 = cpuregs_13_1
* NET  1763 = cpuregs_13_0
* NET  1764 = cpuregs_12_9
* NET  1765 = cpuregs_12_8
* NET  1766 = cpuregs_12_7
* NET  1767 = cpuregs_12_6
* NET  1768 = cpuregs_12_5
* NET  1769 = cpuregs_12_4
* NET  1770 = cpuregs_12_31
* NET  1771 = cpuregs_12_30
* NET  1772 = cpuregs_12_3
* NET  1773 = cpuregs_12_29
* NET  1774 = cpuregs_12_28
* NET  1775 = cpuregs_12_27
* NET  1776 = cpuregs_12_26
* NET  1777 = cpuregs_12_25
* NET  1778 = cpuregs_12_24
* NET  1779 = cpuregs_12_23
* NET  1780 = cpuregs_12_22
* NET  1781 = cpuregs_12_21
* NET  1782 = cpuregs_12_20
* NET  1783 = cpuregs_12_2
* NET  1784 = cpuregs_12_19
* NET  1785 = cpuregs_12_18
* NET  1786 = cpuregs_12_17
* NET  1787 = cpuregs_12_16
* NET  1788 = cpuregs_12_15
* NET  1789 = cpuregs_12_14
* NET  1790 = cpuregs_12_13
* NET  1791 = cpuregs_12_12
* NET  1792 = cpuregs_12_11
* NET  1793 = cpuregs_12_10
* NET  1794 = cpuregs_12_1
* NET  1795 = cpuregs_12_0
* NET  1796 = cpuregs_11_9
* NET  1797 = cpuregs_11_8
* NET  1798 = cpuregs_11_7
* NET  1799 = cpuregs_11_6
* NET  1800 = cpuregs_11_5
* NET  1801 = cpuregs_11_4
* NET  1802 = cpuregs_11_31
* NET  1803 = cpuregs_11_30
* NET  1804 = cpuregs_11_3
* NET  1805 = cpuregs_11_29
* NET  1806 = cpuregs_11_28
* NET  1807 = cpuregs_11_27
* NET  1808 = cpuregs_11_26
* NET  1809 = cpuregs_11_25
* NET  1810 = cpuregs_11_24
* NET  1811 = cpuregs_11_23
* NET  1812 = cpuregs_11_22
* NET  1813 = cpuregs_11_21
* NET  1814 = cpuregs_11_20
* NET  1815 = cpuregs_11_2
* NET  1816 = cpuregs_11_19
* NET  1817 = cpuregs_11_18
* NET  1818 = cpuregs_11_17
* NET  1819 = cpuregs_11_16
* NET  1820 = cpuregs_11_15
* NET  1821 = cpuregs_11_14
* NET  1822 = cpuregs_11_13
* NET  1823 = cpuregs_11_12
* NET  1824 = cpuregs_11_11
* NET  1825 = cpuregs_11_10
* NET  1826 = cpuregs_11_1
* NET  1827 = cpuregs_11_0
* NET  1828 = cpuregs_10_9
* NET  1829 = cpuregs_10_8
* NET  1830 = cpuregs_10_7
* NET  1831 = cpuregs_10_6
* NET  1832 = cpuregs_10_5
* NET  1833 = cpuregs_10_4
* NET  1834 = cpuregs_10_31
* NET  1835 = cpuregs_10_30
* NET  1836 = cpuregs_10_3
* NET  1837 = cpuregs_10_29
* NET  1838 = cpuregs_10_28
* NET  1839 = cpuregs_10_27
* NET  1840 = cpuregs_10_26
* NET  1841 = cpuregs_10_25
* NET  1842 = cpuregs_10_24
* NET  1843 = cpuregs_10_23
* NET  1844 = cpuregs_10_22
* NET  1845 = cpuregs_10_21
* NET  1846 = cpuregs_10_20
* NET  1847 = cpuregs_10_2
* NET  1848 = cpuregs_10_19
* NET  1849 = cpuregs_10_18
* NET  1850 = cpuregs_10_17
* NET  1851 = cpuregs_10_16
* NET  1852 = cpuregs_10_15
* NET  1853 = cpuregs_10_14
* NET  1854 = cpuregs_10_13
* NET  1855 = cpuregs_10_12
* NET  1856 = cpuregs_10_11
* NET  1857 = cpuregs_10_10
* NET  1858 = cpuregs_10_1
* NET  1859 = cpuregs_10_0
* NET  1860 = cpuregs_0_9
* NET  1861 = cpuregs_0_8
* NET  1862 = cpuregs_0_7
* NET  1863 = cpuregs_0_6
* NET  1864 = cpuregs_0_5
* NET  1865 = cpuregs_0_4
* NET  1866 = cpuregs_0_31
* NET  1867 = cpuregs_0_30
* NET  1868 = cpuregs_0_3
* NET  1869 = cpuregs_0_29
* NET  1870 = cpuregs_0_28
* NET  1871 = cpuregs_0_27
* NET  1872 = cpuregs_0_26
* NET  1873 = cpuregs_0_25
* NET  1874 = cpuregs_0_24
* NET  1875 = cpuregs_0_23
* NET  1876 = cpuregs_0_22
* NET  1877 = cpuregs_0_21
* NET  1878 = cpuregs_0_20
* NET  1879 = cpuregs_0_2
* NET  1880 = cpuregs_0_19
* NET  1881 = cpuregs_0_18
* NET  1882 = cpuregs_0_17
* NET  1883 = cpuregs_0_16
* NET  1884 = cpuregs_0_15
* NET  1885 = cpuregs_0_14
* NET  1886 = cpuregs_0_13
* NET  1887 = cpuregs_0_12
* NET  1888 = cpuregs_0_11
* NET  1889 = cpuregs_0_10
* NET  1890 = cpuregs_0_1
* NET  1891 = cpuregs_0_0
* NET  1892 = cpu_state_bit6_hfns_3
* NET  1893 = cpu_state_bit6_hfns_2
* NET  1894 = cpu_state_bit6_hfns_1
* NET  1895 = cpu_state_bit6_hfns_0
* NET  1896 = cpu_state_bit4_hfns_3
* NET  1897 = cpu_state_bit4_hfns_2
* NET  1898 = cpu_state_bit4_hfns_1
* NET  1899 = cpu_state_bit4_hfns_0
* NET  1900 = cpu_state_bit3_hfns_3
* NET  1901 = cpu_state_bit3_hfns_2
* NET  1902 = cpu_state_bit3_hfns_1
* NET  1903 = cpu_state_bit3_hfns_0
* NET  1904 = cpu_state_bit2_hfns_2
* NET  1905 = cpu_state_bit2_hfns_1
* NET  1906 = cpu_state_bit2_hfns_0
* NET  1907 = cpu_state[6]
* NET  1908 = cpu_state[5]
* NET  1909 = cpu_state[4]
* NET  1910 = cpu_state[3]
* NET  1911 = cpu_state[2]
* NET  1912 = cpu_state[1]
* NET  1913 = cpu_state[0]
* NET  1914 = count_instr[9]
* NET  1915 = count_instr[8]
* NET  1916 = count_instr[7]
* NET  1917 = count_instr[63]
* NET  1918 = count_instr[62]
* NET  1919 = count_instr[61]
* NET  1920 = count_instr[60]
* NET  1921 = count_instr[6]
* NET  1922 = count_instr[59]
* NET  1923 = count_instr[58]
* NET  1924 = count_instr[57]
* NET  1925 = count_instr[56]
* NET  1926 = count_instr[55]
* NET  1927 = count_instr[54]
* NET  1928 = count_instr[53]
* NET  1929 = count_instr[52]
* NET  1930 = count_instr[51]
* NET  1931 = count_instr[50]
* NET  1932 = count_instr[5]
* NET  1933 = count_instr[49]
* NET  1934 = count_instr[48]
* NET  1935 = count_instr[47]
* NET  1936 = count_instr[46]
* NET  1937 = count_instr[45]
* NET  1938 = count_instr[44]
* NET  1939 = count_instr[43]
* NET  1940 = count_instr[42]
* NET  1941 = count_instr[41]
* NET  1942 = count_instr[40]
* NET  1943 = count_instr[4]
* NET  1944 = count_instr[39]
* NET  1945 = count_instr[38]
* NET  1946 = count_instr[37]
* NET  1947 = count_instr[36]
* NET  1948 = count_instr[35]
* NET  1949 = count_instr[34]
* NET  1950 = count_instr[33]
* NET  1951 = count_instr[32]
* NET  1952 = count_instr[31]
* NET  1953 = count_instr[30]
* NET  1954 = count_instr[3]
* NET  1955 = count_instr[29]
* NET  1956 = count_instr[28]
* NET  1957 = count_instr[27]
* NET  1958 = count_instr[26]
* NET  1959 = count_instr[25]
* NET  1960 = count_instr[24]
* NET  1961 = count_instr[23]
* NET  1962 = count_instr[22]
* NET  1963 = count_instr[21]
* NET  1964 = count_instr[20]
* NET  1965 = count_instr[2]
* NET  1966 = count_instr[19]
* NET  1967 = count_instr[18]
* NET  1968 = count_instr[17]
* NET  1969 = count_instr[16]
* NET  1970 = count_instr[15]
* NET  1971 = count_instr[14]
* NET  1972 = count_instr[13]
* NET  1973 = count_instr[12]
* NET  1974 = count_instr[11]
* NET  1975 = count_instr[10]
* NET  1976 = count_instr[1]
* NET  1977 = count_instr[0]
* NET  1978 = count_cycle[9]
* NET  1979 = count_cycle[8]
* NET  1980 = count_cycle[7]
* NET  1981 = count_cycle[63]
* NET  1982 = count_cycle[62]
* NET  1983 = count_cycle[61]
* NET  1984 = count_cycle[60]
* NET  1985 = count_cycle[6]
* NET  1986 = count_cycle[59]
* NET  1987 = count_cycle[58]
* NET  1988 = count_cycle[57]
* NET  1989 = count_cycle[56]
* NET  1990 = count_cycle[55]
* NET  1991 = count_cycle[54]
* NET  1992 = count_cycle[53]
* NET  1993 = count_cycle[52]
* NET  1994 = count_cycle[51]
* NET  1995 = count_cycle[50]
* NET  1996 = count_cycle[5]
* NET  1997 = count_cycle[49]
* NET  1998 = count_cycle[48]
* NET  1999 = count_cycle[47]
* NET  2000 = count_cycle[46]
* NET  2001 = count_cycle[45]
* NET  2002 = count_cycle[44]
* NET  2003 = count_cycle[43]
* NET  2004 = count_cycle[42]
* NET  2005 = count_cycle[41]
* NET  2006 = count_cycle[40]
* NET  2007 = count_cycle[4]
* NET  2008 = count_cycle[39]
* NET  2009 = count_cycle[38]
* NET  2010 = count_cycle[37]
* NET  2011 = count_cycle[36]
* NET  2012 = count_cycle[35]
* NET  2013 = count_cycle[34]
* NET  2014 = count_cycle[33]
* NET  2015 = count_cycle[32]
* NET  2016 = count_cycle[31]
* NET  2017 = count_cycle[30]
* NET  2018 = count_cycle[3]
* NET  2019 = count_cycle[29]
* NET  2020 = count_cycle[28]
* NET  2021 = count_cycle[27]
* NET  2022 = count_cycle[26]
* NET  2023 = count_cycle[25]
* NET  2024 = count_cycle[24]
* NET  2025 = count_cycle[23]
* NET  2026 = count_cycle[22]
* NET  2027 = count_cycle[21]
* NET  2028 = count_cycle[20]
* NET  2029 = count_cycle[2]
* NET  2030 = count_cycle[19]
* NET  2031 = count_cycle[18]
* NET  2032 = count_cycle[17]
* NET  2033 = count_cycle[16]
* NET  2034 = count_cycle[15]
* NET  2035 = count_cycle[14]
* NET  2036 = count_cycle[13]
* NET  2037 = count_cycle[12]
* NET  2038 = count_cycle[11]
* NET  2039 = count_cycle[10]
* NET  2040 = count_cycle[1]
* NET  2041 = count_cycle[0]
* NET  2042 = clk_root_tr_tr_tr_2
* NET  2043 = clk_root_tr_tr_tr_1
* NET  2044 = clk_root_tr_tr_tr_0
* NET  2045 = clk_root_tr_tr_tl_2
* NET  2046 = clk_root_tr_tr_tl_1
* NET  2047 = clk_root_tr_tr_tl_0
* NET  2048 = clk_root_tr_tr_br_2
* NET  2049 = clk_root_tr_tr_br_1
* NET  2050 = clk_root_tr_tr_br_0
* NET  2051 = clk_root_tr_tr_bl_2
* NET  2052 = clk_root_tr_tr_bl_1
* NET  2053 = clk_root_tr_tr_bl_0
* NET  2054 = clk_root_tr_tr_0
* NET  2055 = clk_root_tr_tl_tr_2
* NET  2056 = clk_root_tr_tl_tr_1
* NET  2057 = clk_root_tr_tl_tr_0
* NET  2058 = clk_root_tr_tl_tl_2
* NET  2059 = clk_root_tr_tl_tl_1
* NET  2060 = clk_root_tr_tl_tl_0
* NET  2061 = clk_root_tr_tl_br_2
* NET  2062 = clk_root_tr_tl_br_1
* NET  2063 = clk_root_tr_tl_br_0
* NET  2064 = clk_root_tr_tl_bl_2
* NET  2065 = clk_root_tr_tl_bl_1
* NET  2066 = clk_root_tr_tl_bl_0
* NET  2067 = clk_root_tr_tl_0
* NET  2068 = clk_root_tr_br_tr_2
* NET  2069 = clk_root_tr_br_tr_1
* NET  2070 = clk_root_tr_br_tr_0
* NET  2071 = clk_root_tr_br_tl_2
* NET  2072 = clk_root_tr_br_tl_1
* NET  2073 = clk_root_tr_br_tl_0
* NET  2074 = clk_root_tr_br_br_2
* NET  2075 = clk_root_tr_br_br_1
* NET  2076 = clk_root_tr_br_br_0
* NET  2077 = clk_root_tr_br_bl_2
* NET  2078 = clk_root_tr_br_bl_1
* NET  2079 = clk_root_tr_br_bl_0
* NET  2080 = clk_root_tr_br_0
* NET  2081 = clk_root_tr_bl_tr_2
* NET  2082 = clk_root_tr_bl_tr_1
* NET  2083 = clk_root_tr_bl_tr_0
* NET  2084 = clk_root_tr_bl_tl_2
* NET  2085 = clk_root_tr_bl_tl_1
* NET  2086 = clk_root_tr_bl_tl_0
* NET  2087 = clk_root_tr_bl_br_2
* NET  2088 = clk_root_tr_bl_br_1
* NET  2089 = clk_root_tr_bl_br_0
* NET  2090 = clk_root_tr_bl_bl_2
* NET  2091 = clk_root_tr_bl_bl_1
* NET  2092 = clk_root_tr_bl_bl_0
* NET  2093 = clk_root_tr_bl_0
* NET  2094 = clk_root_tr_0
* NET  2095 = clk_root_tl_tr_tr_2
* NET  2096 = clk_root_tl_tr_tr_1
* NET  2097 = clk_root_tl_tr_tr_0
* NET  2098 = clk_root_tl_tr_tl_2
* NET  2099 = clk_root_tl_tr_tl_1
* NET  2100 = clk_root_tl_tr_tl_0
* NET  2101 = clk_root_tl_tr_br_2
* NET  2102 = clk_root_tl_tr_br_1
* NET  2103 = clk_root_tl_tr_br_0
* NET  2104 = clk_root_tl_tr_bl_2
* NET  2105 = clk_root_tl_tr_bl_1
* NET  2106 = clk_root_tl_tr_bl_0
* NET  2107 = clk_root_tl_tr_0
* NET  2108 = clk_root_tl_tl_tr_2
* NET  2109 = clk_root_tl_tl_tr_1
* NET  2110 = clk_root_tl_tl_tr_0
* NET  2111 = clk_root_tl_tl_tl_2
* NET  2112 = clk_root_tl_tl_tl_1
* NET  2113 = clk_root_tl_tl_tl_0
* NET  2114 = clk_root_tl_tl_br_2
* NET  2115 = clk_root_tl_tl_br_1
* NET  2116 = clk_root_tl_tl_br_0
* NET  2117 = clk_root_tl_tl_bl_2
* NET  2118 = clk_root_tl_tl_bl_1
* NET  2119 = clk_root_tl_tl_bl_0
* NET  2120 = clk_root_tl_tl_0
* NET  2121 = clk_root_tl_br_tr_2
* NET  2122 = clk_root_tl_br_tr_1
* NET  2123 = clk_root_tl_br_tr_0
* NET  2124 = clk_root_tl_br_tl_2
* NET  2125 = clk_root_tl_br_tl_1
* NET  2126 = clk_root_tl_br_tl_0
* NET  2127 = clk_root_tl_br_br_2
* NET  2128 = clk_root_tl_br_br_1
* NET  2129 = clk_root_tl_br_br_0
* NET  2130 = clk_root_tl_br_bl_2
* NET  2131 = clk_root_tl_br_bl_1
* NET  2132 = clk_root_tl_br_bl_0
* NET  2133 = clk_root_tl_br_0
* NET  2134 = clk_root_tl_bl_tr_2
* NET  2135 = clk_root_tl_bl_tr_1
* NET  2136 = clk_root_tl_bl_tr_0
* NET  2137 = clk_root_tl_bl_tl_2
* NET  2138 = clk_root_tl_bl_tl_1
* NET  2139 = clk_root_tl_bl_tl_0
* NET  2140 = clk_root_tl_bl_br_2
* NET  2141 = clk_root_tl_bl_br_1
* NET  2142 = clk_root_tl_bl_br_0
* NET  2143 = clk_root_tl_bl_bl_2
* NET  2144 = clk_root_tl_bl_bl_1
* NET  2145 = clk_root_tl_bl_bl_0
* NET  2146 = clk_root_tl_bl_0
* NET  2147 = clk_root_tl_0
* NET  2148 = clk_root_br_tr_tr_2
* NET  2149 = clk_root_br_tr_tr_1
* NET  2150 = clk_root_br_tr_tr_0
* NET  2151 = clk_root_br_tr_tl_2
* NET  2152 = clk_root_br_tr_tl_1
* NET  2153 = clk_root_br_tr_tl_0
* NET  2154 = clk_root_br_tr_br_2
* NET  2155 = clk_root_br_tr_br_1
* NET  2156 = clk_root_br_tr_br_0
* NET  2157 = clk_root_br_tr_bl_2
* NET  2158 = clk_root_br_tr_bl_1
* NET  2159 = clk_root_br_tr_bl_0
* NET  2160 = clk_root_br_tr_0
* NET  2161 = clk_root_br_tl_tr_2
* NET  2162 = clk_root_br_tl_tr_1
* NET  2163 = clk_root_br_tl_tr_0
* NET  2164 = clk_root_br_tl_tl_2
* NET  2165 = clk_root_br_tl_tl_1
* NET  2166 = clk_root_br_tl_tl_0
* NET  2167 = clk_root_br_tl_br_2
* NET  2168 = clk_root_br_tl_br_1
* NET  2169 = clk_root_br_tl_br_0
* NET  2170 = clk_root_br_tl_bl_2
* NET  2171 = clk_root_br_tl_bl_1
* NET  2172 = clk_root_br_tl_bl_0
* NET  2173 = clk_root_br_tl_0
* NET  2174 = clk_root_br_br_tr_2
* NET  2175 = clk_root_br_br_tr_1
* NET  2176 = clk_root_br_br_tr_0
* NET  2177 = clk_root_br_br_tl_2
* NET  2178 = clk_root_br_br_tl_1
* NET  2179 = clk_root_br_br_tl_0
* NET  2180 = clk_root_br_br_br_2
* NET  2181 = clk_root_br_br_br_1
* NET  2182 = clk_root_br_br_br_0
* NET  2183 = clk_root_br_br_bl_2
* NET  2184 = clk_root_br_br_bl_1
* NET  2185 = clk_root_br_br_bl_0
* NET  2186 = clk_root_br_br_0
* NET  2187 = clk_root_br_bl_tr_2
* NET  2188 = clk_root_br_bl_tr_1
* NET  2189 = clk_root_br_bl_tr_0
* NET  2190 = clk_root_br_bl_tl_2
* NET  2191 = clk_root_br_bl_tl_1
* NET  2192 = clk_root_br_bl_tl_0
* NET  2193 = clk_root_br_bl_br_2
* NET  2194 = clk_root_br_bl_br_1
* NET  2195 = clk_root_br_bl_br_0
* NET  2196 = clk_root_br_bl_bl_2
* NET  2197 = clk_root_br_bl_bl_1
* NET  2198 = clk_root_br_bl_bl_0
* NET  2199 = clk_root_br_bl_0
* NET  2200 = clk_root_br_0
* NET  2201 = clk_root_bl_tr_tr_2
* NET  2202 = clk_root_bl_tr_tr_1
* NET  2203 = clk_root_bl_tr_tr_0
* NET  2204 = clk_root_bl_tr_tl_2
* NET  2205 = clk_root_bl_tr_tl_1
* NET  2206 = clk_root_bl_tr_tl_0
* NET  2207 = clk_root_bl_tr_br_2
* NET  2208 = clk_root_bl_tr_br_1
* NET  2209 = clk_root_bl_tr_br_0
* NET  2210 = clk_root_bl_tr_bl_2
* NET  2211 = clk_root_bl_tr_bl_1
* NET  2212 = clk_root_bl_tr_bl_0
* NET  2213 = clk_root_bl_tr_0
* NET  2214 = clk_root_bl_tl_tr_2
* NET  2215 = clk_root_bl_tl_tr_1
* NET  2216 = clk_root_bl_tl_tr_0
* NET  2217 = clk_root_bl_tl_tl_2
* NET  2218 = clk_root_bl_tl_tl_1
* NET  2219 = clk_root_bl_tl_tl_0
* NET  2220 = clk_root_bl_tl_br_2
* NET  2221 = clk_root_bl_tl_br_1
* NET  2222 = clk_root_bl_tl_br_0
* NET  2223 = clk_root_bl_tl_bl_2
* NET  2224 = clk_root_bl_tl_bl_1
* NET  2225 = clk_root_bl_tl_bl_0
* NET  2226 = clk_root_bl_tl_0
* NET  2227 = clk_root_bl_br_tr_2
* NET  2228 = clk_root_bl_br_tr_1
* NET  2229 = clk_root_bl_br_tr_0
* NET  2230 = clk_root_bl_br_tl_2
* NET  2231 = clk_root_bl_br_tl_1
* NET  2232 = clk_root_bl_br_tl_0
* NET  2233 = clk_root_bl_br_br_2
* NET  2234 = clk_root_bl_br_br_1
* NET  2235 = clk_root_bl_br_br_0
* NET  2236 = clk_root_bl_br_bl_2
* NET  2237 = clk_root_bl_br_bl_1
* NET  2238 = clk_root_bl_br_bl_0
* NET  2239 = clk_root_bl_br_0
* NET  2240 = clk_root_bl_bl_tr_2
* NET  2241 = clk_root_bl_bl_tr_1
* NET  2242 = clk_root_bl_bl_tr_0
* NET  2243 = clk_root_bl_bl_tl_2
* NET  2244 = clk_root_bl_bl_tl_1
* NET  2245 = clk_root_bl_bl_tl_0
* NET  2246 = clk_root_bl_bl_br_2
* NET  2247 = clk_root_bl_bl_br_1
* NET  2248 = clk_root_bl_bl_br_0
* NET  2249 = clk_root_bl_bl_bl_2
* NET  2250 = clk_root_bl_bl_bl_1
* NET  2251 = clk_root_bl_bl_bl_0
* NET  2252 = clk_root_bl_bl_0
* NET  2253 = clk_root_bl_0
* NET  2254 = clk_root_0
* NET  2255 = clk
* NET  2256 = blockagenet
* NET  2257 = alu_out_q[9]
* NET  2258 = alu_out_q[8]
* NET  2259 = alu_out_q[7]
* NET  2260 = alu_out_q[6]
* NET  2261 = alu_out_q[5]
* NET  2262 = alu_out_q[4]
* NET  2263 = alu_out_q[31]
* NET  2264 = alu_out_q[30]
* NET  2265 = alu_out_q[3]
* NET  2266 = alu_out_q[29]
* NET  2267 = alu_out_q[28]
* NET  2268 = alu_out_q[27]
* NET  2269 = alu_out_q[26]
* NET  2270 = alu_out_q[25]
* NET  2271 = alu_out_q[24]
* NET  2272 = alu_out_q[23]
* NET  2273 = alu_out_q[22]
* NET  2274 = alu_out_q[21]
* NET  2275 = alu_out_q[20]
* NET  2276 = alu_out_q[2]
* NET  2277 = alu_out_q[19]
* NET  2278 = alu_out_q[18]
* NET  2279 = alu_out_q[17]
* NET  2280 = alu_out_q[16]
* NET  2281 = alu_out_q[15]
* NET  2282 = alu_out_q[14]
* NET  2283 = alu_out_q[13]
* NET  2284 = alu_out_q[12]
* NET  2285 = alu_out_q[11]
* NET  2286 = alu_out_q[10]
* NET  2287 = alu_out_q[1]
* NET  2288 = alu_out_q[0]
* NET  2289 = alu_out[9]
* NET  2290 = alu_out[8]
* NET  2291 = alu_out[7]
* NET  2292 = alu_out[6]
* NET  2293 = alu_out[5]
* NET  2294 = alu_out[4]
* NET  2295 = alu_out[31]
* NET  2296 = alu_out[30]
* NET  2297 = alu_out[3]
* NET  2298 = alu_out[29]
* NET  2299 = alu_out[28]
* NET  2300 = alu_out[27]
* NET  2301 = alu_out[26]
* NET  2302 = alu_out[25]
* NET  2303 = alu_out[24]
* NET  2304 = alu_out[23]
* NET  2305 = alu_out[22]
* NET  2306 = alu_out[21]
* NET  2307 = alu_out[20]
* NET  2308 = alu_out[2]
* NET  2309 = alu_out[19]
* NET  2310 = alu_out[18]
* NET  2311 = alu_out[17]
* NET  2312 = alu_out[16]
* NET  2313 = alu_out[15]
* NET  2314 = alu_out[14]
* NET  2315 = alu_out[13]
* NET  2316 = alu_out[12]
* NET  2317 = alu_out[11]
* NET  2318 = alu_out[10]
* NET  2319 = alu_out[1]
* NET  2320 = alu_out[0]
* NET  2321 = abc_30082_new_n9999
* NET  2322 = abc_30082_new_n9998
* NET  2323 = abc_30082_new_n9997
* NET  2324 = abc_30082_new_n9996
* NET  2325 = abc_30082_new_n9995
* NET  2326 = abc_30082_new_n9994
* NET  2327 = abc_30082_new_n9993
* NET  2328 = abc_30082_new_n9992
* NET  2329 = abc_30082_new_n9991
* NET  2330 = abc_30082_new_n9990
* NET  2331 = abc_30082_new_n9989
* NET  2332 = abc_30082_new_n9988
* NET  2333 = abc_30082_new_n9987
* NET  2334 = abc_30082_new_n9986
* NET  2335 = abc_30082_new_n9985
* NET  2336 = abc_30082_new_n9984
* NET  2337 = abc_30082_new_n9983
* NET  2338 = abc_30082_new_n9982
* NET  2339 = abc_30082_new_n9981
* NET  2340 = abc_30082_new_n9980
* NET  2341 = abc_30082_new_n9979
* NET  2342 = abc_30082_new_n9978
* NET  2343 = abc_30082_new_n9977
* NET  2344 = abc_30082_new_n9976
* NET  2345 = abc_30082_new_n9975
* NET  2346 = abc_30082_new_n9974
* NET  2347 = abc_30082_new_n9973
* NET  2348 = abc_30082_new_n9972
* NET  2349 = abc_30082_new_n9971
* NET  2350 = abc_30082_new_n9969
* NET  2351 = abc_30082_new_n9968
* NET  2352 = abc_30082_new_n9967
* NET  2353 = abc_30082_new_n9966
* NET  2354 = abc_30082_new_n9965
* NET  2355 = abc_30082_new_n9964
* NET  2356 = abc_30082_new_n9963
* NET  2357 = abc_30082_new_n9962
* NET  2358 = abc_30082_new_n9961
* NET  2359 = abc_30082_new_n9960
* NET  2360 = abc_30082_new_n9959
* NET  2361 = abc_30082_new_n9958
* NET  2362 = abc_30082_new_n9957
* NET  2363 = abc_30082_new_n9956
* NET  2364 = abc_30082_new_n9955
* NET  2365 = abc_30082_new_n9954
* NET  2366 = abc_30082_new_n9953
* NET  2367 = abc_30082_new_n9952
* NET  2368 = abc_30082_new_n9951
* NET  2369 = abc_30082_new_n9950
* NET  2370 = abc_30082_new_n9949
* NET  2371 = abc_30082_new_n9948
* NET  2372 = abc_30082_new_n9947
* NET  2373 = abc_30082_new_n9946
* NET  2374 = abc_30082_new_n9945
* NET  2375 = abc_30082_new_n9944
* NET  2376 = abc_30082_new_n9943
* NET  2377 = abc_30082_new_n9942
* NET  2378 = abc_30082_new_n9941
* NET  2379 = abc_30082_new_n9940
* NET  2380 = abc_30082_new_n9939
* NET  2381 = abc_30082_new_n9938
* NET  2382 = abc_30082_new_n9937
* NET  2383 = abc_30082_new_n9936
* NET  2384 = abc_30082_new_n9935
* NET  2385 = abc_30082_new_n9933
* NET  2386 = abc_30082_new_n9932
* NET  2387 = abc_30082_new_n9931
* NET  2388 = abc_30082_new_n9930
* NET  2389 = abc_30082_new_n9929
* NET  2390 = abc_30082_new_n9928
* NET  2391 = abc_30082_new_n9927
* NET  2392 = abc_30082_new_n9926
* NET  2393 = abc_30082_new_n9925
* NET  2394 = abc_30082_new_n9924
* NET  2395 = abc_30082_new_n9923
* NET  2396 = abc_30082_new_n9922
* NET  2397 = abc_30082_new_n9921
* NET  2398 = abc_30082_new_n9920
* NET  2399 = abc_30082_new_n9919
* NET  2400 = abc_30082_new_n9918
* NET  2401 = abc_30082_new_n9917
* NET  2402 = abc_30082_new_n9916
* NET  2403 = abc_30082_new_n9915
* NET  2404 = abc_30082_new_n9914
* NET  2405 = abc_30082_new_n9913
* NET  2406 = abc_30082_new_n9912
* NET  2407 = abc_30082_new_n9911
* NET  2408 = abc_30082_new_n9910
* NET  2409 = abc_30082_new_n9909
* NET  2410 = abc_30082_new_n9908
* NET  2411 = abc_30082_new_n9907
* NET  2412 = abc_30082_new_n9906
* NET  2413 = abc_30082_new_n9905
* NET  2414 = abc_30082_new_n9904
* NET  2415 = abc_30082_new_n9903
* NET  2416 = abc_30082_new_n9902
* NET  2417 = abc_30082_new_n9901
* NET  2418 = abc_30082_new_n9900
* NET  2419 = abc_30082_new_n9899
* NET  2420 = abc_30082_new_n9897
* NET  2421 = abc_30082_new_n9896
* NET  2422 = abc_30082_new_n9895
* NET  2423 = abc_30082_new_n9894
* NET  2424 = abc_30082_new_n9893
* NET  2425 = abc_30082_new_n9892
* NET  2426 = abc_30082_new_n9891
* NET  2427 = abc_30082_new_n9890
* NET  2428 = abc_30082_new_n9889
* NET  2429 = abc_30082_new_n9888
* NET  2430 = abc_30082_new_n9887
* NET  2431 = abc_30082_new_n9886
* NET  2432 = abc_30082_new_n9885
* NET  2433 = abc_30082_new_n9884
* NET  2434 = abc_30082_new_n9883
* NET  2435 = abc_30082_new_n9882
* NET  2436 = abc_30082_new_n9881
* NET  2437 = abc_30082_new_n9880
* NET  2438 = abc_30082_new_n9879
* NET  2439 = abc_30082_new_n9878
* NET  2440 = abc_30082_new_n9877
* NET  2441 = abc_30082_new_n9876
* NET  2442 = abc_30082_new_n9875
* NET  2443 = abc_30082_new_n9874
* NET  2444 = abc_30082_new_n9873
* NET  2445 = abc_30082_new_n9872
* NET  2446 = abc_30082_new_n9871
* NET  2447 = abc_30082_new_n9870
* NET  2448 = abc_30082_new_n9869
* NET  2449 = abc_30082_new_n9868
* NET  2450 = abc_30082_new_n9867
* NET  2451 = abc_30082_new_n9866
* NET  2452 = abc_30082_new_n9865
* NET  2453 = abc_30082_new_n9864
* NET  2454 = abc_30082_new_n9863
* NET  2455 = abc_30082_new_n9861
* NET  2456 = abc_30082_new_n9860
* NET  2457 = abc_30082_new_n9859
* NET  2458 = abc_30082_new_n9858
* NET  2459 = abc_30082_new_n9857
* NET  2460 = abc_30082_new_n9856
* NET  2461 = abc_30082_new_n9855
* NET  2462 = abc_30082_new_n9854
* NET  2463 = abc_30082_new_n9853
* NET  2464 = abc_30082_new_n9852
* NET  2465 = abc_30082_new_n9851
* NET  2466 = abc_30082_new_n9850
* NET  2467 = abc_30082_new_n9849
* NET  2468 = abc_30082_new_n9848
* NET  2469 = abc_30082_new_n9847
* NET  2470 = abc_30082_new_n9846
* NET  2471 = abc_30082_new_n9845
* NET  2472 = abc_30082_new_n9844
* NET  2473 = abc_30082_new_n9843
* NET  2474 = abc_30082_new_n9842
* NET  2475 = abc_30082_new_n9841
* NET  2476 = abc_30082_new_n9840
* NET  2477 = abc_30082_new_n9839
* NET  2478 = abc_30082_new_n9838
* NET  2479 = abc_30082_new_n9837
* NET  2480 = abc_30082_new_n9836
* NET  2481 = abc_30082_new_n9835
* NET  2482 = abc_30082_new_n9834
* NET  2483 = abc_30082_new_n9833
* NET  2484 = abc_30082_new_n9832
* NET  2485 = abc_30082_new_n9831
* NET  2486 = abc_30082_new_n9830
* NET  2487 = abc_30082_new_n9829
* NET  2488 = abc_30082_new_n9828
* NET  2489 = abc_30082_new_n9827
* NET  2490 = abc_30082_new_n9825
* NET  2491 = abc_30082_new_n9824
* NET  2492 = abc_30082_new_n9823
* NET  2493 = abc_30082_new_n9822
* NET  2494 = abc_30082_new_n9821
* NET  2495 = abc_30082_new_n9820
* NET  2496 = abc_30082_new_n9819
* NET  2497 = abc_30082_new_n9818
* NET  2498 = abc_30082_new_n9817
* NET  2499 = abc_30082_new_n9816
* NET  2500 = abc_30082_new_n9815
* NET  2501 = abc_30082_new_n9814
* NET  2502 = abc_30082_new_n9813
* NET  2503 = abc_30082_new_n9812
* NET  2504 = abc_30082_new_n9811
* NET  2505 = abc_30082_new_n9810
* NET  2506 = abc_30082_new_n9809
* NET  2507 = abc_30082_new_n9808
* NET  2508 = abc_30082_new_n9807
* NET  2509 = abc_30082_new_n9806
* NET  2510 = abc_30082_new_n9805
* NET  2511 = abc_30082_new_n9804
* NET  2512 = abc_30082_new_n9803
* NET  2513 = abc_30082_new_n9802
* NET  2514 = abc_30082_new_n9801
* NET  2515 = abc_30082_new_n9800
* NET  2516 = abc_30082_new_n9799
* NET  2517 = abc_30082_new_n9798
* NET  2518 = abc_30082_new_n9797
* NET  2519 = abc_30082_new_n9796
* NET  2520 = abc_30082_new_n9795
* NET  2521 = abc_30082_new_n9794
* NET  2522 = abc_30082_new_n9793
* NET  2523 = abc_30082_new_n9792
* NET  2524 = abc_30082_new_n9791
* NET  2525 = abc_30082_new_n9789
* NET  2526 = abc_30082_new_n9788
* NET  2527 = abc_30082_new_n9787
* NET  2528 = abc_30082_new_n9786
* NET  2529 = abc_30082_new_n9785
* NET  2530 = abc_30082_new_n9784
* NET  2531 = abc_30082_new_n9783
* NET  2532 = abc_30082_new_n9782
* NET  2533 = abc_30082_new_n9781
* NET  2534 = abc_30082_new_n9780
* NET  2535 = abc_30082_new_n9779
* NET  2536 = abc_30082_new_n9778
* NET  2537 = abc_30082_new_n9777
* NET  2538 = abc_30082_new_n9776
* NET  2539 = abc_30082_new_n9775
* NET  2540 = abc_30082_new_n9774
* NET  2541 = abc_30082_new_n9773
* NET  2542 = abc_30082_new_n9772
* NET  2543 = abc_30082_new_n9771
* NET  2544 = abc_30082_new_n9770
* NET  2545 = abc_30082_new_n9769
* NET  2546 = abc_30082_new_n9768
* NET  2547 = abc_30082_new_n9767
* NET  2548 = abc_30082_new_n9766
* NET  2549 = abc_30082_new_n9765
* NET  2550 = abc_30082_new_n9764
* NET  2551 = abc_30082_new_n9763
* NET  2552 = abc_30082_new_n9762
* NET  2553 = abc_30082_new_n9761
* NET  2554 = abc_30082_new_n9760
* NET  2555 = abc_30082_new_n9759
* NET  2556 = abc_30082_new_n9758
* NET  2557 = abc_30082_new_n9757
* NET  2558 = abc_30082_new_n9756
* NET  2559 = abc_30082_new_n9755
* NET  2560 = abc_30082_new_n9753
* NET  2561 = abc_30082_new_n9752
* NET  2562 = abc_30082_new_n9751
* NET  2563 = abc_30082_new_n9750
* NET  2564 = abc_30082_new_n9749
* NET  2565 = abc_30082_new_n9748
* NET  2566 = abc_30082_new_n9747
* NET  2567 = abc_30082_new_n9746
* NET  2568 = abc_30082_new_n9745
* NET  2569 = abc_30082_new_n9744
* NET  2570 = abc_30082_new_n9743
* NET  2571 = abc_30082_new_n9742
* NET  2572 = abc_30082_new_n9741
* NET  2573 = abc_30082_new_n9740
* NET  2574 = abc_30082_new_n9739
* NET  2575 = abc_30082_new_n9738
* NET  2576 = abc_30082_new_n9737
* NET  2577 = abc_30082_new_n9736
* NET  2578 = abc_30082_new_n9735
* NET  2579 = abc_30082_new_n9734
* NET  2580 = abc_30082_new_n9733
* NET  2581 = abc_30082_new_n9732
* NET  2582 = abc_30082_new_n9731
* NET  2583 = abc_30082_new_n9730
* NET  2584 = abc_30082_new_n9729
* NET  2585 = abc_30082_new_n9728
* NET  2586 = abc_30082_new_n9727
* NET  2587 = abc_30082_new_n9726
* NET  2588 = abc_30082_new_n9725
* NET  2589 = abc_30082_new_n9724
* NET  2590 = abc_30082_new_n9723
* NET  2591 = abc_30082_new_n9722
* NET  2592 = abc_30082_new_n9721
* NET  2593 = abc_30082_new_n9720
* NET  2594 = abc_30082_new_n9719
* NET  2595 = abc_30082_new_n9717
* NET  2596 = abc_30082_new_n9716
* NET  2597 = abc_30082_new_n9715
* NET  2598 = abc_30082_new_n9714
* NET  2599 = abc_30082_new_n9713
* NET  2600 = abc_30082_new_n9712
* NET  2601 = abc_30082_new_n9711
* NET  2602 = abc_30082_new_n9710
* NET  2603 = abc_30082_new_n9709
* NET  2604 = abc_30082_new_n9708
* NET  2605 = abc_30082_new_n9707
* NET  2606 = abc_30082_new_n9706
* NET  2607 = abc_30082_new_n9705
* NET  2608 = abc_30082_new_n9704
* NET  2609 = abc_30082_new_n9703
* NET  2610 = abc_30082_new_n9702
* NET  2611 = abc_30082_new_n9701
* NET  2612 = abc_30082_new_n9700
* NET  2613 = abc_30082_new_n9699
* NET  2614 = abc_30082_new_n9698
* NET  2615 = abc_30082_new_n9697
* NET  2616 = abc_30082_new_n9696
* NET  2617 = abc_30082_new_n9695
* NET  2618 = abc_30082_new_n9694
* NET  2619 = abc_30082_new_n9693
* NET  2620 = abc_30082_new_n9692
* NET  2621 = abc_30082_new_n9691
* NET  2622 = abc_30082_new_n9690
* NET  2623 = abc_30082_new_n9689
* NET  2624 = abc_30082_new_n9688
* NET  2625 = abc_30082_new_n9687
* NET  2626 = abc_30082_new_n9686
* NET  2627 = abc_30082_new_n9685
* NET  2628 = abc_30082_new_n9684
* NET  2629 = abc_30082_new_n9683
* NET  2630 = abc_30082_new_n9681
* NET  2631 = abc_30082_new_n9680
* NET  2632 = abc_30082_new_n9679
* NET  2633 = abc_30082_new_n9678
* NET  2634 = abc_30082_new_n9677
* NET  2635 = abc_30082_new_n9676
* NET  2636 = abc_30082_new_n9675
* NET  2637 = abc_30082_new_n9674
* NET  2638 = abc_30082_new_n9673
* NET  2639 = abc_30082_new_n9672
* NET  2640 = abc_30082_new_n9671
* NET  2641 = abc_30082_new_n9670
* NET  2642 = abc_30082_new_n9669
* NET  2643 = abc_30082_new_n9668
* NET  2644 = abc_30082_new_n9667
* NET  2645 = abc_30082_new_n9666
* NET  2646 = abc_30082_new_n9665
* NET  2647 = abc_30082_new_n9664
* NET  2648 = abc_30082_new_n9663
* NET  2649 = abc_30082_new_n9662
* NET  2650 = abc_30082_new_n9661
* NET  2651 = abc_30082_new_n9660
* NET  2652 = abc_30082_new_n9659
* NET  2653 = abc_30082_new_n9658
* NET  2654 = abc_30082_new_n9657
* NET  2655 = abc_30082_new_n9656
* NET  2656 = abc_30082_new_n9655
* NET  2657 = abc_30082_new_n9654
* NET  2658 = abc_30082_new_n9653
* NET  2659 = abc_30082_new_n9652
* NET  2660 = abc_30082_new_n9651
* NET  2661 = abc_30082_new_n9650
* NET  2662 = abc_30082_new_n9649
* NET  2663 = abc_30082_new_n9648
* NET  2664 = abc_30082_new_n9647
* NET  2665 = abc_30082_new_n9645
* NET  2666 = abc_30082_new_n9644
* NET  2667 = abc_30082_new_n9643
* NET  2668 = abc_30082_new_n9642
* NET  2669 = abc_30082_new_n9641
* NET  2670 = abc_30082_new_n9640
* NET  2671 = abc_30082_new_n9639
* NET  2672 = abc_30082_new_n9638
* NET  2673 = abc_30082_new_n9637
* NET  2674 = abc_30082_new_n9636
* NET  2675 = abc_30082_new_n9635
* NET  2676 = abc_30082_new_n9634
* NET  2677 = abc_30082_new_n9633
* NET  2678 = abc_30082_new_n9632
* NET  2679 = abc_30082_new_n9631
* NET  2680 = abc_30082_new_n9630
* NET  2681 = abc_30082_new_n9629
* NET  2682 = abc_30082_new_n9628
* NET  2683 = abc_30082_new_n9627
* NET  2684 = abc_30082_new_n9626
* NET  2685 = abc_30082_new_n9625
* NET  2686 = abc_30082_new_n9624
* NET  2687 = abc_30082_new_n9623
* NET  2688 = abc_30082_new_n9622
* NET  2689 = abc_30082_new_n9621
* NET  2690 = abc_30082_new_n9620
* NET  2691 = abc_30082_new_n9619
* NET  2692 = abc_30082_new_n9618
* NET  2693 = abc_30082_new_n9617
* NET  2694 = abc_30082_new_n9616
* NET  2695 = abc_30082_new_n9615
* NET  2696 = abc_30082_new_n9614
* NET  2697 = abc_30082_new_n9613
* NET  2698 = abc_30082_new_n9612
* NET  2699 = abc_30082_new_n9611
* NET  2700 = abc_30082_new_n9609
* NET  2701 = abc_30082_new_n9608
* NET  2702 = abc_30082_new_n9607
* NET  2703 = abc_30082_new_n9606
* NET  2704 = abc_30082_new_n9605
* NET  2705 = abc_30082_new_n9604
* NET  2706 = abc_30082_new_n9603
* NET  2707 = abc_30082_new_n9602
* NET  2708 = abc_30082_new_n9601
* NET  2709 = abc_30082_new_n9600
* NET  2710 = abc_30082_new_n9599
* NET  2711 = abc_30082_new_n9598
* NET  2712 = abc_30082_new_n9597
* NET  2713 = abc_30082_new_n9596
* NET  2714 = abc_30082_new_n9595
* NET  2715 = abc_30082_new_n9594
* NET  2716 = abc_30082_new_n9593
* NET  2717 = abc_30082_new_n9592
* NET  2718 = abc_30082_new_n9591
* NET  2719 = abc_30082_new_n9590
* NET  2720 = abc_30082_new_n9589
* NET  2721 = abc_30082_new_n9588
* NET  2722 = abc_30082_new_n9587
* NET  2723 = abc_30082_new_n9586
* NET  2724 = abc_30082_new_n9585
* NET  2725 = abc_30082_new_n9584
* NET  2726 = abc_30082_new_n9583
* NET  2727 = abc_30082_new_n9582
* NET  2728 = abc_30082_new_n9581
* NET  2729 = abc_30082_new_n9580
* NET  2730 = abc_30082_new_n9579
* NET  2731 = abc_30082_new_n9578
* NET  2732 = abc_30082_new_n9577
* NET  2733 = abc_30082_new_n9576
* NET  2734 = abc_30082_new_n9575
* NET  2735 = abc_30082_new_n9573
* NET  2736 = abc_30082_new_n9572
* NET  2737 = abc_30082_new_n9571
* NET  2738 = abc_30082_new_n9570
* NET  2739 = abc_30082_new_n9569
* NET  2740 = abc_30082_new_n9568
* NET  2741 = abc_30082_new_n9567
* NET  2742 = abc_30082_new_n9566
* NET  2743 = abc_30082_new_n9565
* NET  2744 = abc_30082_new_n9564
* NET  2745 = abc_30082_new_n9563
* NET  2746 = abc_30082_new_n9562
* NET  2747 = abc_30082_new_n9561
* NET  2748 = abc_30082_new_n9560
* NET  2749 = abc_30082_new_n9559
* NET  2750 = abc_30082_new_n9558
* NET  2751 = abc_30082_new_n9557
* NET  2752 = abc_30082_new_n9556
* NET  2753 = abc_30082_new_n9555
* NET  2754 = abc_30082_new_n9554
* NET  2755 = abc_30082_new_n9553
* NET  2756 = abc_30082_new_n9552
* NET  2757 = abc_30082_new_n9551
* NET  2758 = abc_30082_new_n9550
* NET  2759 = abc_30082_new_n9549
* NET  2760 = abc_30082_new_n9548
* NET  2761 = abc_30082_new_n9547
* NET  2762 = abc_30082_new_n9546
* NET  2763 = abc_30082_new_n9545
* NET  2764 = abc_30082_new_n9544
* NET  2765 = abc_30082_new_n9543
* NET  2766 = abc_30082_new_n9542
* NET  2767 = abc_30082_new_n9541
* NET  2768 = abc_30082_new_n9540
* NET  2769 = abc_30082_new_n9539
* NET  2770 = abc_30082_new_n9537
* NET  2771 = abc_30082_new_n9536
* NET  2772 = abc_30082_new_n9535
* NET  2773 = abc_30082_new_n9534
* NET  2774 = abc_30082_new_n9533
* NET  2775 = abc_30082_new_n9532
* NET  2776 = abc_30082_new_n9531
* NET  2777 = abc_30082_new_n9530
* NET  2778 = abc_30082_new_n9529
* NET  2779 = abc_30082_new_n9528
* NET  2780 = abc_30082_new_n9527
* NET  2781 = abc_30082_new_n9526
* NET  2782 = abc_30082_new_n9525
* NET  2783 = abc_30082_new_n9524
* NET  2784 = abc_30082_new_n9523
* NET  2785 = abc_30082_new_n9522
* NET  2786 = abc_30082_new_n9521
* NET  2787 = abc_30082_new_n9520
* NET  2788 = abc_30082_new_n9519
* NET  2789 = abc_30082_new_n9518
* NET  2790 = abc_30082_new_n9517
* NET  2791 = abc_30082_new_n9516
* NET  2792 = abc_30082_new_n9515
* NET  2793 = abc_30082_new_n9514
* NET  2794 = abc_30082_new_n9513
* NET  2795 = abc_30082_new_n9512
* NET  2796 = abc_30082_new_n9511
* NET  2797 = abc_30082_new_n9510
* NET  2798 = abc_30082_new_n9509
* NET  2799 = abc_30082_new_n9508
* NET  2800 = abc_30082_new_n9507
* NET  2801 = abc_30082_new_n9506
* NET  2802 = abc_30082_new_n9505
* NET  2803 = abc_30082_new_n9504
* NET  2804 = abc_30082_new_n9503
* NET  2805 = abc_30082_new_n9501
* NET  2806 = abc_30082_new_n9500
* NET  2807 = abc_30082_new_n9499
* NET  2808 = abc_30082_new_n9498
* NET  2809 = abc_30082_new_n9497
* NET  2810 = abc_30082_new_n9496
* NET  2811 = abc_30082_new_n9495
* NET  2812 = abc_30082_new_n9494
* NET  2813 = abc_30082_new_n9493
* NET  2814 = abc_30082_new_n9492
* NET  2815 = abc_30082_new_n9491
* NET  2816 = abc_30082_new_n9490
* NET  2817 = abc_30082_new_n9489
* NET  2818 = abc_30082_new_n9488
* NET  2819 = abc_30082_new_n9487
* NET  2820 = abc_30082_new_n9486
* NET  2821 = abc_30082_new_n9485
* NET  2822 = abc_30082_new_n9484
* NET  2823 = abc_30082_new_n9483
* NET  2824 = abc_30082_new_n9482
* NET  2825 = abc_30082_new_n9481
* NET  2826 = abc_30082_new_n9480
* NET  2827 = abc_30082_new_n9479
* NET  2828 = abc_30082_new_n9478
* NET  2829 = abc_30082_new_n9477
* NET  2830 = abc_30082_new_n9476
* NET  2831 = abc_30082_new_n9475
* NET  2832 = abc_30082_new_n9474
* NET  2833 = abc_30082_new_n9473
* NET  2834 = abc_30082_new_n9472
* NET  2835 = abc_30082_new_n9471
* NET  2836 = abc_30082_new_n9470
* NET  2837 = abc_30082_new_n9469
* NET  2838 = abc_30082_new_n9468
* NET  2839 = abc_30082_new_n9467
* NET  2840 = abc_30082_new_n9465
* NET  2841 = abc_30082_new_n9464
* NET  2842 = abc_30082_new_n9463
* NET  2843 = abc_30082_new_n9462
* NET  2844 = abc_30082_new_n9461
* NET  2845 = abc_30082_new_n9460
* NET  2846 = abc_30082_new_n9459
* NET  2847 = abc_30082_new_n9458
* NET  2848 = abc_30082_new_n9457
* NET  2849 = abc_30082_new_n9456
* NET  2850 = abc_30082_new_n9455
* NET  2851 = abc_30082_new_n9454
* NET  2852 = abc_30082_new_n9453
* NET  2853 = abc_30082_new_n9452
* NET  2854 = abc_30082_new_n9451
* NET  2855 = abc_30082_new_n9450
* NET  2856 = abc_30082_new_n9449
* NET  2857 = abc_30082_new_n9448
* NET  2858 = abc_30082_new_n9447
* NET  2859 = abc_30082_new_n9446
* NET  2860 = abc_30082_new_n9445
* NET  2861 = abc_30082_new_n9444
* NET  2862 = abc_30082_new_n9443
* NET  2863 = abc_30082_new_n9442
* NET  2864 = abc_30082_new_n9441
* NET  2865 = abc_30082_new_n9440
* NET  2866 = abc_30082_new_n9439
* NET  2867 = abc_30082_new_n9438
* NET  2868 = abc_30082_new_n9437
* NET  2869 = abc_30082_new_n9436
* NET  2870 = abc_30082_new_n9435
* NET  2871 = abc_30082_new_n9434
* NET  2872 = abc_30082_new_n9433
* NET  2873 = abc_30082_new_n9432
* NET  2874 = abc_30082_new_n9431
* NET  2875 = abc_30082_new_n9429
* NET  2876 = abc_30082_new_n9428
* NET  2877 = abc_30082_new_n9427
* NET  2878 = abc_30082_new_n9426
* NET  2879 = abc_30082_new_n9425
* NET  2880 = abc_30082_new_n9424
* NET  2881 = abc_30082_new_n9423
* NET  2882 = abc_30082_new_n9422
* NET  2883 = abc_30082_new_n9421
* NET  2884 = abc_30082_new_n9420
* NET  2885 = abc_30082_new_n9419
* NET  2886 = abc_30082_new_n9418
* NET  2887 = abc_30082_new_n9417
* NET  2888 = abc_30082_new_n9416
* NET  2889 = abc_30082_new_n9415
* NET  2890 = abc_30082_new_n9414
* NET  2891 = abc_30082_new_n9413
* NET  2892 = abc_30082_new_n9412
* NET  2893 = abc_30082_new_n9411
* NET  2894 = abc_30082_new_n9410
* NET  2895 = abc_30082_new_n9409
* NET  2896 = abc_30082_new_n9408
* NET  2897 = abc_30082_new_n9407
* NET  2898 = abc_30082_new_n9406
* NET  2899 = abc_30082_new_n9405
* NET  2900 = abc_30082_new_n9404
* NET  2901 = abc_30082_new_n9403
* NET  2902 = abc_30082_new_n9402
* NET  2903 = abc_30082_new_n9401
* NET  2904 = abc_30082_new_n9400
* NET  2905 = abc_30082_new_n9399
* NET  2906 = abc_30082_new_n9398
* NET  2907 = abc_30082_new_n9397
* NET  2908 = abc_30082_new_n9396
* NET  2909 = abc_30082_new_n9395
* NET  2910 = abc_30082_new_n9393
* NET  2911 = abc_30082_new_n9392
* NET  2912 = abc_30082_new_n9391
* NET  2913 = abc_30082_new_n9390
* NET  2914 = abc_30082_new_n9389
* NET  2915 = abc_30082_new_n9388
* NET  2916 = abc_30082_new_n9387
* NET  2917 = abc_30082_new_n9386
* NET  2918 = abc_30082_new_n9385
* NET  2919 = abc_30082_new_n9384
* NET  2920 = abc_30082_new_n9383
* NET  2921 = abc_30082_new_n9382
* NET  2922 = abc_30082_new_n9381
* NET  2923 = abc_30082_new_n9380
* NET  2924 = abc_30082_new_n9379
* NET  2925 = abc_30082_new_n9378
* NET  2926 = abc_30082_new_n9377
* NET  2927 = abc_30082_new_n9376
* NET  2928 = abc_30082_new_n9375
* NET  2929 = abc_30082_new_n9374
* NET  2930 = abc_30082_new_n9373
* NET  2931 = abc_30082_new_n9372
* NET  2932 = abc_30082_new_n9371
* NET  2933 = abc_30082_new_n9370
* NET  2934 = abc_30082_new_n9369
* NET  2935 = abc_30082_new_n9368
* NET  2936 = abc_30082_new_n9367
* NET  2937 = abc_30082_new_n9366
* NET  2938 = abc_30082_new_n9365
* NET  2939 = abc_30082_new_n9364
* NET  2940 = abc_30082_new_n9363
* NET  2941 = abc_30082_new_n9362
* NET  2942 = abc_30082_new_n9361
* NET  2943 = abc_30082_new_n9360
* NET  2944 = abc_30082_new_n9359
* NET  2945 = abc_30082_new_n9357
* NET  2946 = abc_30082_new_n9356
* NET  2947 = abc_30082_new_n9355
* NET  2948 = abc_30082_new_n9354
* NET  2949 = abc_30082_new_n9353
* NET  2950 = abc_30082_new_n9352
* NET  2951 = abc_30082_new_n9351
* NET  2952 = abc_30082_new_n9350
* NET  2953 = abc_30082_new_n9349
* NET  2954 = abc_30082_new_n9348
* NET  2955 = abc_30082_new_n9347
* NET  2956 = abc_30082_new_n9346
* NET  2957 = abc_30082_new_n9345
* NET  2958 = abc_30082_new_n9344
* NET  2959 = abc_30082_new_n9343
* NET  2960 = abc_30082_new_n9342
* NET  2961 = abc_30082_new_n9341
* NET  2962 = abc_30082_new_n9340
* NET  2963 = abc_30082_new_n9339
* NET  2964 = abc_30082_new_n9338
* NET  2965 = abc_30082_new_n9337
* NET  2966 = abc_30082_new_n9336
* NET  2967 = abc_30082_new_n9335
* NET  2968 = abc_30082_new_n9334
* NET  2969 = abc_30082_new_n9333
* NET  2970 = abc_30082_new_n9332
* NET  2971 = abc_30082_new_n9331
* NET  2972 = abc_30082_new_n9330
* NET  2973 = abc_30082_new_n9329
* NET  2974 = abc_30082_new_n9328
* NET  2975 = abc_30082_new_n9327
* NET  2976 = abc_30082_new_n9326
* NET  2977 = abc_30082_new_n9325
* NET  2978 = abc_30082_new_n9324
* NET  2979 = abc_30082_new_n9323
* NET  2980 = abc_30082_new_n9321
* NET  2981 = abc_30082_new_n9320
* NET  2982 = abc_30082_new_n9319
* NET  2983 = abc_30082_new_n9318
* NET  2984 = abc_30082_new_n9317
* NET  2985 = abc_30082_new_n9316
* NET  2986 = abc_30082_new_n9315
* NET  2987 = abc_30082_new_n9314
* NET  2988 = abc_30082_new_n9313
* NET  2989 = abc_30082_new_n9312
* NET  2990 = abc_30082_new_n9311
* NET  2991 = abc_30082_new_n9310
* NET  2992 = abc_30082_new_n9309
* NET  2993 = abc_30082_new_n9308
* NET  2994 = abc_30082_new_n9307
* NET  2995 = abc_30082_new_n9306
* NET  2996 = abc_30082_new_n9305
* NET  2997 = abc_30082_new_n9304
* NET  2998 = abc_30082_new_n9303
* NET  2999 = abc_30082_new_n9302
* NET  3000 = abc_30082_new_n9301
* NET  3001 = abc_30082_new_n9300
* NET  3002 = abc_30082_new_n9299
* NET  3003 = abc_30082_new_n9298
* NET  3004 = abc_30082_new_n9297
* NET  3005 = abc_30082_new_n9296
* NET  3006 = abc_30082_new_n9295
* NET  3007 = abc_30082_new_n9294
* NET  3008 = abc_30082_new_n9293
* NET  3009 = abc_30082_new_n9292
* NET  3010 = abc_30082_new_n9291
* NET  3011 = abc_30082_new_n9290
* NET  3012 = abc_30082_new_n9289
* NET  3013 = abc_30082_new_n9288
* NET  3014 = abc_30082_new_n9287
* NET  3015 = abc_30082_new_n9285
* NET  3016 = abc_30082_new_n9284
* NET  3017 = abc_30082_new_n9283
* NET  3018 = abc_30082_new_n9282
* NET  3019 = abc_30082_new_n9281
* NET  3020 = abc_30082_new_n9280
* NET  3021 = abc_30082_new_n9279
* NET  3022 = abc_30082_new_n9278
* NET  3023 = abc_30082_new_n9277
* NET  3024 = abc_30082_new_n9276
* NET  3025 = abc_30082_new_n9275
* NET  3026 = abc_30082_new_n9274
* NET  3027 = abc_30082_new_n9273
* NET  3028 = abc_30082_new_n9272
* NET  3029 = abc_30082_new_n9271
* NET  3030 = abc_30082_new_n9270
* NET  3031 = abc_30082_new_n9269
* NET  3032 = abc_30082_new_n9268
* NET  3033 = abc_30082_new_n9267
* NET  3034 = abc_30082_new_n9266
* NET  3035 = abc_30082_new_n9265
* NET  3036 = abc_30082_new_n9264
* NET  3037 = abc_30082_new_n9263
* NET  3038 = abc_30082_new_n9262
* NET  3039 = abc_30082_new_n9261
* NET  3040 = abc_30082_new_n9260
* NET  3041 = abc_30082_new_n9259
* NET  3042 = abc_30082_new_n9258
* NET  3043 = abc_30082_new_n9257
* NET  3044 = abc_30082_new_n9256
* NET  3045 = abc_30082_new_n9255
* NET  3046 = abc_30082_new_n9254
* NET  3047 = abc_30082_new_n9253
* NET  3048 = abc_30082_new_n9252
* NET  3049 = abc_30082_new_n9251
* NET  3050 = abc_30082_new_n9249
* NET  3051 = abc_30082_new_n9248
* NET  3052 = abc_30082_new_n9247
* NET  3053 = abc_30082_new_n9246
* NET  3054 = abc_30082_new_n9245
* NET  3055 = abc_30082_new_n9244
* NET  3056 = abc_30082_new_n9243
* NET  3057 = abc_30082_new_n9242
* NET  3058 = abc_30082_new_n9241
* NET  3059 = abc_30082_new_n9240
* NET  3060 = abc_30082_new_n9239
* NET  3061 = abc_30082_new_n9238
* NET  3062 = abc_30082_new_n9237
* NET  3063 = abc_30082_new_n9236
* NET  3064 = abc_30082_new_n9235
* NET  3065 = abc_30082_new_n9234
* NET  3066 = abc_30082_new_n9233
* NET  3067 = abc_30082_new_n9232
* NET  3068 = abc_30082_new_n9231
* NET  3069 = abc_30082_new_n9230
* NET  3070 = abc_30082_new_n9229
* NET  3071 = abc_30082_new_n9228
* NET  3072 = abc_30082_new_n9227
* NET  3073 = abc_30082_new_n9226
* NET  3074 = abc_30082_new_n9225
* NET  3075 = abc_30082_new_n9224
* NET  3076 = abc_30082_new_n9223
* NET  3077 = abc_30082_new_n9222
* NET  3078 = abc_30082_new_n9221
* NET  3079 = abc_30082_new_n9220
* NET  3080 = abc_30082_new_n9219
* NET  3081 = abc_30082_new_n9218
* NET  3082 = abc_30082_new_n9217
* NET  3083 = abc_30082_new_n9216
* NET  3084 = abc_30082_new_n9215
* NET  3085 = abc_30082_new_n9213
* NET  3086 = abc_30082_new_n9212
* NET  3087 = abc_30082_new_n9211
* NET  3088 = abc_30082_new_n9210
* NET  3089 = abc_30082_new_n9209
* NET  3090 = abc_30082_new_n9208
* NET  3091 = abc_30082_new_n9207
* NET  3092 = abc_30082_new_n9206
* NET  3093 = abc_30082_new_n9205
* NET  3094 = abc_30082_new_n9204
* NET  3095 = abc_30082_new_n9203
* NET  3096 = abc_30082_new_n9202
* NET  3097 = abc_30082_new_n9201
* NET  3098 = abc_30082_new_n9200
* NET  3099 = abc_30082_new_n9199
* NET  3100 = abc_30082_new_n9198
* NET  3101 = abc_30082_new_n9197
* NET  3102 = abc_30082_new_n9196
* NET  3103 = abc_30082_new_n9195
* NET  3104 = abc_30082_new_n9194
* NET  3105 = abc_30082_new_n9193
* NET  3106 = abc_30082_new_n9192
* NET  3107 = abc_30082_new_n9191
* NET  3108 = abc_30082_new_n9190
* NET  3109 = abc_30082_new_n9189
* NET  3110 = abc_30082_new_n9188
* NET  3111 = abc_30082_new_n9187
* NET  3112 = abc_30082_new_n9186
* NET  3113 = abc_30082_new_n9185
* NET  3114 = abc_30082_new_n9184
* NET  3115 = abc_30082_new_n9183
* NET  3116 = abc_30082_new_n9182
* NET  3117 = abc_30082_new_n9181
* NET  3118 = abc_30082_new_n9180
* NET  3119 = abc_30082_new_n9179
* NET  3120 = abc_30082_new_n9177
* NET  3121 = abc_30082_new_n9176
* NET  3122 = abc_30082_new_n9175
* NET  3123 = abc_30082_new_n9174
* NET  3124 = abc_30082_new_n9173
* NET  3125 = abc_30082_new_n9172
* NET  3126 = abc_30082_new_n9171
* NET  3127 = abc_30082_new_n9170
* NET  3128 = abc_30082_new_n9169
* NET  3129 = abc_30082_new_n9168
* NET  3130 = abc_30082_new_n9167
* NET  3131 = abc_30082_new_n9166
* NET  3132 = abc_30082_new_n9165
* NET  3133 = abc_30082_new_n9164
* NET  3134 = abc_30082_new_n9163
* NET  3135 = abc_30082_new_n9162
* NET  3136 = abc_30082_new_n9161
* NET  3137 = abc_30082_new_n9160
* NET  3138 = abc_30082_new_n9159
* NET  3139 = abc_30082_new_n9158
* NET  3140 = abc_30082_new_n9157
* NET  3141 = abc_30082_new_n9156
* NET  3142 = abc_30082_new_n9155
* NET  3143 = abc_30082_new_n9154
* NET  3144 = abc_30082_new_n9153
* NET  3145 = abc_30082_new_n9152
* NET  3146 = abc_30082_new_n9151
* NET  3147 = abc_30082_new_n9150
* NET  3148 = abc_30082_new_n9149
* NET  3149 = abc_30082_new_n9148
* NET  3150 = abc_30082_new_n9147
* NET  3151 = abc_30082_new_n9146
* NET  3152 = abc_30082_new_n9145
* NET  3153 = abc_30082_new_n9144
* NET  3154 = abc_30082_new_n9143
* NET  3155 = abc_30082_new_n9141
* NET  3156 = abc_30082_new_n9140
* NET  3157 = abc_30082_new_n9139
* NET  3158 = abc_30082_new_n9138
* NET  3159 = abc_30082_new_n9137
* NET  3160 = abc_30082_new_n9136
* NET  3161 = abc_30082_new_n9135
* NET  3162 = abc_30082_new_n9134
* NET  3163 = abc_30082_new_n9133
* NET  3164 = abc_30082_new_n9132
* NET  3165 = abc_30082_new_n9131
* NET  3166 = abc_30082_new_n9130
* NET  3167 = abc_30082_new_n9129
* NET  3168 = abc_30082_new_n9128
* NET  3169 = abc_30082_new_n9127
* NET  3170 = abc_30082_new_n9126
* NET  3171 = abc_30082_new_n9125
* NET  3172 = abc_30082_new_n9124
* NET  3173 = abc_30082_new_n9123
* NET  3174 = abc_30082_new_n9122
* NET  3175 = abc_30082_new_n9121
* NET  3176 = abc_30082_new_n9120
* NET  3177 = abc_30082_new_n9119
* NET  3178 = abc_30082_new_n9118
* NET  3179 = abc_30082_new_n9117
* NET  3180 = abc_30082_new_n9116
* NET  3181 = abc_30082_new_n9115
* NET  3182 = abc_30082_new_n9114
* NET  3183 = abc_30082_new_n9113
* NET  3184 = abc_30082_new_n9112
* NET  3185 = abc_30082_new_n9111
* NET  3186 = abc_30082_new_n9110
* NET  3187 = abc_30082_new_n9109
* NET  3188 = abc_30082_new_n9108
* NET  3189 = abc_30082_new_n9107_hfns_2
* NET  3190 = abc_30082_new_n9107_hfns_1
* NET  3191 = abc_30082_new_n9107_hfns_0
* NET  3192 = abc_30082_new_n9107
* NET  3193 = abc_30082_new_n9106
* NET  3194 = abc_30082_new_n9101
* NET  3195 = abc_30082_new_n9100
* NET  3196 = abc_30082_new_n9099
* NET  3197 = abc_30082_new_n9098
* NET  3198 = abc_30082_new_n9097
* NET  3199 = abc_30082_new_n9096
* NET  3200 = abc_30082_new_n9095
* NET  3201 = abc_30082_new_n9094
* NET  3202 = abc_30082_new_n9093
* NET  3203 = abc_30082_new_n9092
* NET  3204 = abc_30082_new_n9091
* NET  3205 = abc_30082_new_n9090
* NET  3206 = abc_30082_new_n9089
* NET  3207 = abc_30082_new_n9088
* NET  3208 = abc_30082_new_n9087
* NET  3209 = abc_30082_new_n9086
* NET  3210 = abc_30082_new_n9085
* NET  3211 = abc_30082_new_n9084
* NET  3212 = abc_30082_new_n9083
* NET  3213 = abc_30082_new_n9082
* NET  3214 = abc_30082_new_n9081
* NET  3215 = abc_30082_new_n9080
* NET  3216 = abc_30082_new_n9079
* NET  3217 = abc_30082_new_n9078
* NET  3218 = abc_30082_new_n9077
* NET  3219 = abc_30082_new_n9076
* NET  3220 = abc_30082_new_n9075
* NET  3221 = abc_30082_new_n9074
* NET  3222 = abc_30082_new_n9073
* NET  3223 = abc_30082_new_n9072
* NET  3224 = abc_30082_new_n9071
* NET  3225 = abc_30082_new_n9070
* NET  3226 = abc_30082_new_n9069
* NET  3227 = abc_30082_new_n9067
* NET  3228 = abc_30082_new_n9066
* NET  3229 = abc_30082_new_n9065
* NET  3230 = abc_30082_new_n9064
* NET  3231 = abc_30082_new_n9063
* NET  3232 = abc_30082_new_n9062
* NET  3233 = abc_30082_new_n9061
* NET  3234 = abc_30082_new_n9060
* NET  3235 = abc_30082_new_n9059
* NET  3236 = abc_30082_new_n9058
* NET  3237 = abc_30082_new_n9057
* NET  3238 = abc_30082_new_n9056
* NET  3239 = abc_30082_new_n9055
* NET  3240 = abc_30082_new_n9054
* NET  3241 = abc_30082_new_n9053
* NET  3242 = abc_30082_new_n9052
* NET  3243 = abc_30082_new_n9051
* NET  3244 = abc_30082_new_n9050
* NET  3245 = abc_30082_new_n9049
* NET  3246 = abc_30082_new_n9048
* NET  3247 = abc_30082_new_n9047
* NET  3248 = abc_30082_new_n9046
* NET  3249 = abc_30082_new_n9045
* NET  3250 = abc_30082_new_n9044
* NET  3251 = abc_30082_new_n9043
* NET  3252 = abc_30082_new_n9042
* NET  3253 = abc_30082_new_n9041
* NET  3254 = abc_30082_new_n9040
* NET  3255 = abc_30082_new_n9039
* NET  3256 = abc_30082_new_n9038
* NET  3257 = abc_30082_new_n9037
* NET  3258 = abc_30082_new_n9036
* NET  3259 = abc_30082_new_n9034
* NET  3260 = abc_30082_new_n9033
* NET  3261 = abc_30082_new_n9032
* NET  3262 = abc_30082_new_n9030
* NET  3263 = abc_30082_new_n9028
* NET  3264 = abc_30082_new_n9027
* NET  3265 = abc_30082_new_n9026
* NET  3266 = abc_30082_new_n9025
* NET  3267 = abc_30082_new_n9024
* NET  3268 = abc_30082_new_n9023
* NET  3269 = abc_30082_new_n9022
* NET  3270 = abc_30082_new_n9021
* NET  3271 = abc_30082_new_n9020
* NET  3272 = abc_30082_new_n9019
* NET  3273 = abc_30082_new_n9018
* NET  3274 = abc_30082_new_n9017
* NET  3275 = abc_30082_new_n9016
* NET  3276 = abc_30082_new_n9015
* NET  3277 = abc_30082_new_n9014
* NET  3278 = abc_30082_new_n9013
* NET  3279 = abc_30082_new_n9012
* NET  3280 = abc_30082_new_n9010
* NET  3281 = abc_30082_new_n8979_hfns_2
* NET  3282 = abc_30082_new_n8979_hfns_1
* NET  3283 = abc_30082_new_n8979_hfns_0
* NET  3284 = abc_30082_new_n8979
* NET  3285 = abc_30082_new_n8978
* NET  3286 = abc_30082_new_n8977
* NET  3287 = abc_30082_new_n8976
* NET  3288 = abc_30082_new_n8975
* NET  3289 = abc_30082_new_n8973
* NET  3290 = abc_30082_new_n8972
* NET  3291 = abc_30082_new_n8971
* NET  3292 = abc_30082_new_n8970
* NET  3293 = abc_30082_new_n8969
* NET  3294 = abc_30082_new_n8968
* NET  3295 = abc_30082_new_n8967
* NET  3296 = abc_30082_new_n8966
* NET  3297 = abc_30082_new_n8965
* NET  3298 = abc_30082_new_n8964
* NET  3299 = abc_30082_new_n8963
* NET  3300 = abc_30082_new_n8962
* NET  3301 = abc_30082_new_n8961
* NET  3302 = abc_30082_new_n8960
* NET  3303 = abc_30082_new_n8959
* NET  3304 = abc_30082_new_n8958
* NET  3305 = abc_30082_new_n8957
* NET  3306 = abc_30082_new_n8956
* NET  3307 = abc_30082_new_n8955
* NET  3308 = abc_30082_new_n8954
* NET  3309 = abc_30082_new_n8953
* NET  3310 = abc_30082_new_n8952
* NET  3311 = abc_30082_new_n8951
* NET  3312 = abc_30082_new_n8950
* NET  3313 = abc_30082_new_n8949
* NET  3314 = abc_30082_new_n8948
* NET  3315 = abc_30082_new_n8947
* NET  3316 = abc_30082_new_n8946
* NET  3317 = abc_30082_new_n8945
* NET  3318 = abc_30082_new_n8944
* NET  3319 = abc_30082_new_n8943
* NET  3320 = abc_30082_new_n8942
* NET  3321 = abc_30082_new_n8941
* NET  3322 = abc_30082_new_n8940
* NET  3323 = abc_30082_new_n8939
* NET  3324 = abc_30082_new_n8938
* NET  3325 = abc_30082_new_n8937
* NET  3326 = abc_30082_new_n8936
* NET  3327 = abc_30082_new_n8935
* NET  3328 = abc_30082_new_n8934
* NET  3329 = abc_30082_new_n8933
* NET  3330 = abc_30082_new_n8932
* NET  3331 = abc_30082_new_n8931
* NET  3332 = abc_30082_new_n8930
* NET  3333 = abc_30082_new_n8928
* NET  3334 = abc_30082_new_n8926
* NET  3335 = abc_30082_new_n8925
* NET  3336 = abc_30082_new_n8923
* NET  3337 = abc_30082_new_n8922
* NET  3338 = abc_30082_new_n8920
* NET  3339 = abc_30082_new_n8919
* NET  3340 = abc_30082_new_n8917
* NET  3341 = abc_30082_new_n8916
* NET  3342 = abc_30082_new_n8914
* NET  3343 = abc_30082_new_n8913
* NET  3344 = abc_30082_new_n8911
* NET  3345 = abc_30082_new_n8910
* NET  3346 = abc_30082_new_n8909
* NET  3347 = abc_30082_new_n8907
* NET  3348 = abc_30082_new_n8906
* NET  3349 = abc_30082_new_n8904
* NET  3350 = abc_30082_new_n8903
* NET  3351 = abc_30082_new_n8902
* NET  3352 = abc_30082_new_n8900
* NET  3353 = abc_30082_new_n8899
* NET  3354 = abc_30082_new_n8897
* NET  3355 = abc_30082_new_n8896
* NET  3356 = abc_30082_new_n8895
* NET  3357 = abc_30082_new_n8893
* NET  3358 = abc_30082_new_n8891
* NET  3359 = abc_30082_new_n8890
* NET  3360 = abc_30082_new_n8889
* NET  3361 = abc_30082_new_n8887
* NET  3362 = abc_30082_new_n8886
* NET  3363 = abc_30082_new_n8884
* NET  3364 = abc_30082_new_n8883
* NET  3365 = abc_30082_new_n8882
* NET  3366 = abc_30082_new_n8880
* NET  3367 = abc_30082_new_n8879
* NET  3368 = abc_30082_new_n8877
* NET  3369 = abc_30082_new_n8876
* NET  3370 = abc_30082_new_n8875
* NET  3371 = abc_30082_new_n8873
* NET  3372 = abc_30082_new_n8872
* NET  3373 = abc_30082_new_n8870
* NET  3374 = abc_30082_new_n8869
* NET  3375 = abc_30082_new_n8868
* NET  3376 = abc_30082_new_n8866
* NET  3377 = abc_30082_new_n8865
* NET  3378 = abc_30082_new_n8863
* NET  3379 = abc_30082_new_n8862
* NET  3380 = abc_30082_new_n8861
* NET  3381 = abc_30082_new_n8859
* NET  3382 = abc_30082_new_n8858
* NET  3383 = abc_30082_new_n8856
* NET  3384 = abc_30082_new_n8855
* NET  3385 = abc_30082_new_n8854
* NET  3386 = abc_30082_new_n8852
* NET  3387 = abc_30082_new_n8850
* NET  3388 = abc_30082_new_n8849
* NET  3389 = abc_30082_new_n8848
* NET  3390 = abc_30082_new_n8846
* NET  3391 = abc_30082_new_n8844
* NET  3392 = abc_30082_new_n8843
* NET  3393 = abc_30082_new_n8842
* NET  3394 = abc_30082_new_n8840
* NET  3395 = abc_30082_new_n8839
* NET  3396 = abc_30082_new_n8837
* NET  3397 = abc_30082_new_n8836
* NET  3398 = abc_30082_new_n8835
* NET  3399 = abc_30082_new_n8833
* NET  3400 = abc_30082_new_n8831
* NET  3401 = abc_30082_new_n8830
* NET  3402 = abc_30082_new_n8828
* NET  3403 = abc_30082_new_n8827
* NET  3404 = abc_30082_new_n8825
* NET  3405 = abc_30082_new_n8824
* NET  3406 = abc_30082_new_n8822
* NET  3407 = abc_30082_new_n8821
* NET  3408 = abc_30082_new_n8819
* NET  3409 = abc_30082_new_n8818
* NET  3410 = abc_30082_new_n8817
* NET  3411 = abc_30082_new_n8815
* NET  3412 = abc_30082_new_n8813
* NET  3413 = abc_30082_new_n8812
* NET  3414 = abc_30082_new_n8811
* NET  3415 = abc_30082_new_n8809
* NET  3416 = abc_30082_new_n8808
* NET  3417 = abc_30082_new_n8806
* NET  3418 = abc_30082_new_n8805
* NET  3419 = abc_30082_new_n8804
* NET  3420 = abc_30082_new_n8802
* NET  3421 = abc_30082_new_n8801
* NET  3422 = abc_30082_new_n8799
* NET  3423 = abc_30082_new_n8798
* NET  3424 = abc_30082_new_n8797
* NET  3425 = abc_30082_new_n8795
* NET  3426 = abc_30082_new_n8793
* NET  3427 = abc_30082_new_n8792
* NET  3428 = abc_30082_new_n8790
* NET  3429 = abc_30082_new_n8789
* NET  3430 = abc_30082_new_n8787
* NET  3431 = abc_30082_new_n8786
* NET  3432 = abc_30082_new_n8784
* NET  3433 = abc_30082_new_n8783
* NET  3434 = abc_30082_new_n8781
* NET  3435 = abc_30082_new_n8780
* NET  3436 = abc_30082_new_n8778
* NET  3437 = abc_30082_new_n8776
* NET  3438 = abc_30082_new_n8775
* NET  3439 = abc_30082_new_n8774
* NET  3440 = abc_30082_new_n8772
* NET  3441 = abc_30082_new_n8771
* NET  3442 = abc_30082_new_n8769
* NET  3443 = abc_30082_new_n8768
* NET  3444 = abc_30082_new_n8767
* NET  3445 = abc_30082_new_n8765
* NET  3446 = abc_30082_new_n8764
* NET  3447 = abc_30082_new_n8762
* NET  3448 = abc_30082_new_n8761
* NET  3449 = abc_30082_new_n8760
* NET  3450 = abc_30082_new_n8758
* NET  3451 = abc_30082_new_n8756
* NET  3452 = abc_30082_new_n8755
* NET  3453 = abc_30082_new_n8754
* NET  3454 = abc_30082_new_n8752
* NET  3455 = abc_30082_new_n8750
* NET  3456 = abc_30082_new_n8749
* NET  3457 = abc_30082_new_n8748
* NET  3458 = abc_30082_new_n8746
* NET  3459 = abc_30082_new_n8745
* NET  3460 = abc_30082_new_n8743
* NET  3461 = abc_30082_new_n8742
* NET  3462 = abc_30082_new_n8741
* NET  3463 = abc_30082_new_n8739
* NET  3464 = abc_30082_new_n8737
* NET  3465 = abc_30082_new_n8736
* NET  3466 = abc_30082_new_n8734
* NET  3467 = abc_30082_new_n8733
* NET  3468 = abc_30082_new_n8732
* NET  3469 = abc_30082_new_n8730
* NET  3470 = abc_30082_new_n8727
* NET  3471 = abc_30082_new_n8726
* NET  3472 = abc_30082_new_n8725
* NET  3473 = abc_30082_new_n8724
* NET  3474 = abc_30082_new_n8723
* NET  3475 = abc_30082_new_n8722
* NET  3476 = abc_30082_new_n8721
* NET  3477 = abc_30082_new_n8719
* NET  3478 = abc_30082_new_n8718
* NET  3479 = abc_30082_new_n8717
* NET  3480 = abc_30082_new_n8716
* NET  3481 = abc_30082_new_n8715
* NET  3482 = abc_30082_new_n8714
* NET  3483 = abc_30082_new_n8713
* NET  3484 = abc_30082_new_n8712
* NET  3485 = abc_30082_new_n8711
* NET  3486 = abc_30082_new_n8710
* NET  3487 = abc_30082_new_n8709
* NET  3488 = abc_30082_new_n8708
* NET  3489 = abc_30082_new_n8707
* NET  3490 = abc_30082_new_n8706
* NET  3491 = abc_30082_new_n8705
* NET  3492 = abc_30082_new_n8703
* NET  3493 = abc_30082_new_n8702
* NET  3494 = abc_30082_new_n8701
* NET  3495 = abc_30082_new_n8700
* NET  3496 = abc_30082_new_n8699
* NET  3497 = abc_30082_new_n8698
* NET  3498 = abc_30082_new_n8697
* NET  3499 = abc_30082_new_n8696
* NET  3500 = abc_30082_new_n8695
* NET  3501 = abc_30082_new_n8694
* NET  3502 = abc_30082_new_n8693
* NET  3503 = abc_30082_new_n8692
* NET  3504 = abc_30082_new_n8691
* NET  3505 = abc_30082_new_n8690
* NET  3506 = abc_30082_new_n8689
* NET  3507 = abc_30082_new_n8688
* NET  3508 = abc_30082_new_n8687
* NET  3509 = abc_30082_new_n8686
* NET  3510 = abc_30082_new_n8684
* NET  3511 = abc_30082_new_n8683
* NET  3512 = abc_30082_new_n8682
* NET  3513 = abc_30082_new_n8681
* NET  3514 = abc_30082_new_n8680
* NET  3515 = abc_30082_new_n8679
* NET  3516 = abc_30082_new_n8678
* NET  3517 = abc_30082_new_n8677
* NET  3518 = abc_30082_new_n8675
* NET  3519 = abc_30082_new_n8674
* NET  3520 = abc_30082_new_n8673
* NET  3521 = abc_30082_new_n8672
* NET  3522 = abc_30082_new_n8671
* NET  3523 = abc_30082_new_n8670
* NET  3524 = abc_30082_new_n8669
* NET  3525 = abc_30082_new_n8668
* NET  3526 = abc_30082_new_n8667
* NET  3527 = abc_30082_new_n8666
* NET  3528 = abc_30082_new_n8665
* NET  3529 = abc_30082_new_n8664
* NET  3530 = abc_30082_new_n8663
* NET  3531 = abc_30082_new_n8662
* NET  3532 = abc_30082_new_n8661
* NET  3533 = abc_30082_new_n8660
* NET  3534 = abc_30082_new_n8658
* NET  3535 = abc_30082_new_n8657
* NET  3536 = abc_30082_new_n8656
* NET  3537 = abc_30082_new_n8655
* NET  3538 = abc_30082_new_n8654
* NET  3539 = abc_30082_new_n8653
* NET  3540 = abc_30082_new_n8652
* NET  3541 = abc_30082_new_n8651
* NET  3542 = abc_30082_new_n8649
* NET  3543 = abc_30082_new_n8648
* NET  3544 = abc_30082_new_n8647
* NET  3545 = abc_30082_new_n8646
* NET  3546 = abc_30082_new_n8645
* NET  3547 = abc_30082_new_n8644
* NET  3548 = abc_30082_new_n8643
* NET  3549 = abc_30082_new_n8642
* NET  3550 = abc_30082_new_n8641
* NET  3551 = abc_30082_new_n8640
* NET  3552 = abc_30082_new_n8639
* NET  3553 = abc_30082_new_n8638
* NET  3554 = abc_30082_new_n8637
* NET  3555 = abc_30082_new_n8636
* NET  3556 = abc_30082_new_n8635
* NET  3557 = abc_30082_new_n8634
* NET  3558 = abc_30082_new_n8633
* NET  3559 = abc_30082_new_n8632
* NET  3560 = abc_30082_new_n8631
* NET  3561 = abc_30082_new_n8630
* NET  3562 = abc_30082_new_n8629
* NET  3563 = abc_30082_new_n8628
* NET  3564 = abc_30082_new_n8627
* NET  3565 = abc_30082_new_n8626
* NET  3566 = abc_30082_new_n8624
* NET  3567 = abc_30082_new_n8623
* NET  3568 = abc_30082_new_n8622
* NET  3569 = abc_30082_new_n8621
* NET  3570 = abc_30082_new_n8620
* NET  3571 = abc_30082_new_n8619
* NET  3572 = abc_30082_new_n8618
* NET  3573 = abc_30082_new_n8616
* NET  3574 = abc_30082_new_n8615
* NET  3575 = abc_30082_new_n8614
* NET  3576 = abc_30082_new_n8613
* NET  3577 = abc_30082_new_n8612
* NET  3578 = abc_30082_new_n8611
* NET  3579 = abc_30082_new_n8610
* NET  3580 = abc_30082_new_n8609
* NET  3581 = abc_30082_new_n8608
* NET  3582 = abc_30082_new_n8607
* NET  3583 = abc_30082_new_n8606
* NET  3584 = abc_30082_new_n8605
* NET  3585 = abc_30082_new_n8604
* NET  3586 = abc_30082_new_n8603
* NET  3587 = abc_30082_new_n8602
* NET  3588 = abc_30082_new_n8601
* NET  3589 = abc_30082_new_n8600
* NET  3590 = abc_30082_new_n8599
* NET  3591 = abc_30082_new_n8597
* NET  3592 = abc_30082_new_n8596
* NET  3593 = abc_30082_new_n8595
* NET  3594 = abc_30082_new_n8594
* NET  3595 = abc_30082_new_n8593
* NET  3596 = abc_30082_new_n8592
* NET  3597 = abc_30082_new_n8591
* NET  3598 = abc_30082_new_n8590
* NET  3599 = abc_30082_new_n8588
* NET  3600 = abc_30082_new_n8587
* NET  3601 = abc_30082_new_n8586
* NET  3602 = abc_30082_new_n8585
* NET  3603 = abc_30082_new_n8584
* NET  3604 = abc_30082_new_n8583
* NET  3605 = abc_30082_new_n8582
* NET  3606 = abc_30082_new_n8581
* NET  3607 = abc_30082_new_n8580
* NET  3608 = abc_30082_new_n8579
* NET  3609 = abc_30082_new_n8578
* NET  3610 = abc_30082_new_n8577
* NET  3611 = abc_30082_new_n8576
* NET  3612 = abc_30082_new_n8575
* NET  3613 = abc_30082_new_n8573
* NET  3614 = abc_30082_new_n8572
* NET  3615 = abc_30082_new_n8571
* NET  3616 = abc_30082_new_n8570
* NET  3617 = abc_30082_new_n8569
* NET  3618 = abc_30082_new_n8568
* NET  3619 = abc_30082_new_n8567
* NET  3620 = abc_30082_new_n8566
* NET  3621 = abc_30082_new_n8565
* NET  3622 = abc_30082_new_n8564
* NET  3623 = abc_30082_new_n8563
* NET  3624 = abc_30082_new_n8562
* NET  3625 = abc_30082_new_n8561
* NET  3626 = abc_30082_new_n8559
* NET  3627 = abc_30082_new_n8558
* NET  3628 = abc_30082_new_n8557
* NET  3629 = abc_30082_new_n8556
* NET  3630 = abc_30082_new_n8555
* NET  3631 = abc_30082_new_n8554
* NET  3632 = abc_30082_new_n8553
* NET  3633 = abc_30082_new_n8552
* NET  3634 = abc_30082_new_n8551
* NET  3635 = abc_30082_new_n8550
* NET  3636 = abc_30082_new_n8549
* NET  3637 = abc_30082_new_n8548
* NET  3638 = abc_30082_new_n8547
* NET  3639 = abc_30082_new_n8546
* NET  3640 = abc_30082_new_n8544
* NET  3641 = abc_30082_new_n8543
* NET  3642 = abc_30082_new_n8542
* NET  3643 = abc_30082_new_n8541
* NET  3644 = abc_30082_new_n8540
* NET  3645 = abc_30082_new_n8539
* NET  3646 = abc_30082_new_n8538
* NET  3647 = abc_30082_new_n8537
* NET  3648 = abc_30082_new_n8536
* NET  3649 = abc_30082_new_n8535
* NET  3650 = abc_30082_new_n8534
* NET  3651 = abc_30082_new_n8533
* NET  3652 = abc_30082_new_n8531
* NET  3653 = abc_30082_new_n8530
* NET  3654 = abc_30082_new_n8529
* NET  3655 = abc_30082_new_n8528
* NET  3656 = abc_30082_new_n8527
* NET  3657 = abc_30082_new_n8526
* NET  3658 = abc_30082_new_n8525
* NET  3659 = abc_30082_new_n8524
* NET  3660 = abc_30082_new_n8523
* NET  3661 = abc_30082_new_n8522
* NET  3662 = abc_30082_new_n8521
* NET  3663 = abc_30082_new_n8520
* NET  3664 = abc_30082_new_n8519
* NET  3665 = abc_30082_new_n8518
* NET  3666 = abc_30082_new_n8516
* NET  3667 = abc_30082_new_n8515
* NET  3668 = abc_30082_new_n8514
* NET  3669 = abc_30082_new_n8513
* NET  3670 = abc_30082_new_n8512
* NET  3671 = abc_30082_new_n8511
* NET  3672 = abc_30082_new_n8510
* NET  3673 = abc_30082_new_n8509
* NET  3674 = abc_30082_new_n8508
* NET  3675 = abc_30082_new_n8507
* NET  3676 = abc_30082_new_n8506
* NET  3677 = abc_30082_new_n8505
* NET  3678 = abc_30082_new_n8504
* NET  3679 = abc_30082_new_n8502
* NET  3680 = abc_30082_new_n8501
* NET  3681 = abc_30082_new_n8500
* NET  3682 = abc_30082_new_n8499
* NET  3683 = abc_30082_new_n8498
* NET  3684 = abc_30082_new_n8497
* NET  3685 = abc_30082_new_n8496
* NET  3686 = abc_30082_new_n8495
* NET  3687 = abc_30082_new_n8494
* NET  3688 = abc_30082_new_n8493
* NET  3689 = abc_30082_new_n8492
* NET  3690 = abc_30082_new_n8491
* NET  3691 = abc_30082_new_n8490
* NET  3692 = abc_30082_new_n8488
* NET  3693 = abc_30082_new_n8487
* NET  3694 = abc_30082_new_n8486
* NET  3695 = abc_30082_new_n8485
* NET  3696 = abc_30082_new_n8484
* NET  3697 = abc_30082_new_n8483
* NET  3698 = abc_30082_new_n8482
* NET  3699 = abc_30082_new_n8481
* NET  3700 = abc_30082_new_n8480
* NET  3701 = abc_30082_new_n8479
* NET  3702 = abc_30082_new_n8478
* NET  3703 = abc_30082_new_n8477
* NET  3704 = abc_30082_new_n8476
* NET  3705 = abc_30082_new_n8474
* NET  3706 = abc_30082_new_n8473
* NET  3707 = abc_30082_new_n8472
* NET  3708 = abc_30082_new_n8471
* NET  3709 = abc_30082_new_n8470
* NET  3710 = abc_30082_new_n8469
* NET  3711 = abc_30082_new_n8468
* NET  3712 = abc_30082_new_n8467
* NET  3713 = abc_30082_new_n8466
* NET  3714 = abc_30082_new_n8465
* NET  3715 = abc_30082_new_n8464
* NET  3716 = abc_30082_new_n8463
* NET  3717 = abc_30082_new_n8462
* NET  3718 = abc_30082_new_n8461
* NET  3719 = abc_30082_new_n8459
* NET  3720 = abc_30082_new_n8458
* NET  3721 = abc_30082_new_n8457
* NET  3722 = abc_30082_new_n8456
* NET  3723 = abc_30082_new_n8455
* NET  3724 = abc_30082_new_n8454
* NET  3725 = abc_30082_new_n8453
* NET  3726 = abc_30082_new_n8452
* NET  3727 = abc_30082_new_n8451
* NET  3728 = abc_30082_new_n8450
* NET  3729 = abc_30082_new_n8449
* NET  3730 = abc_30082_new_n8448
* NET  3731 = abc_30082_new_n8446
* NET  3732 = abc_30082_new_n8445
* NET  3733 = abc_30082_new_n8444
* NET  3734 = abc_30082_new_n8443
* NET  3735 = abc_30082_new_n8442
* NET  3736 = abc_30082_new_n8441
* NET  3737 = abc_30082_new_n8440
* NET  3738 = abc_30082_new_n8439
* NET  3739 = abc_30082_new_n8438
* NET  3740 = abc_30082_new_n8437
* NET  3741 = abc_30082_new_n8436
* NET  3742 = abc_30082_new_n8435
* NET  3743 = abc_30082_new_n8434
* NET  3744 = abc_30082_new_n8433
* NET  3745 = abc_30082_new_n8431
* NET  3746 = abc_30082_new_n8430
* NET  3747 = abc_30082_new_n8429
* NET  3748 = abc_30082_new_n8428
* NET  3749 = abc_30082_new_n8427
* NET  3750 = abc_30082_new_n8426
* NET  3751 = abc_30082_new_n8425
* NET  3752 = abc_30082_new_n8424
* NET  3753 = abc_30082_new_n8423
* NET  3754 = abc_30082_new_n8422
* NET  3755 = abc_30082_new_n8421
* NET  3756 = abc_30082_new_n8420
* NET  3757 = abc_30082_new_n8419
* NET  3758 = abc_30082_new_n8417
* NET  3759 = abc_30082_new_n8416
* NET  3760 = abc_30082_new_n8415
* NET  3761 = abc_30082_new_n8414
* NET  3762 = abc_30082_new_n8413
* NET  3763 = abc_30082_new_n8412
* NET  3764 = abc_30082_new_n8411
* NET  3765 = abc_30082_new_n8410
* NET  3766 = abc_30082_new_n8409
* NET  3767 = abc_30082_new_n8408
* NET  3768 = abc_30082_new_n8407
* NET  3769 = abc_30082_new_n8406
* NET  3770 = abc_30082_new_n8405
* NET  3771 = abc_30082_new_n8403
* NET  3772 = abc_30082_new_n8402
* NET  3773 = abc_30082_new_n8401
* NET  3774 = abc_30082_new_n8400
* NET  3775 = abc_30082_new_n8399
* NET  3776 = abc_30082_new_n8398
* NET  3777 = abc_30082_new_n8397
* NET  3778 = abc_30082_new_n8396
* NET  3779 = abc_30082_new_n8395
* NET  3780 = abc_30082_new_n8394
* NET  3781 = abc_30082_new_n8393
* NET  3782 = abc_30082_new_n8392
* NET  3783 = abc_30082_new_n8391
* NET  3784 = abc_30082_new_n8389
* NET  3785 = abc_30082_new_n8388
* NET  3786 = abc_30082_new_n8387
* NET  3787 = abc_30082_new_n8386
* NET  3788 = abc_30082_new_n8385
* NET  3789 = abc_30082_new_n8384
* NET  3790 = abc_30082_new_n8383
* NET  3791 = abc_30082_new_n8382
* NET  3792 = abc_30082_new_n8381
* NET  3793 = abc_30082_new_n8380
* NET  3794 = abc_30082_new_n8379
* NET  3795 = abc_30082_new_n8378
* NET  3796 = abc_30082_new_n8377
* NET  3797 = abc_30082_new_n8376
* NET  3798 = abc_30082_new_n8374
* NET  3799 = abc_30082_new_n8373
* NET  3800 = abc_30082_new_n8372
* NET  3801 = abc_30082_new_n8371
* NET  3802 = abc_30082_new_n8370
* NET  3803 = abc_30082_new_n8369
* NET  3804 = abc_30082_new_n8368
* NET  3805 = abc_30082_new_n8367
* NET  3806 = abc_30082_new_n8366
* NET  3807 = abc_30082_new_n8365
* NET  3808 = abc_30082_new_n8364
* NET  3809 = abc_30082_new_n8363
* NET  3810 = abc_30082_new_n8361
* NET  3811 = abc_30082_new_n8360
* NET  3812 = abc_30082_new_n8359
* NET  3813 = abc_30082_new_n8358
* NET  3814 = abc_30082_new_n8357
* NET  3815 = abc_30082_new_n8356
* NET  3816 = abc_30082_new_n8355
* NET  3817 = abc_30082_new_n8354
* NET  3818 = abc_30082_new_n8353
* NET  3819 = abc_30082_new_n8352
* NET  3820 = abc_30082_new_n8351
* NET  3821 = abc_30082_new_n8350
* NET  3822 = abc_30082_new_n8349
* NET  3823 = abc_30082_new_n8347
* NET  3824 = abc_30082_new_n8346
* NET  3825 = abc_30082_new_n8345
* NET  3826 = abc_30082_new_n8344
* NET  3827 = abc_30082_new_n8343
* NET  3828 = abc_30082_new_n8342
* NET  3829 = abc_30082_new_n8341
* NET  3830 = abc_30082_new_n8340
* NET  3831 = abc_30082_new_n8339
* NET  3832 = abc_30082_new_n8338
* NET  3833 = abc_30082_new_n8337
* NET  3834 = abc_30082_new_n8336
* NET  3835 = abc_30082_new_n8335
* NET  3836 = abc_30082_new_n8334
* NET  3837 = abc_30082_new_n8332
* NET  3838 = abc_30082_new_n8331
* NET  3839 = abc_30082_new_n8330
* NET  3840 = abc_30082_new_n8329
* NET  3841 = abc_30082_new_n8328
* NET  3842 = abc_30082_new_n8327
* NET  3843 = abc_30082_new_n8326
* NET  3844 = abc_30082_new_n8325
* NET  3845 = abc_30082_new_n8324
* NET  3846 = abc_30082_new_n8323
* NET  3847 = abc_30082_new_n8321
* NET  3848 = abc_30082_new_n8320
* NET  3849 = abc_30082_new_n8319
* NET  3850 = abc_30082_new_n8318
* NET  3851 = abc_30082_new_n8317
* NET  3852 = abc_30082_new_n8316
* NET  3853 = abc_30082_new_n8315
* NET  3854 = abc_30082_new_n8314
* NET  3855 = abc_30082_new_n8313
* NET  3856 = abc_30082_new_n8312
* NET  3857 = abc_30082_new_n8310
* NET  3858 = abc_30082_new_n8309
* NET  3859 = abc_30082_new_n8308
* NET  3860 = abc_30082_new_n8307
* NET  3861 = abc_30082_new_n8305
* NET  3862 = abc_30082_new_n8304
* NET  3863 = abc_30082_new_n8303
* NET  3864 = abc_30082_new_n8301
* NET  3865 = abc_30082_new_n8300
* NET  3866 = abc_30082_new_n8299
* NET  3867 = abc_30082_new_n8297
* NET  3868 = abc_30082_new_n8296
* NET  3869 = abc_30082_new_n8295
* NET  3870 = abc_30082_new_n8293
* NET  3871 = abc_30082_new_n8292
* NET  3872 = abc_30082_new_n8291
* NET  3873 = abc_30082_new_n8289
* NET  3874 = abc_30082_new_n8288
* NET  3875 = abc_30082_new_n8287
* NET  3876 = abc_30082_new_n8285
* NET  3877 = abc_30082_new_n8284
* NET  3878 = abc_30082_new_n8283
* NET  3879 = abc_30082_new_n8281
* NET  3880 = abc_30082_new_n8280
* NET  3881 = abc_30082_new_n8279
* NET  3882 = abc_30082_new_n8277
* NET  3883 = abc_30082_new_n8276
* NET  3884 = abc_30082_new_n8275
* NET  3885 = abc_30082_new_n8273
* NET  3886 = abc_30082_new_n8272
* NET  3887 = abc_30082_new_n8271
* NET  3888 = abc_30082_new_n8269
* NET  3889 = abc_30082_new_n8268
* NET  3890 = abc_30082_new_n8267
* NET  3891 = abc_30082_new_n8265
* NET  3892 = abc_30082_new_n8264
* NET  3893 = abc_30082_new_n8263
* NET  3894 = abc_30082_new_n8261
* NET  3895 = abc_30082_new_n8260
* NET  3896 = abc_30082_new_n8259
* NET  3897 = abc_30082_new_n8257
* NET  3898 = abc_30082_new_n8256
* NET  3899 = abc_30082_new_n8255
* NET  3900 = abc_30082_new_n8253
* NET  3901 = abc_30082_new_n8252
* NET  3902 = abc_30082_new_n8251
* NET  3903 = abc_30082_new_n8249
* NET  3904 = abc_30082_new_n8248
* NET  3905 = abc_30082_new_n8247
* NET  3906 = abc_30082_new_n8245
* NET  3907 = abc_30082_new_n8244
* NET  3908 = abc_30082_new_n8243
* NET  3909 = abc_30082_new_n8241
* NET  3910 = abc_30082_new_n8240
* NET  3911 = abc_30082_new_n8239
* NET  3912 = abc_30082_new_n8237
* NET  3913 = abc_30082_new_n8236
* NET  3914 = abc_30082_new_n8235
* NET  3915 = abc_30082_new_n8233
* NET  3916 = abc_30082_new_n8232
* NET  3917 = abc_30082_new_n8231
* NET  3918 = abc_30082_new_n8229
* NET  3919 = abc_30082_new_n8228
* NET  3920 = abc_30082_new_n8227
* NET  3921 = abc_30082_new_n8225
* NET  3922 = abc_30082_new_n8224
* NET  3923 = abc_30082_new_n8223
* NET  3924 = abc_30082_new_n8221
* NET  3925 = abc_30082_new_n8220
* NET  3926 = abc_30082_new_n8219
* NET  3927 = abc_30082_new_n8217
* NET  3928 = abc_30082_new_n8216
* NET  3929 = abc_30082_new_n8215
* NET  3930 = abc_30082_new_n8213
* NET  3931 = abc_30082_new_n8212
* NET  3932 = abc_30082_new_n8211
* NET  3933 = abc_30082_new_n8209
* NET  3934 = abc_30082_new_n8208
* NET  3935 = abc_30082_new_n8207
* NET  3936 = abc_30082_new_n8205
* NET  3937 = abc_30082_new_n8204
* NET  3938 = abc_30082_new_n8203
* NET  3939 = abc_30082_new_n8201
* NET  3940 = abc_30082_new_n8200
* NET  3941 = abc_30082_new_n8199
* NET  3942 = abc_30082_new_n8197
* NET  3943 = abc_30082_new_n8196
* NET  3944 = abc_30082_new_n8195
* NET  3945 = abc_30082_new_n8193
* NET  3946 = abc_30082_new_n8192
* NET  3947 = abc_30082_new_n8191
* NET  3948 = abc_30082_new_n8189
* NET  3949 = abc_30082_new_n8188
* NET  3950 = abc_30082_new_n8187
* NET  3951 = abc_30082_new_n8185
* NET  3952 = abc_30082_new_n8184
* NET  3953 = abc_30082_new_n8182
* NET  3954 = abc_30082_new_n8180
* NET  3955 = abc_30082_new_n8179
* NET  3956 = abc_30082_new_n8177
* NET  3957 = abc_30082_new_n8176
* NET  3958 = abc_30082_new_n8175
* NET  3959 = abc_30082_new_n8174
* NET  3960 = abc_30082_new_n8172
* NET  3961 = abc_30082_new_n8171
* NET  3962 = abc_30082_new_n8169
* NET  3963 = abc_30082_new_n8168
* NET  3964 = abc_30082_new_n8166
* NET  3965 = abc_30082_new_n8165
* NET  3966 = abc_30082_new_n8164
* NET  3967 = abc_30082_new_n8162
* NET  3968 = abc_30082_new_n8161
* NET  3969 = abc_30082_new_n8160
* NET  3970 = abc_30082_new_n8158
* NET  3971 = abc_30082_new_n8157
* NET  3972 = abc_30082_new_n8155
* NET  3973 = abc_30082_new_n8153
* NET  3974 = abc_30082_new_n8152
* NET  3975 = abc_30082_new_n8151
* NET  3976 = abc_30082_new_n8149
* NET  3977 = abc_30082_new_n8147
* NET  3978 = abc_30082_new_n8146
* NET  3979 = abc_30082_new_n8145
* NET  3980 = abc_30082_new_n8144
* NET  3981 = abc_30082_new_n8142
* NET  3982 = abc_30082_new_n8141
* NET  3983 = abc_30082_new_n8139
* NET  3984 = abc_30082_new_n8138
* NET  3985 = abc_30082_new_n8137
* NET  3986 = abc_30082_new_n8136
* NET  3987 = abc_30082_new_n8134
* NET  3988 = abc_30082_new_n8132
* NET  3989 = abc_30082_new_n8131
* NET  3990 = abc_30082_new_n8130
* NET  3991 = abc_30082_new_n8129
* NET  3992 = abc_30082_new_n8128
* NET  3993 = abc_30082_new_n8126
* NET  3994 = abc_30082_new_n8124
* NET  3995 = abc_30082_new_n8123
* NET  3996 = abc_30082_new_n8122
* NET  3997 = abc_30082_new_n8121
* NET  3998 = abc_30082_new_n8120
* NET  3999 = abc_30082_new_n8118
* NET  4000 = abc_30082_new_n8116
* NET  4001 = abc_30082_new_n8115
* NET  4002 = abc_30082_new_n8114
* NET  4003 = abc_30082_new_n8113
* NET  4004 = abc_30082_new_n8112
* NET  4005 = abc_30082_new_n8110
* NET  4006 = abc_30082_new_n8108
* NET  4007 = abc_30082_new_n8107
* NET  4008 = abc_30082_new_n8106
* NET  4009 = abc_30082_new_n8105
* NET  4010 = abc_30082_new_n8104
* NET  4011 = abc_30082_new_n8102
* NET  4012 = abc_30082_new_n8100
* NET  4013 = abc_30082_new_n8099
* NET  4014 = abc_30082_new_n8098
* NET  4015 = abc_30082_new_n8097
* NET  4016 = abc_30082_new_n8096
* NET  4017 = abc_30082_new_n8095
* NET  4018 = abc_30082_new_n8094
* NET  4019 = abc_30082_new_n8092
* NET  4020 = abc_30082_new_n8090
* NET  4021 = abc_30082_new_n8089
* NET  4022 = abc_30082_new_n8088
* NET  4023 = abc_30082_new_n8087
* NET  4024 = abc_30082_new_n8085
* NET  4025 = abc_30082_new_n8083
* NET  4026 = abc_30082_new_n8082
* NET  4027 = abc_30082_new_n8081
* NET  4028 = abc_30082_new_n8080
* NET  4029 = abc_30082_new_n8079
* NET  4030 = abc_30082_new_n8077
* NET  4031 = abc_30082_new_n8076
* NET  4032 = abc_30082_new_n8074
* NET  4033 = abc_30082_new_n8073
* NET  4034 = abc_30082_new_n8072
* NET  4035 = abc_30082_new_n8071
* NET  4036 = abc_30082_new_n8069
* NET  4037 = abc_30082_new_n8067
* NET  4038 = abc_30082_new_n8066
* NET  4039 = abc_30082_new_n8065
* NET  4040 = abc_30082_new_n8064
* NET  4041 = abc_30082_new_n8063
* NET  4042 = abc_30082_new_n8062
* NET  4043 = abc_30082_new_n8061
* NET  4044 = abc_30082_new_n8059
* NET  4045 = abc_30082_new_n8058
* NET  4046 = abc_30082_new_n8056
* NET  4047 = abc_30082_new_n8055
* NET  4048 = abc_30082_new_n8054
* NET  4049 = abc_30082_new_n8053
* NET  4050 = abc_30082_new_n8051
* NET  4051 = abc_30082_new_n8049
* NET  4052 = abc_30082_new_n8048
* NET  4053 = abc_30082_new_n8047
* NET  4054 = abc_30082_new_n8046
* NET  4055 = abc_30082_new_n8044
* NET  4056 = abc_30082_new_n8042
* NET  4057 = abc_30082_new_n8041
* NET  4058 = abc_30082_new_n8040
* NET  4059 = abc_30082_new_n8039
* NET  4060 = abc_30082_new_n8037
* NET  4061 = abc_30082_new_n8036
* NET  4062 = abc_30082_new_n8034
* NET  4063 = abc_30082_new_n8033
* NET  4064 = abc_30082_new_n8032
* NET  4065 = abc_30082_new_n8031
* NET  4066 = abc_30082_new_n8030
* NET  4067 = abc_30082_new_n8028
* NET  4068 = abc_30082_new_n8027
* NET  4069 = abc_30082_new_n8025
* NET  4070 = abc_30082_new_n8024
* NET  4071 = abc_30082_new_n8023
* NET  4072 = abc_30082_new_n8022
* NET  4073 = abc_30082_new_n8020
* NET  4074 = abc_30082_new_n8018
* NET  4075 = abc_30082_new_n8017
* NET  4076 = abc_30082_new_n8016
* NET  4077 = abc_30082_new_n8015
* NET  4078 = abc_30082_new_n8014
* NET  4079 = abc_30082_new_n8012
* NET  4080 = abc_30082_new_n8011
* NET  4081 = abc_30082_new_n8009
* NET  4082 = abc_30082_new_n8008
* NET  4083 = abc_30082_new_n8007
* NET  4084 = abc_30082_new_n8006
* NET  4085 = abc_30082_new_n8005
* NET  4086 = abc_30082_new_n8003
* NET  4087 = abc_30082_new_n8001
* NET  4088 = abc_30082_new_n8000
* NET  4089 = abc_30082_new_n7999
* NET  4090 = abc_30082_new_n7998
* NET  4091 = abc_30082_new_n7997
* NET  4092 = abc_30082_new_n7996
* NET  4093 = abc_30082_new_n7994
* NET  4094 = abc_30082_new_n7992
* NET  4095 = abc_30082_new_n7991
* NET  4096 = abc_30082_new_n7990
* NET  4097 = abc_30082_new_n7989
* NET  4098 = abc_30082_new_n7988
* NET  4099 = abc_30082_new_n7986
* NET  4100 = abc_30082_new_n7985
* NET  4101 = abc_30082_new_n7983
* NET  4102 = abc_30082_new_n7982
* NET  4103 = abc_30082_new_n7981
* NET  4104 = abc_30082_new_n7980
* NET  4105 = abc_30082_new_n7979
* NET  4106 = abc_30082_new_n7978
* NET  4107 = abc_30082_new_n7977
* NET  4108 = abc_30082_new_n7975
* NET  4109 = abc_30082_new_n7973
* NET  4110 = abc_30082_new_n7972
* NET  4111 = abc_30082_new_n7971
* NET  4112 = abc_30082_new_n7970
* NET  4113 = abc_30082_new_n7968
* NET  4114 = abc_30082_new_n7966
* NET  4115 = abc_30082_new_n7965
* NET  4116 = abc_30082_new_n7964
* NET  4117 = abc_30082_new_n7963
* NET  4118 = abc_30082_new_n7962
* NET  4119 = abc_30082_new_n7960
* NET  4120 = abc_30082_new_n7959
* NET  4121 = abc_30082_new_n7957
* NET  4122 = abc_30082_new_n7956
* NET  4123 = abc_30082_new_n7955
* NET  4124 = abc_30082_new_n7954
* NET  4125 = abc_30082_new_n7952
* NET  4126 = abc_30082_new_n7950
* NET  4127 = abc_30082_new_n7949
* NET  4128 = abc_30082_new_n7948
* NET  4129 = abc_30082_new_n7947
* NET  4130 = abc_30082_new_n7945
* NET  4131 = abc_30082_new_n7944
* NET  4132 = abc_30082_new_n7942
* NET  4133 = abc_30082_new_n7941
* NET  4134 = abc_30082_new_n7940
* NET  4135 = abc_30082_new_n7938
* NET  4136 = abc_30082_new_n7936
* NET  4137 = abc_30082_new_n7935
* NET  4138 = abc_30082_new_n7934
* NET  4139 = abc_30082_new_n7933
* NET  4140 = abc_30082_new_n7932_hfns_3
* NET  4141 = abc_30082_new_n7932_hfns_2
* NET  4142 = abc_30082_new_n7932_hfns_1
* NET  4143 = abc_30082_new_n7932_hfns_0
* NET  4144 = abc_30082_new_n7932
* NET  4145 = abc_30082_new_n7899_hfns_2
* NET  4146 = abc_30082_new_n7899_hfns_1
* NET  4147 = abc_30082_new_n7899_hfns_0
* NET  4148 = abc_30082_new_n7899
* NET  4149 = abc_30082_new_n7898
* NET  4150 = abc_30082_new_n7865_hfns_2
* NET  4151 = abc_30082_new_n7865_hfns_1
* NET  4152 = abc_30082_new_n7865_hfns_0
* NET  4153 = abc_30082_new_n7865
* NET  4154 = abc_30082_new_n7864
* NET  4155 = abc_30082_new_n7831_hfns_2
* NET  4156 = abc_30082_new_n7831_hfns_1
* NET  4157 = abc_30082_new_n7831_hfns_0
* NET  4158 = abc_30082_new_n7831
* NET  4159 = abc_30082_new_n7830
* NET  4160 = abc_30082_new_n7797_hfns_2
* NET  4161 = abc_30082_new_n7797_hfns_1
* NET  4162 = abc_30082_new_n7797_hfns_0
* NET  4163 = abc_30082_new_n7797
* NET  4164 = abc_30082_new_n7796
* NET  4165 = abc_30082_new_n7795
* NET  4166 = abc_30082_new_n7762_hfns_2
* NET  4167 = abc_30082_new_n7762_hfns_1
* NET  4168 = abc_30082_new_n7762_hfns_0
* NET  4169 = abc_30082_new_n7762
* NET  4170 = abc_30082_new_n7761
* NET  4171 = abc_30082_new_n7760
* NET  4172 = abc_30082_new_n7727_hfns_2
* NET  4173 = abc_30082_new_n7727_hfns_1
* NET  4174 = abc_30082_new_n7727_hfns_0
* NET  4175 = abc_30082_new_n7727
* NET  4176 = abc_30082_new_n7726
* NET  4177 = abc_30082_new_n7693_hfns_2
* NET  4178 = abc_30082_new_n7693_hfns_1
* NET  4179 = abc_30082_new_n7693_hfns_0
* NET  4180 = abc_30082_new_n7693
* NET  4181 = abc_30082_new_n7692
* NET  4182 = abc_30082_new_n7691
* NET  4183 = abc_30082_new_n7690
* NET  4184 = abc_30082_new_n7657_hfns_2
* NET  4185 = abc_30082_new_n7657_hfns_1
* NET  4186 = abc_30082_new_n7657_hfns_0
* NET  4187 = abc_30082_new_n7657
* NET  4188 = abc_30082_new_n7656
* NET  4189 = abc_30082_new_n7623_hfns_2
* NET  4190 = abc_30082_new_n7623_hfns_1
* NET  4191 = abc_30082_new_n7623_hfns_0
* NET  4192 = abc_30082_new_n7623
* NET  4193 = abc_30082_new_n7622
* NET  4194 = abc_30082_new_n7621
* NET  4195 = abc_30082_new_n7620
* NET  4196 = abc_30082_new_n7619
* NET  4197 = abc_30082_new_n7586_hfns_2
* NET  4198 = abc_30082_new_n7586_hfns_1
* NET  4199 = abc_30082_new_n7586_hfns_0
* NET  4200 = abc_30082_new_n7586
* NET  4201 = abc_30082_new_n7585
* NET  4202 = abc_30082_new_n7552_hfns_2
* NET  4203 = abc_30082_new_n7552_hfns_1
* NET  4204 = abc_30082_new_n7552_hfns_0
* NET  4205 = abc_30082_new_n7552
* NET  4206 = abc_30082_new_n7551
* NET  4207 = abc_30082_new_n7518_hfns_2
* NET  4208 = abc_30082_new_n7518_hfns_1
* NET  4209 = abc_30082_new_n7518_hfns_0
* NET  4210 = abc_30082_new_n7518
* NET  4211 = abc_30082_new_n7517
* NET  4212 = abc_30082_new_n7516
* NET  4213 = abc_30082_new_n7483_hfns_2
* NET  4214 = abc_30082_new_n7483_hfns_1
* NET  4215 = abc_30082_new_n7483_hfns_0
* NET  4216 = abc_30082_new_n7483
* NET  4217 = abc_30082_new_n7482
* NET  4218 = abc_30082_new_n7481
* NET  4219 = abc_30082_new_n7480
* NET  4220 = abc_30082_new_n7479
* NET  4221 = abc_30082_new_n7478
* NET  4222 = abc_30082_new_n7445_hfns_2
* NET  4223 = abc_30082_new_n7445_hfns_1
* NET  4224 = abc_30082_new_n7445_hfns_0
* NET  4225 = abc_30082_new_n7445
* NET  4226 = abc_30082_new_n7444
* NET  4227 = abc_30082_new_n7443
* NET  4228 = abc_30082_new_n7441
* NET  4229 = abc_30082_new_n7440
* NET  4230 = abc_30082_new_n7439
* NET  4231 = abc_30082_new_n7438
* NET  4232 = abc_30082_new_n7437
* NET  4233 = abc_30082_new_n7436
* NET  4234 = abc_30082_new_n7435
* NET  4235 = abc_30082_new_n7434
* NET  4236 = abc_30082_new_n7433
* NET  4237 = abc_30082_new_n7432
* NET  4238 = abc_30082_new_n7431
* NET  4239 = abc_30082_new_n7430
* NET  4240 = abc_30082_new_n7429
* NET  4241 = abc_30082_new_n7428
* NET  4242 = abc_30082_new_n7427
* NET  4243 = abc_30082_new_n7426
* NET  4244 = abc_30082_new_n7425
* NET  4245 = abc_30082_new_n7424
* NET  4246 = abc_30082_new_n7423
* NET  4247 = abc_30082_new_n7422
* NET  4248 = abc_30082_new_n7421
* NET  4249 = abc_30082_new_n7420
* NET  4250 = abc_30082_new_n7419
* NET  4251 = abc_30082_new_n7418
* NET  4252 = abc_30082_new_n7417
* NET  4253 = abc_30082_new_n7416
* NET  4254 = abc_30082_new_n7415
* NET  4255 = abc_30082_new_n7414
* NET  4256 = abc_30082_new_n7413
* NET  4257 = abc_30082_new_n7412
* NET  4258 = abc_30082_new_n7411
* NET  4259 = abc_30082_new_n7410
* NET  4260 = abc_30082_new_n7409
* NET  4261 = abc_30082_new_n7408
* NET  4262 = abc_30082_new_n7407
* NET  4263 = abc_30082_new_n7406
* NET  4264 = abc_30082_new_n7405
* NET  4265 = abc_30082_new_n7404
* NET  4266 = abc_30082_new_n7403
* NET  4267 = abc_30082_new_n7402
* NET  4268 = abc_30082_new_n7401
* NET  4269 = abc_30082_new_n7400
* NET  4270 = abc_30082_new_n7399
* NET  4271 = abc_30082_new_n7398
* NET  4272 = abc_30082_new_n7397
* NET  4273 = abc_30082_new_n7396
* NET  4274 = abc_30082_new_n7395
* NET  4275 = abc_30082_new_n7394
* NET  4276 = abc_30082_new_n7393
* NET  4277 = abc_30082_new_n7392
* NET  4278 = abc_30082_new_n7391
* NET  4279 = abc_30082_new_n7390
* NET  4280 = abc_30082_new_n7388
* NET  4281 = abc_30082_new_n7387
* NET  4282 = abc_30082_new_n7386
* NET  4283 = abc_30082_new_n7385
* NET  4284 = abc_30082_new_n7384
* NET  4285 = abc_30082_new_n7383
* NET  4286 = abc_30082_new_n7382
* NET  4287 = abc_30082_new_n7381
* NET  4288 = abc_30082_new_n7380
* NET  4289 = abc_30082_new_n7379
* NET  4290 = abc_30082_new_n7378
* NET  4291 = abc_30082_new_n7377
* NET  4292 = abc_30082_new_n7376
* NET  4293 = abc_30082_new_n7375
* NET  4294 = abc_30082_new_n7374
* NET  4295 = abc_30082_new_n7373
* NET  4296 = abc_30082_new_n7372
* NET  4297 = abc_30082_new_n7371
* NET  4298 = abc_30082_new_n7370
* NET  4299 = abc_30082_new_n7369
* NET  4300 = abc_30082_new_n7368
* NET  4301 = abc_30082_new_n7367
* NET  4302 = abc_30082_new_n7366
* NET  4303 = abc_30082_new_n7365
* NET  4304 = abc_30082_new_n7364
* NET  4305 = abc_30082_new_n7363
* NET  4306 = abc_30082_new_n7362
* NET  4307 = abc_30082_new_n7361
* NET  4308 = abc_30082_new_n7360
* NET  4309 = abc_30082_new_n7359
* NET  4310 = abc_30082_new_n7358
* NET  4311 = abc_30082_new_n7357
* NET  4312 = abc_30082_new_n7356
* NET  4313 = abc_30082_new_n7355
* NET  4314 = abc_30082_new_n7354
* NET  4315 = abc_30082_new_n7353
* NET  4316 = abc_30082_new_n7352
* NET  4317 = abc_30082_new_n7351
* NET  4318 = abc_30082_new_n7350
* NET  4319 = abc_30082_new_n7349
* NET  4320 = abc_30082_new_n7348
* NET  4321 = abc_30082_new_n7347
* NET  4322 = abc_30082_new_n7346
* NET  4323 = abc_30082_new_n7345
* NET  4324 = abc_30082_new_n7344
* NET  4325 = abc_30082_new_n7343
* NET  4326 = abc_30082_new_n7342
* NET  4327 = abc_30082_new_n7341
* NET  4328 = abc_30082_new_n7340
* NET  4329 = abc_30082_new_n7339
* NET  4330 = abc_30082_new_n7338
* NET  4331 = abc_30082_new_n7337
* NET  4332 = abc_30082_new_n7336
* NET  4333 = abc_30082_new_n7335
* NET  4334 = abc_30082_new_n7334
* NET  4335 = abc_30082_new_n7332
* NET  4336 = abc_30082_new_n7331
* NET  4337 = abc_30082_new_n7330
* NET  4338 = abc_30082_new_n7329
* NET  4339 = abc_30082_new_n7328
* NET  4340 = abc_30082_new_n7327
* NET  4341 = abc_30082_new_n7326
* NET  4342 = abc_30082_new_n7325
* NET  4343 = abc_30082_new_n7324
* NET  4344 = abc_30082_new_n7323
* NET  4345 = abc_30082_new_n7322
* NET  4346 = abc_30082_new_n7321
* NET  4347 = abc_30082_new_n7320
* NET  4348 = abc_30082_new_n7319
* NET  4349 = abc_30082_new_n7318
* NET  4350 = abc_30082_new_n7317
* NET  4351 = abc_30082_new_n7316
* NET  4352 = abc_30082_new_n7315
* NET  4353 = abc_30082_new_n7314
* NET  4354 = abc_30082_new_n7313
* NET  4355 = abc_30082_new_n7312
* NET  4356 = abc_30082_new_n7311
* NET  4357 = abc_30082_new_n7310
* NET  4358 = abc_30082_new_n7309
* NET  4359 = abc_30082_new_n7308
* NET  4360 = abc_30082_new_n7307
* NET  4361 = abc_30082_new_n7306
* NET  4362 = abc_30082_new_n7305
* NET  4363 = abc_30082_new_n7304
* NET  4364 = abc_30082_new_n7303
* NET  4365 = abc_30082_new_n7302
* NET  4366 = abc_30082_new_n7301
* NET  4367 = abc_30082_new_n7300
* NET  4368 = abc_30082_new_n7299
* NET  4369 = abc_30082_new_n7298
* NET  4370 = abc_30082_new_n7297
* NET  4371 = abc_30082_new_n7296
* NET  4372 = abc_30082_new_n7295
* NET  4373 = abc_30082_new_n7294
* NET  4374 = abc_30082_new_n7293
* NET  4375 = abc_30082_new_n7292
* NET  4376 = abc_30082_new_n7291
* NET  4377 = abc_30082_new_n7290
* NET  4378 = abc_30082_new_n7289
* NET  4379 = abc_30082_new_n7288
* NET  4380 = abc_30082_new_n7287
* NET  4381 = abc_30082_new_n7286
* NET  4382 = abc_30082_new_n7285
* NET  4383 = abc_30082_new_n7284
* NET  4384 = abc_30082_new_n7283
* NET  4385 = abc_30082_new_n7282
* NET  4386 = abc_30082_new_n7281
* NET  4387 = abc_30082_new_n7280
* NET  4388 = abc_30082_new_n7279
* NET  4389 = abc_30082_new_n7278
* NET  4390 = abc_30082_new_n7277
* NET  4391 = abc_30082_new_n7276
* NET  4392 = abc_30082_new_n7274
* NET  4393 = abc_30082_new_n7273
* NET  4394 = abc_30082_new_n7272
* NET  4395 = abc_30082_new_n7271
* NET  4396 = abc_30082_new_n7270
* NET  4397 = abc_30082_new_n7269
* NET  4398 = abc_30082_new_n7268
* NET  4399 = abc_30082_new_n7267
* NET  4400 = abc_30082_new_n7266
* NET  4401 = abc_30082_new_n7265
* NET  4402 = abc_30082_new_n7264
* NET  4403 = abc_30082_new_n7263
* NET  4404 = abc_30082_new_n7262
* NET  4405 = abc_30082_new_n7261
* NET  4406 = abc_30082_new_n7260
* NET  4407 = abc_30082_new_n7259
* NET  4408 = abc_30082_new_n7258
* NET  4409 = abc_30082_new_n7257
* NET  4410 = abc_30082_new_n7256
* NET  4411 = abc_30082_new_n7255
* NET  4412 = abc_30082_new_n7254
* NET  4413 = abc_30082_new_n7253
* NET  4414 = abc_30082_new_n7252
* NET  4415 = abc_30082_new_n7251
* NET  4416 = abc_30082_new_n7250
* NET  4417 = abc_30082_new_n7249
* NET  4418 = abc_30082_new_n7248
* NET  4419 = abc_30082_new_n7247
* NET  4420 = abc_30082_new_n7246
* NET  4421 = abc_30082_new_n7245
* NET  4422 = abc_30082_new_n7244
* NET  4423 = abc_30082_new_n7243
* NET  4424 = abc_30082_new_n7242
* NET  4425 = abc_30082_new_n7241
* NET  4426 = abc_30082_new_n7240
* NET  4427 = abc_30082_new_n7239
* NET  4428 = abc_30082_new_n7238
* NET  4429 = abc_30082_new_n7237
* NET  4430 = abc_30082_new_n7236
* NET  4431 = abc_30082_new_n7235
* NET  4432 = abc_30082_new_n7234
* NET  4433 = abc_30082_new_n7233
* NET  4434 = abc_30082_new_n7232
* NET  4435 = abc_30082_new_n7231
* NET  4436 = abc_30082_new_n7230
* NET  4437 = abc_30082_new_n7229
* NET  4438 = abc_30082_new_n7228
* NET  4439 = abc_30082_new_n7227
* NET  4440 = abc_30082_new_n7226
* NET  4441 = abc_30082_new_n7225
* NET  4442 = abc_30082_new_n7224
* NET  4443 = abc_30082_new_n7223
* NET  4444 = abc_30082_new_n7222
* NET  4445 = abc_30082_new_n7221
* NET  4446 = abc_30082_new_n7220
* NET  4447 = abc_30082_new_n7219
* NET  4448 = abc_30082_new_n7218
* NET  4449 = abc_30082_new_n7217
* NET  4450 = abc_30082_new_n7216
* NET  4451 = abc_30082_new_n7215
* NET  4452 = abc_30082_new_n7213
* NET  4453 = abc_30082_new_n7212
* NET  4454 = abc_30082_new_n7211
* NET  4455 = abc_30082_new_n7210
* NET  4456 = abc_30082_new_n7209
* NET  4457 = abc_30082_new_n7208
* NET  4458 = abc_30082_new_n7207
* NET  4459 = abc_30082_new_n7206
* NET  4460 = abc_30082_new_n7205
* NET  4461 = abc_30082_new_n7204
* NET  4462 = abc_30082_new_n7203
* NET  4463 = abc_30082_new_n7202
* NET  4464 = abc_30082_new_n7201
* NET  4465 = abc_30082_new_n7200
* NET  4466 = abc_30082_new_n7199
* NET  4467 = abc_30082_new_n7198
* NET  4468 = abc_30082_new_n7197
* NET  4469 = abc_30082_new_n7196
* NET  4470 = abc_30082_new_n7195
* NET  4471 = abc_30082_new_n7194
* NET  4472 = abc_30082_new_n7193
* NET  4473 = abc_30082_new_n7192
* NET  4474 = abc_30082_new_n7191
* NET  4475 = abc_30082_new_n7190
* NET  4476 = abc_30082_new_n7189
* NET  4477 = abc_30082_new_n7188
* NET  4478 = abc_30082_new_n7187
* NET  4479 = abc_30082_new_n7186
* NET  4480 = abc_30082_new_n7185
* NET  4481 = abc_30082_new_n7184
* NET  4482 = abc_30082_new_n7183
* NET  4483 = abc_30082_new_n7182
* NET  4484 = abc_30082_new_n7181
* NET  4485 = abc_30082_new_n7180
* NET  4486 = abc_30082_new_n7179
* NET  4487 = abc_30082_new_n7178
* NET  4488 = abc_30082_new_n7177
* NET  4489 = abc_30082_new_n7176
* NET  4490 = abc_30082_new_n7175
* NET  4491 = abc_30082_new_n7174
* NET  4492 = abc_30082_new_n7173
* NET  4493 = abc_30082_new_n7172
* NET  4494 = abc_30082_new_n7171
* NET  4495 = abc_30082_new_n7170
* NET  4496 = abc_30082_new_n7169
* NET  4497 = abc_30082_new_n7168
* NET  4498 = abc_30082_new_n7167
* NET  4499 = abc_30082_new_n7166
* NET  4500 = abc_30082_new_n7165
* NET  4501 = abc_30082_new_n7164
* NET  4502 = abc_30082_new_n7163
* NET  4503 = abc_30082_new_n7162
* NET  4504 = abc_30082_new_n7161
* NET  4505 = abc_30082_new_n7160
* NET  4506 = abc_30082_new_n7159
* NET  4507 = abc_30082_new_n7158
* NET  4508 = abc_30082_new_n7157
* NET  4509 = abc_30082_new_n7156
* NET  4510 = abc_30082_new_n7154
* NET  4511 = abc_30082_new_n7153
* NET  4512 = abc_30082_new_n7152
* NET  4513 = abc_30082_new_n7151
* NET  4514 = abc_30082_new_n7150
* NET  4515 = abc_30082_new_n7149
* NET  4516 = abc_30082_new_n7148
* NET  4517 = abc_30082_new_n7147
* NET  4518 = abc_30082_new_n7146
* NET  4519 = abc_30082_new_n7145
* NET  4520 = abc_30082_new_n7144
* NET  4521 = abc_30082_new_n7143
* NET  4522 = abc_30082_new_n7142
* NET  4523 = abc_30082_new_n7141
* NET  4524 = abc_30082_new_n7140
* NET  4525 = abc_30082_new_n7139
* NET  4526 = abc_30082_new_n7138
* NET  4527 = abc_30082_new_n7137
* NET  4528 = abc_30082_new_n7136
* NET  4529 = abc_30082_new_n7135
* NET  4530 = abc_30082_new_n7134
* NET  4531 = abc_30082_new_n7133
* NET  4532 = abc_30082_new_n7132
* NET  4533 = abc_30082_new_n7131
* NET  4534 = abc_30082_new_n7130
* NET  4535 = abc_30082_new_n7129
* NET  4536 = abc_30082_new_n7128
* NET  4537 = abc_30082_new_n7127
* NET  4538 = abc_30082_new_n7126
* NET  4539 = abc_30082_new_n7125
* NET  4540 = abc_30082_new_n7124
* NET  4541 = abc_30082_new_n7123
* NET  4542 = abc_30082_new_n7122
* NET  4543 = abc_30082_new_n7121
* NET  4544 = abc_30082_new_n7120
* NET  4545 = abc_30082_new_n7119
* NET  4546 = abc_30082_new_n7118
* NET  4547 = abc_30082_new_n7117
* NET  4548 = abc_30082_new_n7116
* NET  4549 = abc_30082_new_n7115
* NET  4550 = abc_30082_new_n7114
* NET  4551 = abc_30082_new_n7113
* NET  4552 = abc_30082_new_n7112
* NET  4553 = abc_30082_new_n7111
* NET  4554 = abc_30082_new_n7110
* NET  4555 = abc_30082_new_n7109
* NET  4556 = abc_30082_new_n7108
* NET  4557 = abc_30082_new_n7107
* NET  4558 = abc_30082_new_n7106
* NET  4559 = abc_30082_new_n7105
* NET  4560 = abc_30082_new_n7104
* NET  4561 = abc_30082_new_n7103
* NET  4562 = abc_30082_new_n7102
* NET  4563 = abc_30082_new_n7101
* NET  4564 = abc_30082_new_n7100
* NET  4565 = abc_30082_new_n7099
* NET  4566 = abc_30082_new_n7098
* NET  4567 = abc_30082_new_n7097
* NET  4568 = abc_30082_new_n7096
* NET  4569 = abc_30082_new_n7095
* NET  4570 = abc_30082_new_n7093
* NET  4571 = abc_30082_new_n7092
* NET  4572 = abc_30082_new_n7091
* NET  4573 = abc_30082_new_n7090
* NET  4574 = abc_30082_new_n7089
* NET  4575 = abc_30082_new_n7088
* NET  4576 = abc_30082_new_n7087
* NET  4577 = abc_30082_new_n7086
* NET  4578 = abc_30082_new_n7085
* NET  4579 = abc_30082_new_n7084
* NET  4580 = abc_30082_new_n7083
* NET  4581 = abc_30082_new_n7082
* NET  4582 = abc_30082_new_n7081
* NET  4583 = abc_30082_new_n7080
* NET  4584 = abc_30082_new_n7079
* NET  4585 = abc_30082_new_n7078
* NET  4586 = abc_30082_new_n7077
* NET  4587 = abc_30082_new_n7076
* NET  4588 = abc_30082_new_n7075
* NET  4589 = abc_30082_new_n7074
* NET  4590 = abc_30082_new_n7073
* NET  4591 = abc_30082_new_n7072
* NET  4592 = abc_30082_new_n7071
* NET  4593 = abc_30082_new_n7070
* NET  4594 = abc_30082_new_n7069
* NET  4595 = abc_30082_new_n7068
* NET  4596 = abc_30082_new_n7067
* NET  4597 = abc_30082_new_n7066
* NET  4598 = abc_30082_new_n7065
* NET  4599 = abc_30082_new_n7064
* NET  4600 = abc_30082_new_n7063
* NET  4601 = abc_30082_new_n7062
* NET  4602 = abc_30082_new_n7061
* NET  4603 = abc_30082_new_n7060
* NET  4604 = abc_30082_new_n7059
* NET  4605 = abc_30082_new_n7058
* NET  4606 = abc_30082_new_n7057
* NET  4607 = abc_30082_new_n7056
* NET  4608 = abc_30082_new_n7055
* NET  4609 = abc_30082_new_n7054
* NET  4610 = abc_30082_new_n7053
* NET  4611 = abc_30082_new_n7052
* NET  4612 = abc_30082_new_n7051
* NET  4613 = abc_30082_new_n7050
* NET  4614 = abc_30082_new_n7049
* NET  4615 = abc_30082_new_n7048
* NET  4616 = abc_30082_new_n7047
* NET  4617 = abc_30082_new_n7046
* NET  4618 = abc_30082_new_n7045
* NET  4619 = abc_30082_new_n7044
* NET  4620 = abc_30082_new_n7043
* NET  4621 = abc_30082_new_n7042
* NET  4622 = abc_30082_new_n7041
* NET  4623 = abc_30082_new_n7040
* NET  4624 = abc_30082_new_n7039
* NET  4625 = abc_30082_new_n7038
* NET  4626 = abc_30082_new_n7037
* NET  4627 = abc_30082_new_n7036
* NET  4628 = abc_30082_new_n7034
* NET  4629 = abc_30082_new_n7033
* NET  4630 = abc_30082_new_n7032
* NET  4631 = abc_30082_new_n7031
* NET  4632 = abc_30082_new_n7030
* NET  4633 = abc_30082_new_n7029
* NET  4634 = abc_30082_new_n7028
* NET  4635 = abc_30082_new_n7027
* NET  4636 = abc_30082_new_n7026
* NET  4637 = abc_30082_new_n7025
* NET  4638 = abc_30082_new_n7024
* NET  4639 = abc_30082_new_n7023
* NET  4640 = abc_30082_new_n7022
* NET  4641 = abc_30082_new_n7021
* NET  4642 = abc_30082_new_n7020
* NET  4643 = abc_30082_new_n7019
* NET  4644 = abc_30082_new_n7018
* NET  4645 = abc_30082_new_n7017
* NET  4646 = abc_30082_new_n7016
* NET  4647 = abc_30082_new_n7015
* NET  4648 = abc_30082_new_n7014
* NET  4649 = abc_30082_new_n7013
* NET  4650 = abc_30082_new_n7012
* NET  4651 = abc_30082_new_n7011
* NET  4652 = abc_30082_new_n7010
* NET  4653 = abc_30082_new_n7009
* NET  4654 = abc_30082_new_n7008
* NET  4655 = abc_30082_new_n7007
* NET  4656 = abc_30082_new_n7006
* NET  4657 = abc_30082_new_n7005
* NET  4658 = abc_30082_new_n7004
* NET  4659 = abc_30082_new_n7003
* NET  4660 = abc_30082_new_n7002
* NET  4661 = abc_30082_new_n7001
* NET  4662 = abc_30082_new_n7000
* NET  4663 = abc_30082_new_n6999
* NET  4664 = abc_30082_new_n6998
* NET  4665 = abc_30082_new_n6997
* NET  4666 = abc_30082_new_n6996
* NET  4667 = abc_30082_new_n6995
* NET  4668 = abc_30082_new_n6994
* NET  4669 = abc_30082_new_n6993
* NET  4670 = abc_30082_new_n6992
* NET  4671 = abc_30082_new_n6991
* NET  4672 = abc_30082_new_n6990
* NET  4673 = abc_30082_new_n6989
* NET  4674 = abc_30082_new_n6988
* NET  4675 = abc_30082_new_n6987
* NET  4676 = abc_30082_new_n6986
* NET  4677 = abc_30082_new_n6985
* NET  4678 = abc_30082_new_n6984
* NET  4679 = abc_30082_new_n6983
* NET  4680 = abc_30082_new_n6982
* NET  4681 = abc_30082_new_n6981
* NET  4682 = abc_30082_new_n6980
* NET  4683 = abc_30082_new_n6979
* NET  4684 = abc_30082_new_n6978
* NET  4685 = abc_30082_new_n6977
* NET  4686 = abc_30082_new_n6976
* NET  4687 = abc_30082_new_n6975
* NET  4688 = abc_30082_new_n6973
* NET  4689 = abc_30082_new_n6972
* NET  4690 = abc_30082_new_n6971
* NET  4691 = abc_30082_new_n6970
* NET  4692 = abc_30082_new_n6969
* NET  4693 = abc_30082_new_n6968
* NET  4694 = abc_30082_new_n6967
* NET  4695 = abc_30082_new_n6966
* NET  4696 = abc_30082_new_n6965
* NET  4697 = abc_30082_new_n6964
* NET  4698 = abc_30082_new_n6963
* NET  4699 = abc_30082_new_n6962
* NET  4700 = abc_30082_new_n6961
* NET  4701 = abc_30082_new_n6960
* NET  4702 = abc_30082_new_n6959
* NET  4703 = abc_30082_new_n6958
* NET  4704 = abc_30082_new_n6957
* NET  4705 = abc_30082_new_n6956
* NET  4706 = abc_30082_new_n6955
* NET  4707 = abc_30082_new_n6954
* NET  4708 = abc_30082_new_n6953
* NET  4709 = abc_30082_new_n6952
* NET  4710 = abc_30082_new_n6951
* NET  4711 = abc_30082_new_n6950
* NET  4712 = abc_30082_new_n6949
* NET  4713 = abc_30082_new_n6948
* NET  4714 = abc_30082_new_n6947
* NET  4715 = abc_30082_new_n6946
* NET  4716 = abc_30082_new_n6945
* NET  4717 = abc_30082_new_n6944
* NET  4718 = abc_30082_new_n6943
* NET  4719 = abc_30082_new_n6942
* NET  4720 = abc_30082_new_n6941
* NET  4721 = abc_30082_new_n6940
* NET  4722 = abc_30082_new_n6939
* NET  4723 = abc_30082_new_n6938
* NET  4724 = abc_30082_new_n6937
* NET  4725 = abc_30082_new_n6936
* NET  4726 = abc_30082_new_n6935
* NET  4727 = abc_30082_new_n6934
* NET  4728 = abc_30082_new_n6933
* NET  4729 = abc_30082_new_n6932
* NET  4730 = abc_30082_new_n6931
* NET  4731 = abc_30082_new_n6930
* NET  4732 = abc_30082_new_n6929
* NET  4733 = abc_30082_new_n6928
* NET  4734 = abc_30082_new_n6927
* NET  4735 = abc_30082_new_n6926
* NET  4736 = abc_30082_new_n6925
* NET  4737 = abc_30082_new_n6924
* NET  4738 = abc_30082_new_n6923
* NET  4739 = abc_30082_new_n6922
* NET  4740 = abc_30082_new_n6921
* NET  4741 = abc_30082_new_n6920
* NET  4742 = abc_30082_new_n6919
* NET  4743 = abc_30082_new_n6918
* NET  4744 = abc_30082_new_n6917
* NET  4745 = abc_30082_new_n6916
* NET  4746 = abc_30082_new_n6914
* NET  4747 = abc_30082_new_n6913
* NET  4748 = abc_30082_new_n6912
* NET  4749 = abc_30082_new_n6911
* NET  4750 = abc_30082_new_n6910
* NET  4751 = abc_30082_new_n6909
* NET  4752 = abc_30082_new_n6908
* NET  4753 = abc_30082_new_n6907
* NET  4754 = abc_30082_new_n6906
* NET  4755 = abc_30082_new_n6905
* NET  4756 = abc_30082_new_n6904
* NET  4757 = abc_30082_new_n6903
* NET  4758 = abc_30082_new_n6902
* NET  4759 = abc_30082_new_n6901
* NET  4760 = abc_30082_new_n6900
* NET  4761 = abc_30082_new_n6899
* NET  4762 = abc_30082_new_n6898
* NET  4763 = abc_30082_new_n6897
* NET  4764 = abc_30082_new_n6896
* NET  4765 = abc_30082_new_n6895
* NET  4766 = abc_30082_new_n6894
* NET  4767 = abc_30082_new_n6893
* NET  4768 = abc_30082_new_n6892
* NET  4769 = abc_30082_new_n6891
* NET  4770 = abc_30082_new_n6890
* NET  4771 = abc_30082_new_n6889
* NET  4772 = abc_30082_new_n6888
* NET  4773 = abc_30082_new_n6887
* NET  4774 = abc_30082_new_n6886
* NET  4775 = abc_30082_new_n6885
* NET  4776 = abc_30082_new_n6884
* NET  4777 = abc_30082_new_n6883
* NET  4778 = abc_30082_new_n6882
* NET  4779 = abc_30082_new_n6881
* NET  4780 = abc_30082_new_n6880
* NET  4781 = abc_30082_new_n6879
* NET  4782 = abc_30082_new_n6878
* NET  4783 = abc_30082_new_n6877
* NET  4784 = abc_30082_new_n6876
* NET  4785 = abc_30082_new_n6875
* NET  4786 = abc_30082_new_n6874
* NET  4787 = abc_30082_new_n6873
* NET  4788 = abc_30082_new_n6872
* NET  4789 = abc_30082_new_n6871
* NET  4790 = abc_30082_new_n6870
* NET  4791 = abc_30082_new_n6869
* NET  4792 = abc_30082_new_n6868
* NET  4793 = abc_30082_new_n6867
* NET  4794 = abc_30082_new_n6866
* NET  4795 = abc_30082_new_n6865
* NET  4796 = abc_30082_new_n6864
* NET  4797 = abc_30082_new_n6863
* NET  4798 = abc_30082_new_n6862
* NET  4799 = abc_30082_new_n6861
* NET  4800 = abc_30082_new_n6860
* NET  4801 = abc_30082_new_n6859
* NET  4802 = abc_30082_new_n6858
* NET  4803 = abc_30082_new_n6857
* NET  4804 = abc_30082_new_n6856
* NET  4805 = abc_30082_new_n6855
* NET  4806 = abc_30082_new_n6853
* NET  4807 = abc_30082_new_n6852
* NET  4808 = abc_30082_new_n6851
* NET  4809 = abc_30082_new_n6850
* NET  4810 = abc_30082_new_n6849
* NET  4811 = abc_30082_new_n6848
* NET  4812 = abc_30082_new_n6847
* NET  4813 = abc_30082_new_n6846
* NET  4814 = abc_30082_new_n6845
* NET  4815 = abc_30082_new_n6844
* NET  4816 = abc_30082_new_n6843
* NET  4817 = abc_30082_new_n6842
* NET  4818 = abc_30082_new_n6841
* NET  4819 = abc_30082_new_n6840
* NET  4820 = abc_30082_new_n6839
* NET  4821 = abc_30082_new_n6838
* NET  4822 = abc_30082_new_n6837
* NET  4823 = abc_30082_new_n6836
* NET  4824 = abc_30082_new_n6835
* NET  4825 = abc_30082_new_n6834
* NET  4826 = abc_30082_new_n6833
* NET  4827 = abc_30082_new_n6832
* NET  4828 = abc_30082_new_n6831
* NET  4829 = abc_30082_new_n6830
* NET  4830 = abc_30082_new_n6829
* NET  4831 = abc_30082_new_n6828
* NET  4832 = abc_30082_new_n6827
* NET  4833 = abc_30082_new_n6826
* NET  4834 = abc_30082_new_n6825
* NET  4835 = abc_30082_new_n6824
* NET  4836 = abc_30082_new_n6823
* NET  4837 = abc_30082_new_n6822
* NET  4838 = abc_30082_new_n6821
* NET  4839 = abc_30082_new_n6820
* NET  4840 = abc_30082_new_n6819
* NET  4841 = abc_30082_new_n6818
* NET  4842 = abc_30082_new_n6817
* NET  4843 = abc_30082_new_n6816
* NET  4844 = abc_30082_new_n6815
* NET  4845 = abc_30082_new_n6814
* NET  4846 = abc_30082_new_n6813
* NET  4847 = abc_30082_new_n6812
* NET  4848 = abc_30082_new_n6811
* NET  4849 = abc_30082_new_n6810
* NET  4850 = abc_30082_new_n6809
* NET  4851 = abc_30082_new_n6808
* NET  4852 = abc_30082_new_n6807
* NET  4853 = abc_30082_new_n6806
* NET  4854 = abc_30082_new_n6805
* NET  4855 = abc_30082_new_n6804
* NET  4856 = abc_30082_new_n6803
* NET  4857 = abc_30082_new_n6802
* NET  4858 = abc_30082_new_n6801
* NET  4859 = abc_30082_new_n6800
* NET  4860 = abc_30082_new_n6799
* NET  4861 = abc_30082_new_n6798
* NET  4862 = abc_30082_new_n6797
* NET  4863 = abc_30082_new_n6796
* NET  4864 = abc_30082_new_n6794
* NET  4865 = abc_30082_new_n6793
* NET  4866 = abc_30082_new_n6792
* NET  4867 = abc_30082_new_n6791
* NET  4868 = abc_30082_new_n6790
* NET  4869 = abc_30082_new_n6789
* NET  4870 = abc_30082_new_n6788
* NET  4871 = abc_30082_new_n6787
* NET  4872 = abc_30082_new_n6786
* NET  4873 = abc_30082_new_n6785
* NET  4874 = abc_30082_new_n6784
* NET  4875 = abc_30082_new_n6783
* NET  4876 = abc_30082_new_n6782
* NET  4877 = abc_30082_new_n6781
* NET  4878 = abc_30082_new_n6780
* NET  4879 = abc_30082_new_n6779
* NET  4880 = abc_30082_new_n6778
* NET  4881 = abc_30082_new_n6777
* NET  4882 = abc_30082_new_n6776
* NET  4883 = abc_30082_new_n6775
* NET  4884 = abc_30082_new_n6774
* NET  4885 = abc_30082_new_n6773
* NET  4886 = abc_30082_new_n6772
* NET  4887 = abc_30082_new_n6771
* NET  4888 = abc_30082_new_n6770
* NET  4889 = abc_30082_new_n6769
* NET  4890 = abc_30082_new_n6768
* NET  4891 = abc_30082_new_n6767
* NET  4892 = abc_30082_new_n6766
* NET  4893 = abc_30082_new_n6765
* NET  4894 = abc_30082_new_n6764
* NET  4895 = abc_30082_new_n6763
* NET  4896 = abc_30082_new_n6762
* NET  4897 = abc_30082_new_n6761
* NET  4898 = abc_30082_new_n6760
* NET  4899 = abc_30082_new_n6759
* NET  4900 = abc_30082_new_n6758
* NET  4901 = abc_30082_new_n6757
* NET  4902 = abc_30082_new_n6756
* NET  4903 = abc_30082_new_n6755
* NET  4904 = abc_30082_new_n6754
* NET  4905 = abc_30082_new_n6753
* NET  4906 = abc_30082_new_n6752
* NET  4907 = abc_30082_new_n6751
* NET  4908 = abc_30082_new_n6750
* NET  4909 = abc_30082_new_n6749
* NET  4910 = abc_30082_new_n6748
* NET  4911 = abc_30082_new_n6747
* NET  4912 = abc_30082_new_n6746
* NET  4913 = abc_30082_new_n6745
* NET  4914 = abc_30082_new_n6744
* NET  4915 = abc_30082_new_n6743
* NET  4916 = abc_30082_new_n6742
* NET  4917 = abc_30082_new_n6741
* NET  4918 = abc_30082_new_n6740
* NET  4919 = abc_30082_new_n6739
* NET  4920 = abc_30082_new_n6738
* NET  4921 = abc_30082_new_n6737
* NET  4922 = abc_30082_new_n6736
* NET  4923 = abc_30082_new_n6735
* NET  4924 = abc_30082_new_n6733
* NET  4925 = abc_30082_new_n6732
* NET  4926 = abc_30082_new_n6731
* NET  4927 = abc_30082_new_n6730
* NET  4928 = abc_30082_new_n6729
* NET  4929 = abc_30082_new_n6728
* NET  4930 = abc_30082_new_n6727
* NET  4931 = abc_30082_new_n6726
* NET  4932 = abc_30082_new_n6725
* NET  4933 = abc_30082_new_n6724
* NET  4934 = abc_30082_new_n6723
* NET  4935 = abc_30082_new_n6722
* NET  4936 = abc_30082_new_n6721
* NET  4937 = abc_30082_new_n6720
* NET  4938 = abc_30082_new_n6719
* NET  4939 = abc_30082_new_n6718
* NET  4940 = abc_30082_new_n6717
* NET  4941 = abc_30082_new_n6716
* NET  4942 = abc_30082_new_n6715
* NET  4943 = abc_30082_new_n6714
* NET  4944 = abc_30082_new_n6713
* NET  4945 = abc_30082_new_n6712
* NET  4946 = abc_30082_new_n6711
* NET  4947 = abc_30082_new_n6710
* NET  4948 = abc_30082_new_n6709
* NET  4949 = abc_30082_new_n6708
* NET  4950 = abc_30082_new_n6707
* NET  4951 = abc_30082_new_n6706
* NET  4952 = abc_30082_new_n6705
* NET  4953 = abc_30082_new_n6704
* NET  4954 = abc_30082_new_n6703
* NET  4955 = abc_30082_new_n6702
* NET  4956 = abc_30082_new_n6701
* NET  4957 = abc_30082_new_n6700
* NET  4958 = abc_30082_new_n6699
* NET  4959 = abc_30082_new_n6698
* NET  4960 = abc_30082_new_n6697
* NET  4961 = abc_30082_new_n6696
* NET  4962 = abc_30082_new_n6695
* NET  4963 = abc_30082_new_n6694
* NET  4964 = abc_30082_new_n6693
* NET  4965 = abc_30082_new_n6692
* NET  4966 = abc_30082_new_n6691
* NET  4967 = abc_30082_new_n6690
* NET  4968 = abc_30082_new_n6689
* NET  4969 = abc_30082_new_n6688
* NET  4970 = abc_30082_new_n6687
* NET  4971 = abc_30082_new_n6686
* NET  4972 = abc_30082_new_n6685
* NET  4973 = abc_30082_new_n6684
* NET  4974 = abc_30082_new_n6683
* NET  4975 = abc_30082_new_n6682
* NET  4976 = abc_30082_new_n6681
* NET  4977 = abc_30082_new_n6680
* NET  4978 = abc_30082_new_n6679
* NET  4979 = abc_30082_new_n6678
* NET  4980 = abc_30082_new_n6677
* NET  4981 = abc_30082_new_n6676
* NET  4982 = abc_30082_new_n6674
* NET  4983 = abc_30082_new_n6673
* NET  4984 = abc_30082_new_n6672
* NET  4985 = abc_30082_new_n6671
* NET  4986 = abc_30082_new_n6670
* NET  4987 = abc_30082_new_n6669
* NET  4988 = abc_30082_new_n6668
* NET  4989 = abc_30082_new_n6667
* NET  4990 = abc_30082_new_n6666
* NET  4991 = abc_30082_new_n6665
* NET  4992 = abc_30082_new_n6664
* NET  4993 = abc_30082_new_n6663
* NET  4994 = abc_30082_new_n6662
* NET  4995 = abc_30082_new_n6661
* NET  4996 = abc_30082_new_n6660
* NET  4997 = abc_30082_new_n6659
* NET  4998 = abc_30082_new_n6658
* NET  4999 = abc_30082_new_n6657
* NET  5000 = abc_30082_new_n6656
* NET  5001 = abc_30082_new_n6655
* NET  5002 = abc_30082_new_n6654
* NET  5003 = abc_30082_new_n6653
* NET  5004 = abc_30082_new_n6652
* NET  5005 = abc_30082_new_n6651
* NET  5006 = abc_30082_new_n6650
* NET  5007 = abc_30082_new_n6649
* NET  5008 = abc_30082_new_n6648
* NET  5009 = abc_30082_new_n6647
* NET  5010 = abc_30082_new_n6646
* NET  5011 = abc_30082_new_n6645
* NET  5012 = abc_30082_new_n6644
* NET  5013 = abc_30082_new_n6643
* NET  5014 = abc_30082_new_n6642
* NET  5015 = abc_30082_new_n6641
* NET  5016 = abc_30082_new_n6640
* NET  5017 = abc_30082_new_n6639
* NET  5018 = abc_30082_new_n6638
* NET  5019 = abc_30082_new_n6637
* NET  5020 = abc_30082_new_n6636
* NET  5021 = abc_30082_new_n6635
* NET  5022 = abc_30082_new_n6634
* NET  5023 = abc_30082_new_n6633
* NET  5024 = abc_30082_new_n6632
* NET  5025 = abc_30082_new_n6631
* NET  5026 = abc_30082_new_n6630
* NET  5027 = abc_30082_new_n6629
* NET  5028 = abc_30082_new_n6628
* NET  5029 = abc_30082_new_n6627
* NET  5030 = abc_30082_new_n6626
* NET  5031 = abc_30082_new_n6625
* NET  5032 = abc_30082_new_n6624
* NET  5033 = abc_30082_new_n6623
* NET  5034 = abc_30082_new_n6622
* NET  5035 = abc_30082_new_n6621
* NET  5036 = abc_30082_new_n6620
* NET  5037 = abc_30082_new_n6619
* NET  5038 = abc_30082_new_n6618
* NET  5039 = abc_30082_new_n6617
* NET  5040 = abc_30082_new_n6616
* NET  5041 = abc_30082_new_n6615
* NET  5042 = abc_30082_new_n6613
* NET  5043 = abc_30082_new_n6612
* NET  5044 = abc_30082_new_n6611
* NET  5045 = abc_30082_new_n6610
* NET  5046 = abc_30082_new_n6609
* NET  5047 = abc_30082_new_n6608
* NET  5048 = abc_30082_new_n6607
* NET  5049 = abc_30082_new_n6606
* NET  5050 = abc_30082_new_n6605
* NET  5051 = abc_30082_new_n6604
* NET  5052 = abc_30082_new_n6603
* NET  5053 = abc_30082_new_n6602
* NET  5054 = abc_30082_new_n6601
* NET  5055 = abc_30082_new_n6600
* NET  5056 = abc_30082_new_n6599
* NET  5057 = abc_30082_new_n6598
* NET  5058 = abc_30082_new_n6597
* NET  5059 = abc_30082_new_n6596
* NET  5060 = abc_30082_new_n6595
* NET  5061 = abc_30082_new_n6594
* NET  5062 = abc_30082_new_n6593
* NET  5063 = abc_30082_new_n6592
* NET  5064 = abc_30082_new_n6591
* NET  5065 = abc_30082_new_n6590
* NET  5066 = abc_30082_new_n6589
* NET  5067 = abc_30082_new_n6588
* NET  5068 = abc_30082_new_n6587
* NET  5069 = abc_30082_new_n6586
* NET  5070 = abc_30082_new_n6585
* NET  5071 = abc_30082_new_n6584
* NET  5072 = abc_30082_new_n6583
* NET  5073 = abc_30082_new_n6582
* NET  5074 = abc_30082_new_n6581
* NET  5075 = abc_30082_new_n6580
* NET  5076 = abc_30082_new_n6579
* NET  5077 = abc_30082_new_n6578
* NET  5078 = abc_30082_new_n6577
* NET  5079 = abc_30082_new_n6576
* NET  5080 = abc_30082_new_n6575
* NET  5081 = abc_30082_new_n6574
* NET  5082 = abc_30082_new_n6573
* NET  5083 = abc_30082_new_n6572
* NET  5084 = abc_30082_new_n6571
* NET  5085 = abc_30082_new_n6570
* NET  5086 = abc_30082_new_n6569
* NET  5087 = abc_30082_new_n6568
* NET  5088 = abc_30082_new_n6567
* NET  5089 = abc_30082_new_n6566
* NET  5090 = abc_30082_new_n6565
* NET  5091 = abc_30082_new_n6564
* NET  5092 = abc_30082_new_n6563
* NET  5093 = abc_30082_new_n6562
* NET  5094 = abc_30082_new_n6561
* NET  5095 = abc_30082_new_n6560
* NET  5096 = abc_30082_new_n6559
* NET  5097 = abc_30082_new_n6558
* NET  5098 = abc_30082_new_n6557
* NET  5099 = abc_30082_new_n6556
* NET  5100 = abc_30082_new_n6554
* NET  5101 = abc_30082_new_n6553
* NET  5102 = abc_30082_new_n6552
* NET  5103 = abc_30082_new_n6551
* NET  5104 = abc_30082_new_n6550
* NET  5105 = abc_30082_new_n6549
* NET  5106 = abc_30082_new_n6548
* NET  5107 = abc_30082_new_n6547
* NET  5108 = abc_30082_new_n6546
* NET  5109 = abc_30082_new_n6545
* NET  5110 = abc_30082_new_n6544
* NET  5111 = abc_30082_new_n6543
* NET  5112 = abc_30082_new_n6542
* NET  5113 = abc_30082_new_n6541
* NET  5114 = abc_30082_new_n6540
* NET  5115 = abc_30082_new_n6539
* NET  5116 = abc_30082_new_n6538
* NET  5117 = abc_30082_new_n6537
* NET  5118 = abc_30082_new_n6536
* NET  5119 = abc_30082_new_n6535
* NET  5120 = abc_30082_new_n6534
* NET  5121 = abc_30082_new_n6533
* NET  5122 = abc_30082_new_n6532
* NET  5123 = abc_30082_new_n6531
* NET  5124 = abc_30082_new_n6530
* NET  5125 = abc_30082_new_n6529
* NET  5126 = abc_30082_new_n6528
* NET  5127 = abc_30082_new_n6527
* NET  5128 = abc_30082_new_n6526
* NET  5129 = abc_30082_new_n6525
* NET  5130 = abc_30082_new_n6524
* NET  5131 = abc_30082_new_n6523
* NET  5132 = abc_30082_new_n6522
* NET  5133 = abc_30082_new_n6521
* NET  5134 = abc_30082_new_n6520
* NET  5135 = abc_30082_new_n6519
* NET  5136 = abc_30082_new_n6518
* NET  5137 = abc_30082_new_n6517
* NET  5138 = abc_30082_new_n6516
* NET  5139 = abc_30082_new_n6515
* NET  5140 = abc_30082_new_n6514
* NET  5141 = abc_30082_new_n6513
* NET  5142 = abc_30082_new_n6512
* NET  5143 = abc_30082_new_n6511
* NET  5144 = abc_30082_new_n6510
* NET  5145 = abc_30082_new_n6509
* NET  5146 = abc_30082_new_n6508
* NET  5147 = abc_30082_new_n6507
* NET  5148 = abc_30082_new_n6506
* NET  5149 = abc_30082_new_n6505
* NET  5150 = abc_30082_new_n6504
* NET  5151 = abc_30082_new_n6503
* NET  5152 = abc_30082_new_n6502
* NET  5153 = abc_30082_new_n6501
* NET  5154 = abc_30082_new_n6500
* NET  5155 = abc_30082_new_n6499
* NET  5156 = abc_30082_new_n6498
* NET  5157 = abc_30082_new_n6497
* NET  5158 = abc_30082_new_n6496
* NET  5159 = abc_30082_new_n6495
* NET  5160 = abc_30082_new_n6493
* NET  5161 = abc_30082_new_n6492
* NET  5162 = abc_30082_new_n6491
* NET  5163 = abc_30082_new_n6490
* NET  5164 = abc_30082_new_n6489
* NET  5165 = abc_30082_new_n6488
* NET  5166 = abc_30082_new_n6487
* NET  5167 = abc_30082_new_n6486
* NET  5168 = abc_30082_new_n6485
* NET  5169 = abc_30082_new_n6484
* NET  5170 = abc_30082_new_n6483
* NET  5171 = abc_30082_new_n6482
* NET  5172 = abc_30082_new_n6481
* NET  5173 = abc_30082_new_n6480
* NET  5174 = abc_30082_new_n6479
* NET  5175 = abc_30082_new_n6478
* NET  5176 = abc_30082_new_n6477
* NET  5177 = abc_30082_new_n6476
* NET  5178 = abc_30082_new_n6475
* NET  5179 = abc_30082_new_n6474
* NET  5180 = abc_30082_new_n6473
* NET  5181 = abc_30082_new_n6472
* NET  5182 = abc_30082_new_n6471
* NET  5183 = abc_30082_new_n6470
* NET  5184 = abc_30082_new_n6469
* NET  5185 = abc_30082_new_n6468
* NET  5186 = abc_30082_new_n6467
* NET  5187 = abc_30082_new_n6466
* NET  5188 = abc_30082_new_n6465
* NET  5189 = abc_30082_new_n6464
* NET  5190 = abc_30082_new_n6463
* NET  5191 = abc_30082_new_n6462
* NET  5192 = abc_30082_new_n6461
* NET  5193 = abc_30082_new_n6460
* NET  5194 = abc_30082_new_n6459
* NET  5195 = abc_30082_new_n6458
* NET  5196 = abc_30082_new_n6457
* NET  5197 = abc_30082_new_n6456
* NET  5198 = abc_30082_new_n6455
* NET  5199 = abc_30082_new_n6454
* NET  5200 = abc_30082_new_n6453
* NET  5201 = abc_30082_new_n6452
* NET  5202 = abc_30082_new_n6451
* NET  5203 = abc_30082_new_n6450
* NET  5204 = abc_30082_new_n6449
* NET  5205 = abc_30082_new_n6448
* NET  5206 = abc_30082_new_n6447
* NET  5207 = abc_30082_new_n6446
* NET  5208 = abc_30082_new_n6445
* NET  5209 = abc_30082_new_n6444
* NET  5210 = abc_30082_new_n6443
* NET  5211 = abc_30082_new_n6442
* NET  5212 = abc_30082_new_n6441
* NET  5213 = abc_30082_new_n6440
* NET  5214 = abc_30082_new_n6439
* NET  5215 = abc_30082_new_n6438
* NET  5216 = abc_30082_new_n6437
* NET  5217 = abc_30082_new_n6436
* NET  5218 = abc_30082_new_n6434
* NET  5219 = abc_30082_new_n6433
* NET  5220 = abc_30082_new_n6432
* NET  5221 = abc_30082_new_n6431
* NET  5222 = abc_30082_new_n6430
* NET  5223 = abc_30082_new_n6429
* NET  5224 = abc_30082_new_n6428
* NET  5225 = abc_30082_new_n6427
* NET  5226 = abc_30082_new_n6426
* NET  5227 = abc_30082_new_n6425
* NET  5228 = abc_30082_new_n6424
* NET  5229 = abc_30082_new_n6423
* NET  5230 = abc_30082_new_n6422
* NET  5231 = abc_30082_new_n6421
* NET  5232 = abc_30082_new_n6420
* NET  5233 = abc_30082_new_n6419
* NET  5234 = abc_30082_new_n6418
* NET  5235 = abc_30082_new_n6417
* NET  5236 = abc_30082_new_n6416
* NET  5237 = abc_30082_new_n6415
* NET  5238 = abc_30082_new_n6414
* NET  5239 = abc_30082_new_n6413
* NET  5240 = abc_30082_new_n6412
* NET  5241 = abc_30082_new_n6411
* NET  5242 = abc_30082_new_n6410
* NET  5243 = abc_30082_new_n6409
* NET  5244 = abc_30082_new_n6408
* NET  5245 = abc_30082_new_n6407
* NET  5246 = abc_30082_new_n6406
* NET  5247 = abc_30082_new_n6405
* NET  5248 = abc_30082_new_n6404
* NET  5249 = abc_30082_new_n6403
* NET  5250 = abc_30082_new_n6402
* NET  5251 = abc_30082_new_n6401
* NET  5252 = abc_30082_new_n6400
* NET  5253 = abc_30082_new_n6399
* NET  5254 = abc_30082_new_n6398
* NET  5255 = abc_30082_new_n6397
* NET  5256 = abc_30082_new_n6396
* NET  5257 = abc_30082_new_n6395
* NET  5258 = abc_30082_new_n6394
* NET  5259 = abc_30082_new_n6393
* NET  5260 = abc_30082_new_n6392
* NET  5261 = abc_30082_new_n6391
* NET  5262 = abc_30082_new_n6390
* NET  5263 = abc_30082_new_n6389
* NET  5264 = abc_30082_new_n6388
* NET  5265 = abc_30082_new_n6387
* NET  5266 = abc_30082_new_n6386
* NET  5267 = abc_30082_new_n6385
* NET  5268 = abc_30082_new_n6384
* NET  5269 = abc_30082_new_n6383
* NET  5270 = abc_30082_new_n6382
* NET  5271 = abc_30082_new_n6381
* NET  5272 = abc_30082_new_n6380
* NET  5273 = abc_30082_new_n6379
* NET  5274 = abc_30082_new_n6378
* NET  5275 = abc_30082_new_n6377
* NET  5276 = abc_30082_new_n6376
* NET  5277 = abc_30082_new_n6375
* NET  5278 = abc_30082_new_n6373
* NET  5279 = abc_30082_new_n6372
* NET  5280 = abc_30082_new_n6371
* NET  5281 = abc_30082_new_n6370
* NET  5282 = abc_30082_new_n6369
* NET  5283 = abc_30082_new_n6368
* NET  5284 = abc_30082_new_n6367
* NET  5285 = abc_30082_new_n6366
* NET  5286 = abc_30082_new_n6365
* NET  5287 = abc_30082_new_n6364
* NET  5288 = abc_30082_new_n6363
* NET  5289 = abc_30082_new_n6362
* NET  5290 = abc_30082_new_n6361
* NET  5291 = abc_30082_new_n6360
* NET  5292 = abc_30082_new_n6359
* NET  5293 = abc_30082_new_n6358
* NET  5294 = abc_30082_new_n6357
* NET  5295 = abc_30082_new_n6356
* NET  5296 = abc_30082_new_n6355
* NET  5297 = abc_30082_new_n6354
* NET  5298 = abc_30082_new_n6353
* NET  5299 = abc_30082_new_n6352
* NET  5300 = abc_30082_new_n6351
* NET  5301 = abc_30082_new_n6350
* NET  5302 = abc_30082_new_n6349
* NET  5303 = abc_30082_new_n6348
* NET  5304 = abc_30082_new_n6347
* NET  5305 = abc_30082_new_n6346
* NET  5306 = abc_30082_new_n6345
* NET  5307 = abc_30082_new_n6344
* NET  5308 = abc_30082_new_n6343
* NET  5309 = abc_30082_new_n6342
* NET  5310 = abc_30082_new_n6341
* NET  5311 = abc_30082_new_n6340
* NET  5312 = abc_30082_new_n6339
* NET  5313 = abc_30082_new_n6338
* NET  5314 = abc_30082_new_n6337
* NET  5315 = abc_30082_new_n6336
* NET  5316 = abc_30082_new_n6335
* NET  5317 = abc_30082_new_n6334
* NET  5318 = abc_30082_new_n6333
* NET  5319 = abc_30082_new_n6332
* NET  5320 = abc_30082_new_n6331
* NET  5321 = abc_30082_new_n6330
* NET  5322 = abc_30082_new_n6329
* NET  5323 = abc_30082_new_n6328
* NET  5324 = abc_30082_new_n6327
* NET  5325 = abc_30082_new_n6326
* NET  5326 = abc_30082_new_n6325
* NET  5327 = abc_30082_new_n6324
* NET  5328 = abc_30082_new_n6323
* NET  5329 = abc_30082_new_n6322
* NET  5330 = abc_30082_new_n6321
* NET  5331 = abc_30082_new_n6320
* NET  5332 = abc_30082_new_n6319
* NET  5333 = abc_30082_new_n6318
* NET  5334 = abc_30082_new_n6317
* NET  5335 = abc_30082_new_n6316
* NET  5336 = abc_30082_new_n6314
* NET  5337 = abc_30082_new_n6313
* NET  5338 = abc_30082_new_n6312
* NET  5339 = abc_30082_new_n6311
* NET  5340 = abc_30082_new_n6310
* NET  5341 = abc_30082_new_n6309
* NET  5342 = abc_30082_new_n6308
* NET  5343 = abc_30082_new_n6307
* NET  5344 = abc_30082_new_n6306
* NET  5345 = abc_30082_new_n6305
* NET  5346 = abc_30082_new_n6304
* NET  5347 = abc_30082_new_n6303
* NET  5348 = abc_30082_new_n6302
* NET  5349 = abc_30082_new_n6301
* NET  5350 = abc_30082_new_n6300
* NET  5351 = abc_30082_new_n6299
* NET  5352 = abc_30082_new_n6298
* NET  5353 = abc_30082_new_n6297
* NET  5354 = abc_30082_new_n6296
* NET  5355 = abc_30082_new_n6295
* NET  5356 = abc_30082_new_n6294
* NET  5357 = abc_30082_new_n6293
* NET  5358 = abc_30082_new_n6292
* NET  5359 = abc_30082_new_n6291
* NET  5360 = abc_30082_new_n6290
* NET  5361 = abc_30082_new_n6289
* NET  5362 = abc_30082_new_n6288
* NET  5363 = abc_30082_new_n6287
* NET  5364 = abc_30082_new_n6286
* NET  5365 = abc_30082_new_n6285
* NET  5366 = abc_30082_new_n6284
* NET  5367 = abc_30082_new_n6283
* NET  5368 = abc_30082_new_n6282
* NET  5369 = abc_30082_new_n6281
* NET  5370 = abc_30082_new_n6280
* NET  5371 = abc_30082_new_n6279
* NET  5372 = abc_30082_new_n6278
* NET  5373 = abc_30082_new_n6277
* NET  5374 = abc_30082_new_n6276
* NET  5375 = abc_30082_new_n6275
* NET  5376 = abc_30082_new_n6274
* NET  5377 = abc_30082_new_n6273
* NET  5378 = abc_30082_new_n6272
* NET  5379 = abc_30082_new_n6271
* NET  5380 = abc_30082_new_n6270
* NET  5381 = abc_30082_new_n6269
* NET  5382 = abc_30082_new_n6268
* NET  5383 = abc_30082_new_n6267
* NET  5384 = abc_30082_new_n6266
* NET  5385 = abc_30082_new_n6265
* NET  5386 = abc_30082_new_n6264
* NET  5387 = abc_30082_new_n6263
* NET  5388 = abc_30082_new_n6262
* NET  5389 = abc_30082_new_n6261
* NET  5390 = abc_30082_new_n6260
* NET  5391 = abc_30082_new_n6259
* NET  5392 = abc_30082_new_n6258
* NET  5393 = abc_30082_new_n6257
* NET  5394 = abc_30082_new_n6256
* NET  5395 = abc_30082_new_n6254
* NET  5396 = abc_30082_new_n6253
* NET  5397 = abc_30082_new_n6252
* NET  5398 = abc_30082_new_n6251
* NET  5399 = abc_30082_new_n6250
* NET  5400 = abc_30082_new_n6249
* NET  5401 = abc_30082_new_n6248
* NET  5402 = abc_30082_new_n6247
* NET  5403 = abc_30082_new_n6246
* NET  5404 = abc_30082_new_n6245
* NET  5405 = abc_30082_new_n6244
* NET  5406 = abc_30082_new_n6243
* NET  5407 = abc_30082_new_n6242
* NET  5408 = abc_30082_new_n6241
* NET  5409 = abc_30082_new_n6240
* NET  5410 = abc_30082_new_n6239
* NET  5411 = abc_30082_new_n6238
* NET  5412 = abc_30082_new_n6237
* NET  5413 = abc_30082_new_n6236
* NET  5414 = abc_30082_new_n6235
* NET  5415 = abc_30082_new_n6234
* NET  5416 = abc_30082_new_n6233
* NET  5417 = abc_30082_new_n6232
* NET  5418 = abc_30082_new_n6231
* NET  5419 = abc_30082_new_n6230
* NET  5420 = abc_30082_new_n6229
* NET  5421 = abc_30082_new_n6228
* NET  5422 = abc_30082_new_n6227
* NET  5423 = abc_30082_new_n6226
* NET  5424 = abc_30082_new_n6225
* NET  5425 = abc_30082_new_n6224
* NET  5426 = abc_30082_new_n6223
* NET  5427 = abc_30082_new_n6222
* NET  5428 = abc_30082_new_n6221
* NET  5429 = abc_30082_new_n6220
* NET  5430 = abc_30082_new_n6219
* NET  5431 = abc_30082_new_n6218
* NET  5432 = abc_30082_new_n6217
* NET  5433 = abc_30082_new_n6216
* NET  5434 = abc_30082_new_n6215
* NET  5435 = abc_30082_new_n6214
* NET  5436 = abc_30082_new_n6213
* NET  5437 = abc_30082_new_n6212
* NET  5438 = abc_30082_new_n6211
* NET  5439 = abc_30082_new_n6210
* NET  5440 = abc_30082_new_n6209
* NET  5441 = abc_30082_new_n6208
* NET  5442 = abc_30082_new_n6207
* NET  5443 = abc_30082_new_n6206
* NET  5444 = abc_30082_new_n6205
* NET  5445 = abc_30082_new_n6204
* NET  5446 = abc_30082_new_n6203
* NET  5447 = abc_30082_new_n6202
* NET  5448 = abc_30082_new_n6201
* NET  5449 = abc_30082_new_n6200
* NET  5450 = abc_30082_new_n6199
* NET  5451 = abc_30082_new_n6198
* NET  5452 = abc_30082_new_n6197
* NET  5453 = abc_30082_new_n6195
* NET  5454 = abc_30082_new_n6194
* NET  5455 = abc_30082_new_n6193
* NET  5456 = abc_30082_new_n6192
* NET  5457 = abc_30082_new_n6191
* NET  5458 = abc_30082_new_n6190
* NET  5459 = abc_30082_new_n6189
* NET  5460 = abc_30082_new_n6188
* NET  5461 = abc_30082_new_n6187
* NET  5462 = abc_30082_new_n6186
* NET  5463 = abc_30082_new_n6185
* NET  5464 = abc_30082_new_n6184
* NET  5465 = abc_30082_new_n6183
* NET  5466 = abc_30082_new_n6182
* NET  5467 = abc_30082_new_n6181
* NET  5468 = abc_30082_new_n6180
* NET  5469 = abc_30082_new_n6179
* NET  5470 = abc_30082_new_n6178
* NET  5471 = abc_30082_new_n6177
* NET  5472 = abc_30082_new_n6176
* NET  5473 = abc_30082_new_n6175
* NET  5474 = abc_30082_new_n6174
* NET  5475 = abc_30082_new_n6173
* NET  5476 = abc_30082_new_n6172
* NET  5477 = abc_30082_new_n6171
* NET  5478 = abc_30082_new_n6170
* NET  5479 = abc_30082_new_n6169
* NET  5480 = abc_30082_new_n6168
* NET  5481 = abc_30082_new_n6167
* NET  5482 = abc_30082_new_n6166
* NET  5483 = abc_30082_new_n6165
* NET  5484 = abc_30082_new_n6164
* NET  5485 = abc_30082_new_n6163
* NET  5486 = abc_30082_new_n6162
* NET  5487 = abc_30082_new_n6161
* NET  5488 = abc_30082_new_n6160
* NET  5489 = abc_30082_new_n6159
* NET  5490 = abc_30082_new_n6158
* NET  5491 = abc_30082_new_n6157
* NET  5492 = abc_30082_new_n6156
* NET  5493 = abc_30082_new_n6155
* NET  5494 = abc_30082_new_n6154
* NET  5495 = abc_30082_new_n6153
* NET  5496 = abc_30082_new_n6152
* NET  5497 = abc_30082_new_n6151
* NET  5498 = abc_30082_new_n6150
* NET  5499 = abc_30082_new_n6149
* NET  5500 = abc_30082_new_n6148
* NET  5501 = abc_30082_new_n6147
* NET  5502 = abc_30082_new_n6146
* NET  5503 = abc_30082_new_n6145
* NET  5504 = abc_30082_new_n6144
* NET  5505 = abc_30082_new_n6143
* NET  5506 = abc_30082_new_n6142
* NET  5507 = abc_30082_new_n6141
* NET  5508 = abc_30082_new_n6140
* NET  5509 = abc_30082_new_n6139
* NET  5510 = abc_30082_new_n6138
* NET  5511 = abc_30082_new_n6136
* NET  5512 = abc_30082_new_n6135
* NET  5513 = abc_30082_new_n6134
* NET  5514 = abc_30082_new_n6133
* NET  5515 = abc_30082_new_n6132
* NET  5516 = abc_30082_new_n6131
* NET  5517 = abc_30082_new_n6130
* NET  5518 = abc_30082_new_n6129
* NET  5519 = abc_30082_new_n6128
* NET  5520 = abc_30082_new_n6127
* NET  5521 = abc_30082_new_n6126
* NET  5522 = abc_30082_new_n6125
* NET  5523 = abc_30082_new_n6124
* NET  5524 = abc_30082_new_n6123
* NET  5525 = abc_30082_new_n6122
* NET  5526 = abc_30082_new_n6121
* NET  5527 = abc_30082_new_n6120
* NET  5528 = abc_30082_new_n6119
* NET  5529 = abc_30082_new_n6118
* NET  5530 = abc_30082_new_n6117
* NET  5531 = abc_30082_new_n6116
* NET  5532 = abc_30082_new_n6115
* NET  5533 = abc_30082_new_n6114
* NET  5534 = abc_30082_new_n6113
* NET  5535 = abc_30082_new_n6112
* NET  5536 = abc_30082_new_n6111
* NET  5537 = abc_30082_new_n6110
* NET  5538 = abc_30082_new_n6109
* NET  5539 = abc_30082_new_n6108
* NET  5540 = abc_30082_new_n6107
* NET  5541 = abc_30082_new_n6106
* NET  5542 = abc_30082_new_n6105
* NET  5543 = abc_30082_new_n6104
* NET  5544 = abc_30082_new_n6103
* NET  5545 = abc_30082_new_n6102
* NET  5546 = abc_30082_new_n6101
* NET  5547 = abc_30082_new_n6100
* NET  5548 = abc_30082_new_n6099
* NET  5549 = abc_30082_new_n6098
* NET  5550 = abc_30082_new_n6097
* NET  5551 = abc_30082_new_n6096
* NET  5552 = abc_30082_new_n6095
* NET  5553 = abc_30082_new_n6094
* NET  5554 = abc_30082_new_n6093
* NET  5555 = abc_30082_new_n6092
* NET  5556 = abc_30082_new_n6091
* NET  5557 = abc_30082_new_n6090
* NET  5558 = abc_30082_new_n6089
* NET  5559 = abc_30082_new_n6088
* NET  5560 = abc_30082_new_n6087
* NET  5561 = abc_30082_new_n6086
* NET  5562 = abc_30082_new_n6085
* NET  5563 = abc_30082_new_n6084
* NET  5564 = abc_30082_new_n6083
* NET  5565 = abc_30082_new_n6082
* NET  5566 = abc_30082_new_n6081
* NET  5567 = abc_30082_new_n6080
* NET  5568 = abc_30082_new_n6079
* NET  5569 = abc_30082_new_n6077
* NET  5570 = abc_30082_new_n6076
* NET  5571 = abc_30082_new_n6075
* NET  5572 = abc_30082_new_n6074
* NET  5573 = abc_30082_new_n6073
* NET  5574 = abc_30082_new_n6072
* NET  5575 = abc_30082_new_n6071
* NET  5576 = abc_30082_new_n6070
* NET  5577 = abc_30082_new_n6069
* NET  5578 = abc_30082_new_n6068
* NET  5579 = abc_30082_new_n6067
* NET  5580 = abc_30082_new_n6066
* NET  5581 = abc_30082_new_n6065
* NET  5582 = abc_30082_new_n6064
* NET  5583 = abc_30082_new_n6063
* NET  5584 = abc_30082_new_n6062
* NET  5585 = abc_30082_new_n6061
* NET  5586 = abc_30082_new_n6060
* NET  5587 = abc_30082_new_n6059
* NET  5588 = abc_30082_new_n6058
* NET  5589 = abc_30082_new_n6057
* NET  5590 = abc_30082_new_n6056
* NET  5591 = abc_30082_new_n6055
* NET  5592 = abc_30082_new_n6054
* NET  5593 = abc_30082_new_n6053
* NET  5594 = abc_30082_new_n6052
* NET  5595 = abc_30082_new_n6051
* NET  5596 = abc_30082_new_n6050
* NET  5597 = abc_30082_new_n6049
* NET  5598 = abc_30082_new_n6048
* NET  5599 = abc_30082_new_n6047
* NET  5600 = abc_30082_new_n6046
* NET  5601 = abc_30082_new_n6045
* NET  5602 = abc_30082_new_n6044
* NET  5603 = abc_30082_new_n6043
* NET  5604 = abc_30082_new_n6042
* NET  5605 = abc_30082_new_n6041
* NET  5606 = abc_30082_new_n6040
* NET  5607 = abc_30082_new_n6039
* NET  5608 = abc_30082_new_n6038
* NET  5609 = abc_30082_new_n6037
* NET  5610 = abc_30082_new_n6036
* NET  5611 = abc_30082_new_n6035
* NET  5612 = abc_30082_new_n6034
* NET  5613 = abc_30082_new_n6033
* NET  5614 = abc_30082_new_n6032
* NET  5615 = abc_30082_new_n6031
* NET  5616 = abc_30082_new_n6030
* NET  5617 = abc_30082_new_n6029
* NET  5618 = abc_30082_new_n6028
* NET  5619 = abc_30082_new_n6027
* NET  5620 = abc_30082_new_n6026
* NET  5621 = abc_30082_new_n6025
* NET  5622 = abc_30082_new_n6024
* NET  5623 = abc_30082_new_n6023
* NET  5624 = abc_30082_new_n6022
* NET  5625 = abc_30082_new_n6021
* NET  5626 = abc_30082_new_n6020
* NET  5627 = abc_30082_new_n6018
* NET  5628 = abc_30082_new_n6017
* NET  5629 = abc_30082_new_n6016
* NET  5630 = abc_30082_new_n6015
* NET  5631 = abc_30082_new_n6014
* NET  5632 = abc_30082_new_n6013
* NET  5633 = abc_30082_new_n6012
* NET  5634 = abc_30082_new_n6011
* NET  5635 = abc_30082_new_n6010
* NET  5636 = abc_30082_new_n6009
* NET  5637 = abc_30082_new_n6008
* NET  5638 = abc_30082_new_n6007
* NET  5639 = abc_30082_new_n6006
* NET  5640 = abc_30082_new_n6005
* NET  5641 = abc_30082_new_n6004
* NET  5642 = abc_30082_new_n6003
* NET  5643 = abc_30082_new_n6002
* NET  5644 = abc_30082_new_n6001
* NET  5645 = abc_30082_new_n6000
* NET  5646 = abc_30082_new_n5999
* NET  5647 = abc_30082_new_n5998
* NET  5648 = abc_30082_new_n5997
* NET  5649 = abc_30082_new_n5996
* NET  5650 = abc_30082_new_n5995
* NET  5651 = abc_30082_new_n5994
* NET  5652 = abc_30082_new_n5993
* NET  5653 = abc_30082_new_n5992
* NET  5654 = abc_30082_new_n5991
* NET  5655 = abc_30082_new_n5990
* NET  5656 = abc_30082_new_n5989
* NET  5657 = abc_30082_new_n5988
* NET  5658 = abc_30082_new_n5987
* NET  5659 = abc_30082_new_n5986
* NET  5660 = abc_30082_new_n5985
* NET  5661 = abc_30082_new_n5984
* NET  5662 = abc_30082_new_n5983
* NET  5663 = abc_30082_new_n5982
* NET  5664 = abc_30082_new_n5981
* NET  5665 = abc_30082_new_n5980
* NET  5666 = abc_30082_new_n5979
* NET  5667 = abc_30082_new_n5978
* NET  5668 = abc_30082_new_n5977
* NET  5669 = abc_30082_new_n5976
* NET  5670 = abc_30082_new_n5975
* NET  5671 = abc_30082_new_n5974
* NET  5672 = abc_30082_new_n5973
* NET  5673 = abc_30082_new_n5972
* NET  5674 = abc_30082_new_n5971
* NET  5675 = abc_30082_new_n5970
* NET  5676 = abc_30082_new_n5969
* NET  5677 = abc_30082_new_n5968
* NET  5678 = abc_30082_new_n5967
* NET  5679 = abc_30082_new_n5966
* NET  5680 = abc_30082_new_n5965
* NET  5681 = abc_30082_new_n5964
* NET  5682 = abc_30082_new_n5963
* NET  5683 = abc_30082_new_n5962
* NET  5684 = abc_30082_new_n5960
* NET  5685 = abc_30082_new_n5959
* NET  5686 = abc_30082_new_n5958
* NET  5687 = abc_30082_new_n5957
* NET  5688 = abc_30082_new_n5956
* NET  5689 = abc_30082_new_n5955
* NET  5690 = abc_30082_new_n5954
* NET  5691 = abc_30082_new_n5953
* NET  5692 = abc_30082_new_n5952
* NET  5693 = abc_30082_new_n5951
* NET  5694 = abc_30082_new_n5950
* NET  5695 = abc_30082_new_n5949
* NET  5696 = abc_30082_new_n5948
* NET  5697 = abc_30082_new_n5947
* NET  5698 = abc_30082_new_n5946
* NET  5699 = abc_30082_new_n5945
* NET  5700 = abc_30082_new_n5944
* NET  5701 = abc_30082_new_n5943
* NET  5702 = abc_30082_new_n5942
* NET  5703 = abc_30082_new_n5941
* NET  5704 = abc_30082_new_n5940
* NET  5705 = abc_30082_new_n5939
* NET  5706 = abc_30082_new_n5938
* NET  5707 = abc_30082_new_n5937
* NET  5708 = abc_30082_new_n5936
* NET  5709 = abc_30082_new_n5935
* NET  5710 = abc_30082_new_n5934
* NET  5711 = abc_30082_new_n5933
* NET  5712 = abc_30082_new_n5932
* NET  5713 = abc_30082_new_n5931
* NET  5714 = abc_30082_new_n5930
* NET  5715 = abc_30082_new_n5929
* NET  5716 = abc_30082_new_n5928
* NET  5717 = abc_30082_new_n5927
* NET  5718 = abc_30082_new_n5926
* NET  5719 = abc_30082_new_n5925
* NET  5720 = abc_30082_new_n5924
* NET  5721 = abc_30082_new_n5923
* NET  5722 = abc_30082_new_n5922
* NET  5723 = abc_30082_new_n5921
* NET  5724 = abc_30082_new_n5920
* NET  5725 = abc_30082_new_n5919
* NET  5726 = abc_30082_new_n5918
* NET  5727 = abc_30082_new_n5917
* NET  5728 = abc_30082_new_n5916
* NET  5729 = abc_30082_new_n5915
* NET  5730 = abc_30082_new_n5914
* NET  5731 = abc_30082_new_n5913
* NET  5732 = abc_30082_new_n5912
* NET  5733 = abc_30082_new_n5911
* NET  5734 = abc_30082_new_n5910
* NET  5735 = abc_30082_new_n5909
* NET  5736 = abc_30082_new_n5907
* NET  5737 = abc_30082_new_n5906
* NET  5738 = abc_30082_new_n5905
* NET  5739 = abc_30082_new_n5904
* NET  5740 = abc_30082_new_n5903
* NET  5741 = abc_30082_new_n5902
* NET  5742 = abc_30082_new_n5901
* NET  5743 = abc_30082_new_n5900
* NET  5744 = abc_30082_new_n5899
* NET  5745 = abc_30082_new_n5898
* NET  5746 = abc_30082_new_n5897
* NET  5747 = abc_30082_new_n5896
* NET  5748 = abc_30082_new_n5895
* NET  5749 = abc_30082_new_n5894
* NET  5750 = abc_30082_new_n5893
* NET  5751 = abc_30082_new_n5892
* NET  5752 = abc_30082_new_n5891
* NET  5753 = abc_30082_new_n5890
* NET  5754 = abc_30082_new_n5889
* NET  5755 = abc_30082_new_n5888
* NET  5756 = abc_30082_new_n5887
* NET  5757 = abc_30082_new_n5886
* NET  5758 = abc_30082_new_n5885
* NET  5759 = abc_30082_new_n5884
* NET  5760 = abc_30082_new_n5883
* NET  5761 = abc_30082_new_n5882
* NET  5762 = abc_30082_new_n5881
* NET  5763 = abc_30082_new_n5880
* NET  5764 = abc_30082_new_n5879
* NET  5765 = abc_30082_new_n5878
* NET  5766 = abc_30082_new_n5877
* NET  5767 = abc_30082_new_n5876
* NET  5768 = abc_30082_new_n5875
* NET  5769 = abc_30082_new_n5874
* NET  5770 = abc_30082_new_n5873
* NET  5771 = abc_30082_new_n5872
* NET  5772 = abc_30082_new_n5871
* NET  5773 = abc_30082_new_n5870
* NET  5774 = abc_30082_new_n5869
* NET  5775 = abc_30082_new_n5868
* NET  5776 = abc_30082_new_n5867
* NET  5777 = abc_30082_new_n5866
* NET  5778 = abc_30082_new_n5865
* NET  5779 = abc_30082_new_n5864
* NET  5780 = abc_30082_new_n5863
* NET  5781 = abc_30082_new_n5862
* NET  5782 = abc_30082_new_n5861
* NET  5783 = abc_30082_new_n5860
* NET  5784 = abc_30082_new_n5859
* NET  5785 = abc_30082_new_n5857
* NET  5786 = abc_30082_new_n5856
* NET  5787 = abc_30082_new_n5855
* NET  5788 = abc_30082_new_n5854
* NET  5789 = abc_30082_new_n5853
* NET  5790 = abc_30082_new_n5852
* NET  5791 = abc_30082_new_n5851
* NET  5792 = abc_30082_new_n5850
* NET  5793 = abc_30082_new_n5849
* NET  5794 = abc_30082_new_n5848
* NET  5795 = abc_30082_new_n5847
* NET  5796 = abc_30082_new_n5846
* NET  5797 = abc_30082_new_n5845
* NET  5798 = abc_30082_new_n5844
* NET  5799 = abc_30082_new_n5843
* NET  5800 = abc_30082_new_n5842
* NET  5801 = abc_30082_new_n5841
* NET  5802 = abc_30082_new_n5840
* NET  5803 = abc_30082_new_n5839
* NET  5804 = abc_30082_new_n5838
* NET  5805 = abc_30082_new_n5837
* NET  5806 = abc_30082_new_n5836
* NET  5807 = abc_30082_new_n5835
* NET  5808 = abc_30082_new_n5834
* NET  5809 = abc_30082_new_n5833
* NET  5810 = abc_30082_new_n5832
* NET  5811 = abc_30082_new_n5831
* NET  5812 = abc_30082_new_n5830
* NET  5813 = abc_30082_new_n5829
* NET  5814 = abc_30082_new_n5828
* NET  5815 = abc_30082_new_n5827
* NET  5816 = abc_30082_new_n5826
* NET  5817 = abc_30082_new_n5825
* NET  5818 = abc_30082_new_n5824
* NET  5819 = abc_30082_new_n5823
* NET  5820 = abc_30082_new_n5822
* NET  5821 = abc_30082_new_n5821
* NET  5822 = abc_30082_new_n5820
* NET  5823 = abc_30082_new_n5819
* NET  5824 = abc_30082_new_n5818
* NET  5825 = abc_30082_new_n5817
* NET  5826 = abc_30082_new_n5816
* NET  5827 = abc_30082_new_n5815
* NET  5828 = abc_30082_new_n5814
* NET  5829 = abc_30082_new_n5813
* NET  5830 = abc_30082_new_n5812
* NET  5831 = abc_30082_new_n5811
* NET  5832 = abc_30082_new_n5810
* NET  5833 = abc_30082_new_n5809
* NET  5834 = abc_30082_new_n5807
* NET  5835 = abc_30082_new_n5806
* NET  5836 = abc_30082_new_n5805
* NET  5837 = abc_30082_new_n5804
* NET  5838 = abc_30082_new_n5803
* NET  5839 = abc_30082_new_n5802
* NET  5840 = abc_30082_new_n5801
* NET  5841 = abc_30082_new_n5800
* NET  5842 = abc_30082_new_n5799
* NET  5843 = abc_30082_new_n5798
* NET  5844 = abc_30082_new_n5797
* NET  5845 = abc_30082_new_n5796
* NET  5846 = abc_30082_new_n5795
* NET  5847 = abc_30082_new_n5794
* NET  5848 = abc_30082_new_n5793
* NET  5849 = abc_30082_new_n5792
* NET  5850 = abc_30082_new_n5791
* NET  5851 = abc_30082_new_n5790
* NET  5852 = abc_30082_new_n5789
* NET  5853 = abc_30082_new_n5788
* NET  5854 = abc_30082_new_n5787
* NET  5855 = abc_30082_new_n5786
* NET  5856 = abc_30082_new_n5785
* NET  5857 = abc_30082_new_n5784
* NET  5858 = abc_30082_new_n5783
* NET  5859 = abc_30082_new_n5782
* NET  5860 = abc_30082_new_n5781
* NET  5861 = abc_30082_new_n5780
* NET  5862 = abc_30082_new_n5779
* NET  5863 = abc_30082_new_n5778
* NET  5864 = abc_30082_new_n5777
* NET  5865 = abc_30082_new_n5776
* NET  5866 = abc_30082_new_n5775
* NET  5867 = abc_30082_new_n5774
* NET  5868 = abc_30082_new_n5773
* NET  5869 = abc_30082_new_n5772
* NET  5870 = abc_30082_new_n5771
* NET  5871 = abc_30082_new_n5770
* NET  5872 = abc_30082_new_n5769
* NET  5873 = abc_30082_new_n5768
* NET  5874 = abc_30082_new_n5767
* NET  5875 = abc_30082_new_n5766
* NET  5876 = abc_30082_new_n5765
* NET  5877 = abc_30082_new_n5764
* NET  5878 = abc_30082_new_n5763
* NET  5879 = abc_30082_new_n5762
* NET  5880 = abc_30082_new_n5761
* NET  5881 = abc_30082_new_n5760
* NET  5882 = abc_30082_new_n5759
* NET  5883 = abc_30082_new_n5758
* NET  5884 = abc_30082_new_n5757
* NET  5885 = abc_30082_new_n5756
* NET  5886 = abc_30082_new_n5755
* NET  5887 = abc_30082_new_n5753
* NET  5888 = abc_30082_new_n5752
* NET  5889 = abc_30082_new_n5751
* NET  5890 = abc_30082_new_n5750
* NET  5891 = abc_30082_new_n5749
* NET  5892 = abc_30082_new_n5748
* NET  5893 = abc_30082_new_n5747
* NET  5894 = abc_30082_new_n5746
* NET  5895 = abc_30082_new_n5745
* NET  5896 = abc_30082_new_n5744
* NET  5897 = abc_30082_new_n5743
* NET  5898 = abc_30082_new_n5742
* NET  5899 = abc_30082_new_n5741
* NET  5900 = abc_30082_new_n5740
* NET  5901 = abc_30082_new_n5739
* NET  5902 = abc_30082_new_n5738
* NET  5903 = abc_30082_new_n5737
* NET  5904 = abc_30082_new_n5736
* NET  5905 = abc_30082_new_n5735
* NET  5906 = abc_30082_new_n5734
* NET  5907 = abc_30082_new_n5733
* NET  5908 = abc_30082_new_n5732
* NET  5909 = abc_30082_new_n5731
* NET  5910 = abc_30082_new_n5730
* NET  5911 = abc_30082_new_n5729
* NET  5912 = abc_30082_new_n5728
* NET  5913 = abc_30082_new_n5727
* NET  5914 = abc_30082_new_n5726
* NET  5915 = abc_30082_new_n5725
* NET  5916 = abc_30082_new_n5724
* NET  5917 = abc_30082_new_n5723
* NET  5918 = abc_30082_new_n5722
* NET  5919 = abc_30082_new_n5721
* NET  5920 = abc_30082_new_n5720
* NET  5921 = abc_30082_new_n5719
* NET  5922 = abc_30082_new_n5718
* NET  5923 = abc_30082_new_n5717
* NET  5924 = abc_30082_new_n5716
* NET  5925 = abc_30082_new_n5715
* NET  5926 = abc_30082_new_n5714
* NET  5927 = abc_30082_new_n5713
* NET  5928 = abc_30082_new_n5712
* NET  5929 = abc_30082_new_n5711
* NET  5930 = abc_30082_new_n5710
* NET  5931 = abc_30082_new_n5709
* NET  5932 = abc_30082_new_n5708
* NET  5933 = abc_30082_new_n5707
* NET  5934 = abc_30082_new_n5706
* NET  5935 = abc_30082_new_n5705
* NET  5936 = abc_30082_new_n5704
* NET  5937 = abc_30082_new_n5702
* NET  5938 = abc_30082_new_n5701
* NET  5939 = abc_30082_new_n5700
* NET  5940 = abc_30082_new_n5699
* NET  5941 = abc_30082_new_n5698
* NET  5942 = abc_30082_new_n5697
* NET  5943 = abc_30082_new_n5696
* NET  5944 = abc_30082_new_n5695
* NET  5945 = abc_30082_new_n5694
* NET  5946 = abc_30082_new_n5693
* NET  5947 = abc_30082_new_n5692
* NET  5948 = abc_30082_new_n5691_hfns_2
* NET  5949 = abc_30082_new_n5691_hfns_1
* NET  5950 = abc_30082_new_n5691_hfns_0
* NET  5951 = abc_30082_new_n5691
* NET  5952 = abc_30082_new_n5690
* NET  5953 = abc_30082_new_n5689
* NET  5954 = abc_30082_new_n5688
* NET  5955 = abc_30082_new_n5687
* NET  5956 = abc_30082_new_n5686_hfns_2
* NET  5957 = abc_30082_new_n5686_hfns_1
* NET  5958 = abc_30082_new_n5686_hfns_0
* NET  5959 = abc_30082_new_n5686
* NET  5960 = abc_30082_new_n5685
* NET  5961 = abc_30082_new_n5684
* NET  5962 = abc_30082_new_n5683
* NET  5963 = abc_30082_new_n5682
* NET  5964 = abc_30082_new_n5681
* NET  5965 = abc_30082_new_n5680
* NET  5966 = abc_30082_new_n5679
* NET  5967 = abc_30082_new_n5678
* NET  5968 = abc_30082_new_n5677
* NET  5969 = abc_30082_new_n5676
* NET  5970 = abc_30082_new_n5675
* NET  5971 = abc_30082_new_n5674
* NET  5972 = abc_30082_new_n5673
* NET  5973 = abc_30082_new_n5672
* NET  5974 = abc_30082_new_n5671
* NET  5975 = abc_30082_new_n5670
* NET  5976 = abc_30082_new_n5669
* NET  5977 = abc_30082_new_n5668
* NET  5978 = abc_30082_new_n5667
* NET  5979 = abc_30082_new_n5666
* NET  5980 = abc_30082_new_n5665
* NET  5981 = abc_30082_new_n5664
* NET  5982 = abc_30082_new_n5663
* NET  5983 = abc_30082_new_n5662
* NET  5984 = abc_30082_new_n5661
* NET  5985 = abc_30082_new_n5660
* NET  5986 = abc_30082_new_n5659
* NET  5987 = abc_30082_new_n5658
* NET  5988 = abc_30082_new_n5657
* NET  5989 = abc_30082_new_n5656
* NET  5990 = abc_30082_new_n5655
* NET  5991 = abc_30082_new_n5654
* NET  5992 = abc_30082_new_n5653_hfns_3
* NET  5993 = abc_30082_new_n5653_hfns_2
* NET  5994 = abc_30082_new_n5653_hfns_1
* NET  5995 = abc_30082_new_n5653_hfns_0
* NET  5996 = abc_30082_new_n5653
* NET  5997 = abc_30082_new_n5652
* NET  5998 = abc_30082_new_n5651
* NET  5999 = abc_30082_new_n5650
* NET  6000 = abc_30082_new_n5649
* NET  6001 = abc_30082_new_n5648
* NET  6002 = abc_30082_new_n5647
* NET  6003 = abc_30082_new_n5646
* NET  6004 = abc_30082_new_n5645
* NET  6005 = abc_30082_new_n5644
* NET  6006 = abc_30082_new_n5643_hfns_2
* NET  6007 = abc_30082_new_n5643_hfns_1
* NET  6008 = abc_30082_new_n5643_hfns_0
* NET  6009 = abc_30082_new_n5643
* NET  6010 = abc_30082_new_n5642_hfns_2
* NET  6011 = abc_30082_new_n5642_hfns_1
* NET  6012 = abc_30082_new_n5642_hfns_0
* NET  6013 = abc_30082_new_n5642
* NET  6014 = abc_30082_new_n5641
* NET  6015 = abc_30082_new_n5640
* NET  6016 = abc_30082_new_n5638_hfns_2
* NET  6017 = abc_30082_new_n5638_hfns_1
* NET  6018 = abc_30082_new_n5638_hfns_0
* NET  6019 = abc_30082_new_n5638
* NET  6020 = abc_30082_new_n5637
* NET  6021 = abc_30082_new_n5636
* NET  6022 = abc_30082_new_n5635
* NET  6023 = abc_30082_new_n5634
* NET  6024 = abc_30082_new_n5633
* NET  6025 = abc_30082_new_n5631_hfns_2
* NET  6026 = abc_30082_new_n5631_hfns_1
* NET  6027 = abc_30082_new_n5631_hfns_0
* NET  6028 = abc_30082_new_n5631
* NET  6029 = abc_30082_new_n5630
* NET  6030 = abc_30082_new_n5629
* NET  6031 = abc_30082_new_n5628
* NET  6032 = abc_30082_new_n5627
* NET  6033 = abc_30082_new_n5625_hfns_2
* NET  6034 = abc_30082_new_n5625_hfns_1
* NET  6035 = abc_30082_new_n5625_hfns_0
* NET  6036 = abc_30082_new_n5625
* NET  6037 = abc_30082_new_n5624
* NET  6038 = abc_30082_new_n5623
* NET  6039 = abc_30082_new_n5622
* NET  6040 = abc_30082_new_n5621
* NET  6041 = abc_30082_new_n5620
* NET  6042 = abc_30082_new_n5618_hfns_2
* NET  6043 = abc_30082_new_n5618_hfns_1
* NET  6044 = abc_30082_new_n5618_hfns_0
* NET  6045 = abc_30082_new_n5618
* NET  6046 = abc_30082_new_n5617
* NET  6047 = abc_30082_new_n5616
* NET  6048 = abc_30082_new_n5615
* NET  6049 = abc_30082_new_n5614
* NET  6050 = abc_30082_new_n5613
* NET  6051 = abc_30082_new_n5612
* NET  6052 = abc_30082_new_n5610_hfns_2
* NET  6053 = abc_30082_new_n5610_hfns_1
* NET  6054 = abc_30082_new_n5610_hfns_0
* NET  6055 = abc_30082_new_n5610
* NET  6056 = abc_30082_new_n5609
* NET  6057 = abc_30082_new_n5608
* NET  6058 = abc_30082_new_n5607
* NET  6059 = abc_30082_new_n5606
* NET  6060 = abc_30082_new_n5604_hfns_2
* NET  6061 = abc_30082_new_n5604_hfns_1
* NET  6062 = abc_30082_new_n5604_hfns_0
* NET  6063 = abc_30082_new_n5604
* NET  6064 = abc_30082_new_n5603
* NET  6065 = abc_30082_new_n5602
* NET  6066 = abc_30082_new_n5601
* NET  6067 = abc_30082_new_n5600
* NET  6068 = abc_30082_new_n5599
* NET  6069 = abc_30082_new_n5597_hfns_2
* NET  6070 = abc_30082_new_n5597_hfns_1
* NET  6071 = abc_30082_new_n5597_hfns_0
* NET  6072 = abc_30082_new_n5597
* NET  6073 = abc_30082_new_n5596
* NET  6074 = abc_30082_new_n5595
* NET  6075 = abc_30082_new_n5594
* NET  6076 = abc_30082_new_n5593
* NET  6077 = abc_30082_new_n5592
* NET  6078 = abc_30082_new_n5591
* NET  6079 = abc_30082_new_n5589_hfns_2
* NET  6080 = abc_30082_new_n5589_hfns_1
* NET  6081 = abc_30082_new_n5589_hfns_0
* NET  6082 = abc_30082_new_n5589
* NET  6083 = abc_30082_new_n5588
* NET  6084 = abc_30082_new_n5587
* NET  6085 = abc_30082_new_n5586
* NET  6086 = abc_30082_new_n5585
* NET  6087 = abc_30082_new_n5583_hfns_2
* NET  6088 = abc_30082_new_n5583_hfns_1
* NET  6089 = abc_30082_new_n5583_hfns_0
* NET  6090 = abc_30082_new_n5583
* NET  6091 = abc_30082_new_n5582
* NET  6092 = abc_30082_new_n5581
* NET  6093 = abc_30082_new_n5580
* NET  6094 = abc_30082_new_n5579
* NET  6095 = abc_30082_new_n5578
* NET  6096 = abc_30082_new_n5576_hfns_2
* NET  6097 = abc_30082_new_n5576_hfns_1
* NET  6098 = abc_30082_new_n5576_hfns_0
* NET  6099 = abc_30082_new_n5576
* NET  6100 = abc_30082_new_n5575
* NET  6101 = abc_30082_new_n5574
* NET  6102 = abc_30082_new_n5573
* NET  6103 = abc_30082_new_n5572
* NET  6104 = abc_30082_new_n5571
* NET  6105 = abc_30082_new_n5570
* NET  6106 = abc_30082_new_n5568_hfns_2
* NET  6107 = abc_30082_new_n5568_hfns_1
* NET  6108 = abc_30082_new_n5568_hfns_0
* NET  6109 = abc_30082_new_n5568
* NET  6110 = abc_30082_new_n5567
* NET  6111 = abc_30082_new_n5566
* NET  6112 = abc_30082_new_n5565
* NET  6113 = abc_30082_new_n5564
* NET  6114 = abc_30082_new_n5562_hfns_2
* NET  6115 = abc_30082_new_n5562_hfns_1
* NET  6116 = abc_30082_new_n5562_hfns_0
* NET  6117 = abc_30082_new_n5562
* NET  6118 = abc_30082_new_n5561
* NET  6119 = abc_30082_new_n5560
* NET  6120 = abc_30082_new_n5559
* NET  6121 = abc_30082_new_n5558
* NET  6122 = abc_30082_new_n5557
* NET  6123 = abc_30082_new_n5555_hfns_2
* NET  6124 = abc_30082_new_n5555_hfns_1
* NET  6125 = abc_30082_new_n5555_hfns_0
* NET  6126 = abc_30082_new_n5555
* NET  6127 = abc_30082_new_n5554
* NET  6128 = abc_30082_new_n5553
* NET  6129 = abc_30082_new_n5552
* NET  6130 = abc_30082_new_n5551
* NET  6131 = abc_30082_new_n5550
* NET  6132 = abc_30082_new_n5549
* NET  6133 = abc_30082_new_n5547_hfns_2
* NET  6134 = abc_30082_new_n5547_hfns_1
* NET  6135 = abc_30082_new_n5547_hfns_0
* NET  6136 = abc_30082_new_n5547
* NET  6137 = abc_30082_new_n5546
* NET  6138 = abc_30082_new_n5545
* NET  6139 = abc_30082_new_n5544
* NET  6140 = abc_30082_new_n5543
* NET  6141 = abc_30082_new_n5541_hfns_2
* NET  6142 = abc_30082_new_n5541_hfns_1
* NET  6143 = abc_30082_new_n5541_hfns_0
* NET  6144 = abc_30082_new_n5541
* NET  6145 = abc_30082_new_n5540
* NET  6146 = abc_30082_new_n5539
* NET  6147 = abc_30082_new_n5538
* NET  6148 = abc_30082_new_n5537
* NET  6149 = abc_30082_new_n5536
* NET  6150 = abc_30082_new_n5534_hfns_2
* NET  6151 = abc_30082_new_n5534_hfns_1
* NET  6152 = abc_30082_new_n5534_hfns_0
* NET  6153 = abc_30082_new_n5534
* NET  6154 = abc_30082_new_n5533
* NET  6155 = abc_30082_new_n5532
* NET  6156 = abc_30082_new_n5531
* NET  6157 = abc_30082_new_n5530
* NET  6158 = abc_30082_new_n5529
* NET  6159 = abc_30082_new_n5528
* NET  6160 = abc_30082_new_n5526_hfns_2
* NET  6161 = abc_30082_new_n5526_hfns_1
* NET  6162 = abc_30082_new_n5526_hfns_0
* NET  6163 = abc_30082_new_n5526
* NET  6164 = abc_30082_new_n5525
* NET  6165 = abc_30082_new_n5524
* NET  6166 = abc_30082_new_n5523
* NET  6167 = abc_30082_new_n5522
* NET  6168 = abc_30082_new_n5520_hfns_2
* NET  6169 = abc_30082_new_n5520_hfns_1
* NET  6170 = abc_30082_new_n5520_hfns_0
* NET  6171 = abc_30082_new_n5520
* NET  6172 = abc_30082_new_n5519
* NET  6173 = abc_30082_new_n5518
* NET  6174 = abc_30082_new_n5517
* NET  6175 = abc_30082_new_n5516
* NET  6176 = abc_30082_new_n5515
* NET  6177 = abc_30082_new_n5513_hfns_2
* NET  6178 = abc_30082_new_n5513_hfns_1
* NET  6179 = abc_30082_new_n5513_hfns_0
* NET  6180 = abc_30082_new_n5513
* NET  6181 = abc_30082_new_n5512
* NET  6182 = abc_30082_new_n5511
* NET  6183 = abc_30082_new_n5510
* NET  6184 = abc_30082_new_n5509
* NET  6185 = abc_30082_new_n5508
* NET  6186 = abc_30082_new_n5507
* NET  6187 = abc_30082_new_n5505_hfns_2
* NET  6188 = abc_30082_new_n5505_hfns_1
* NET  6189 = abc_30082_new_n5505_hfns_0
* NET  6190 = abc_30082_new_n5505
* NET  6191 = abc_30082_new_n5504
* NET  6192 = abc_30082_new_n5503
* NET  6193 = abc_30082_new_n5502
* NET  6194 = abc_30082_new_n5501
* NET  6195 = abc_30082_new_n5499_hfns_2
* NET  6196 = abc_30082_new_n5499_hfns_1
* NET  6197 = abc_30082_new_n5499_hfns_0
* NET  6198 = abc_30082_new_n5499
* NET  6199 = abc_30082_new_n5498_hfns_2
* NET  6200 = abc_30082_new_n5498_hfns_1
* NET  6201 = abc_30082_new_n5498_hfns_0
* NET  6202 = abc_30082_new_n5498
* NET  6203 = abc_30082_new_n5497
* NET  6204 = abc_30082_new_n5495_hfns_2
* NET  6205 = abc_30082_new_n5495_hfns_1
* NET  6206 = abc_30082_new_n5495_hfns_0
* NET  6207 = abc_30082_new_n5495
* NET  6208 = abc_30082_new_n5494_hfns_2
* NET  6209 = abc_30082_new_n5494_hfns_1
* NET  6210 = abc_30082_new_n5494_hfns_0
* NET  6211 = abc_30082_new_n5494
* NET  6212 = abc_30082_new_n5493
* NET  6213 = abc_30082_new_n5491
* NET  6214 = abc_30082_new_n5490_hfns_2
* NET  6215 = abc_30082_new_n5490_hfns_1
* NET  6216 = abc_30082_new_n5490_hfns_0
* NET  6217 = abc_30082_new_n5490
* NET  6218 = abc_30082_new_n5489_hfns_2
* NET  6219 = abc_30082_new_n5489_hfns_1
* NET  6220 = abc_30082_new_n5489_hfns_0
* NET  6221 = abc_30082_new_n5489
* NET  6222 = abc_30082_new_n5488
* NET  6223 = abc_30082_new_n5486
* NET  6224 = abc_30082_new_n5485_hfns_2
* NET  6225 = abc_30082_new_n5485_hfns_1
* NET  6226 = abc_30082_new_n5485_hfns_0
* NET  6227 = abc_30082_new_n5485
* NET  6228 = abc_30082_new_n5484_hfns_2
* NET  6229 = abc_30082_new_n5484_hfns_1
* NET  6230 = abc_30082_new_n5484_hfns_0
* NET  6231 = abc_30082_new_n5484
* NET  6232 = abc_30082_new_n5483
* NET  6233 = abc_30082_new_n5481
* NET  6234 = abc_30082_new_n5480_hfns_2
* NET  6235 = abc_30082_new_n5480_hfns_1
* NET  6236 = abc_30082_new_n5480_hfns_0
* NET  6237 = abc_30082_new_n5480
* NET  6238 = abc_30082_new_n5479_hfns_2
* NET  6239 = abc_30082_new_n5479_hfns_1
* NET  6240 = abc_30082_new_n5479_hfns_0
* NET  6241 = abc_30082_new_n5479
* NET  6242 = abc_30082_new_n5478
* NET  6243 = abc_30082_new_n5476_hfns_2
* NET  6244 = abc_30082_new_n5476_hfns_1
* NET  6245 = abc_30082_new_n5476_hfns_0
* NET  6246 = abc_30082_new_n5476
* NET  6247 = abc_30082_new_n5475
* NET  6248 = abc_30082_new_n5474
* NET  6249 = abc_30082_new_n5473
* NET  6250 = abc_30082_new_n5471_hfns_2
* NET  6251 = abc_30082_new_n5471_hfns_1
* NET  6252 = abc_30082_new_n5471_hfns_0
* NET  6253 = abc_30082_new_n5471
* NET  6254 = abc_30082_new_n5470
* NET  6255 = abc_30082_new_n5469
* NET  6256 = abc_30082_new_n5468
* NET  6257 = abc_30082_new_n5466_hfns_2
* NET  6258 = abc_30082_new_n5466_hfns_1
* NET  6259 = abc_30082_new_n5466_hfns_0
* NET  6260 = abc_30082_new_n5466
* NET  6261 = abc_30082_new_n5465
* NET  6262 = abc_30082_new_n5464
* NET  6263 = abc_30082_new_n5463
* NET  6264 = abc_30082_new_n5461_hfns_2
* NET  6265 = abc_30082_new_n5461_hfns_1
* NET  6266 = abc_30082_new_n5461_hfns_0
* NET  6267 = abc_30082_new_n5461
* NET  6268 = abc_30082_new_n5460
* NET  6269 = abc_30082_new_n5459
* NET  6270 = abc_30082_new_n5458
* NET  6271 = abc_30082_new_n5456_hfns_2
* NET  6272 = abc_30082_new_n5456_hfns_1
* NET  6273 = abc_30082_new_n5456_hfns_0
* NET  6274 = abc_30082_new_n5456
* NET  6275 = abc_30082_new_n5455
* NET  6276 = abc_30082_new_n5453_hfns_2
* NET  6277 = abc_30082_new_n5453_hfns_1
* NET  6278 = abc_30082_new_n5453_hfns_0
* NET  6279 = abc_30082_new_n5453
* NET  6280 = abc_30082_new_n5452
* NET  6281 = abc_30082_new_n5450_hfns_2
* NET  6282 = abc_30082_new_n5450_hfns_1
* NET  6283 = abc_30082_new_n5450_hfns_0
* NET  6284 = abc_30082_new_n5450
* NET  6285 = abc_30082_new_n5449
* NET  6286 = abc_30082_new_n5448_hfns_9
* NET  6287 = abc_30082_new_n5448_hfns_8
* NET  6288 = abc_30082_new_n5448_hfns_7
* NET  6289 = abc_30082_new_n5448_hfns_6
* NET  6290 = abc_30082_new_n5448_hfns_5
* NET  6291 = abc_30082_new_n5448_hfns_4
* NET  6292 = abc_30082_new_n5448_hfns_3
* NET  6293 = abc_30082_new_n5448_hfns_2
* NET  6294 = abc_30082_new_n5448_hfns_1
* NET  6295 = abc_30082_new_n5448_hfns_0
* NET  6296 = abc_30082_new_n5448
* NET  6297 = abc_30082_new_n5447
* NET  6298 = abc_30082_new_n5446_hfns_2
* NET  6299 = abc_30082_new_n5446_hfns_1
* NET  6300 = abc_30082_new_n5446_hfns_0
* NET  6301 = abc_30082_new_n5446
* NET  6302 = abc_30082_new_n5445
* NET  6303 = abc_30082_new_n5444
* NET  6304 = abc_30082_new_n5443
* NET  6305 = abc_30082_new_n5442
* NET  6306 = abc_30082_new_n5441
* NET  6307 = abc_30082_new_n5440
* NET  6308 = abc_30082_new_n5439
* NET  6309 = abc_30082_new_n5438
* NET  6310 = abc_30082_new_n5437
* NET  6311 = abc_30082_new_n5436
* NET  6312 = abc_30082_new_n5435
* NET  6313 = abc_30082_new_n5434
* NET  6314 = abc_30082_new_n5422
* NET  6315 = abc_30082_new_n5421
* NET  6316 = abc_30082_new_n5420
* NET  6317 = abc_30082_new_n5419
* NET  6318 = abc_30082_new_n5418
* NET  6319 = abc_30082_new_n5417
* NET  6320 = abc_30082_new_n5416
* NET  6321 = abc_30082_new_n5415
* NET  6322 = abc_30082_new_n5414
* NET  6323 = abc_30082_new_n5413
* NET  6324 = abc_30082_new_n5412
* NET  6325 = abc_30082_new_n5411
* NET  6326 = abc_30082_new_n5410
* NET  6327 = abc_30082_new_n5409
* NET  6328 = abc_30082_new_n5408
* NET  6329 = abc_30082_new_n5407
* NET  6330 = abc_30082_new_n5406
* NET  6331 = abc_30082_new_n5405
* NET  6332 = abc_30082_new_n5404
* NET  6333 = abc_30082_new_n5403
* NET  6334 = abc_30082_new_n5402
* NET  6335 = abc_30082_new_n5401
* NET  6336 = abc_30082_new_n5400
* NET  6337 = abc_30082_new_n5399
* NET  6338 = abc_30082_new_n5398
* NET  6339 = abc_30082_new_n5397
* NET  6340 = abc_30082_new_n5396
* NET  6341 = abc_30082_new_n5395
* NET  6342 = abc_30082_new_n5394
* NET  6343 = abc_30082_new_n5393
* NET  6344 = abc_30082_new_n5392
* NET  6345 = abc_30082_new_n5391
* NET  6346 = abc_30082_new_n5390
* NET  6347 = abc_30082_new_n5389
* NET  6348 = abc_30082_new_n5388
* NET  6349 = abc_30082_new_n5387
* NET  6350 = abc_30082_new_n5386
* NET  6351 = abc_30082_new_n5384
* NET  6352 = abc_30082_new_n5383
* NET  6353 = abc_30082_new_n5382
* NET  6354 = abc_30082_new_n5381
* NET  6355 = abc_30082_new_n5380
* NET  6356 = abc_30082_new_n5379
* NET  6357 = abc_30082_new_n5378
* NET  6358 = abc_30082_new_n5377
* NET  6359 = abc_30082_new_n5376
* NET  6360 = abc_30082_new_n5375
* NET  6361 = abc_30082_new_n5374
* NET  6362 = abc_30082_new_n5373
* NET  6363 = abc_30082_new_n5372
* NET  6364 = abc_30082_new_n5371
* NET  6365 = abc_30082_new_n5370
* NET  6366 = abc_30082_new_n5369
* NET  6367 = abc_30082_new_n5368
* NET  6368 = abc_30082_new_n5367
* NET  6369 = abc_30082_new_n5366
* NET  6370 = abc_30082_new_n5365
* NET  6371 = abc_30082_new_n5364
* NET  6372 = abc_30082_new_n5363
* NET  6373 = abc_30082_new_n5362
* NET  6374 = abc_30082_new_n5361
* NET  6375 = abc_30082_new_n5360
* NET  6376 = abc_30082_new_n5359
* NET  6377 = abc_30082_new_n5358
* NET  6378 = abc_30082_new_n5357
* NET  6379 = abc_30082_new_n5356
* NET  6380 = abc_30082_new_n5355
* NET  6381 = abc_30082_new_n5354
* NET  6382 = abc_30082_new_n5353
* NET  6383 = abc_30082_new_n5352
* NET  6384 = abc_30082_new_n5351
* NET  6385 = abc_30082_new_n5350
* NET  6386 = abc_30082_new_n5349
* NET  6387 = abc_30082_new_n5347
* NET  6388 = abc_30082_new_n5346
* NET  6389 = abc_30082_new_n5345
* NET  6390 = abc_30082_new_n5344_hfns_2
* NET  6391 = abc_30082_new_n5344_hfns_1
* NET  6392 = abc_30082_new_n5344_hfns_0
* NET  6393 = abc_30082_new_n5344
* NET  6394 = abc_30082_new_n5343
* NET  6395 = abc_30082_new_n5342
* NET  6396 = abc_30082_new_n5341
* NET  6397 = abc_30082_new_n5340
* NET  6398 = abc_30082_new_n5339
* NET  6399 = abc_30082_new_n5338
* NET  6400 = abc_30082_new_n5337
* NET  6401 = abc_30082_new_n5336
* NET  6402 = abc_30082_new_n5335
* NET  6403 = abc_30082_new_n5334
* NET  6404 = abc_30082_new_n5333
* NET  6405 = abc_30082_new_n5332
* NET  6406 = abc_30082_new_n5331
* NET  6407 = abc_30082_new_n5330
* NET  6408 = abc_30082_new_n5329
* NET  6409 = abc_30082_new_n5328
* NET  6410 = abc_30082_new_n5327
* NET  6411 = abc_30082_new_n5326
* NET  6412 = abc_30082_new_n5325
* NET  6413 = abc_30082_new_n5324
* NET  6414 = abc_30082_new_n5323
* NET  6415 = abc_30082_new_n5322
* NET  6416 = abc_30082_new_n5321
* NET  6417 = abc_30082_new_n5320
* NET  6418 = abc_30082_new_n5319
* NET  6419 = abc_30082_new_n5318
* NET  6420 = abc_30082_new_n5317
* NET  6421 = abc_30082_new_n5316
* NET  6422 = abc_30082_new_n5315
* NET  6423 = abc_30082_new_n5314
* NET  6424 = abc_30082_new_n5313
* NET  6425 = abc_30082_new_n5312
* NET  6426 = abc_30082_new_n5311
* NET  6427 = abc_30082_new_n5310
* NET  6428 = abc_30082_new_n5309
* NET  6429 = abc_30082_new_n5308
* NET  6430 = abc_30082_new_n5307
* NET  6431 = abc_30082_new_n5306
* NET  6432 = abc_30082_new_n5304
* NET  6433 = abc_30082_new_n5303
* NET  6434 = abc_30082_new_n5302
* NET  6435 = abc_30082_new_n5301
* NET  6436 = abc_30082_new_n5300
* NET  6437 = abc_30082_new_n5299
* NET  6438 = abc_30082_new_n5288_hfns_3
* NET  6439 = abc_30082_new_n5288_hfns_2
* NET  6440 = abc_30082_new_n5288_hfns_1
* NET  6441 = abc_30082_new_n5288_hfns_0
* NET  6442 = abc_30082_new_n5288
* NET  6443 = abc_30082_new_n5257_hfns_2
* NET  6444 = abc_30082_new_n5257_hfns_1
* NET  6445 = abc_30082_new_n5257_hfns_0
* NET  6446 = abc_30082_new_n5257
* NET  6447 = abc_30082_new_n5256_hfns_3
* NET  6448 = abc_30082_new_n5256_hfns_2
* NET  6449 = abc_30082_new_n5256_hfns_1
* NET  6450 = abc_30082_new_n5256_hfns_0
* NET  6451 = abc_30082_new_n5256
* NET  6452 = abc_30082_new_n5254
* NET  6453 = abc_30082_new_n5252
* NET  6454 = abc_30082_new_n5250
* NET  6455 = abc_30082_new_n5248
* NET  6456 = abc_30082_new_n5246
* NET  6457 = abc_30082_new_n5244
* NET  6458 = abc_30082_new_n5242
* NET  6459 = abc_30082_new_n5240
* NET  6460 = abc_30082_new_n5230
* NET  6461 = abc_30082_new_n5229
* NET  6462 = abc_30082_new_n5228
* NET  6463 = abc_30082_new_n5227
* NET  6464 = abc_30082_new_n5225
* NET  6465 = abc_30082_new_n5224
* NET  6466 = abc_30082_new_n5223
* NET  6467 = abc_30082_new_n5222
* NET  6468 = abc_30082_new_n5220
* NET  6469 = abc_30082_new_n5219
* NET  6470 = abc_30082_new_n5218
* NET  6471 = abc_30082_new_n5217
* NET  6472 = abc_30082_new_n5215
* NET  6473 = abc_30082_new_n5214
* NET  6474 = abc_30082_new_n5213
* NET  6475 = abc_30082_new_n5212
* NET  6476 = abc_30082_new_n5210
* NET  6477 = abc_30082_new_n5209
* NET  6478 = abc_30082_new_n5208
* NET  6479 = abc_30082_new_n5207
* NET  6480 = abc_30082_new_n5205
* NET  6481 = abc_30082_new_n5204
* NET  6482 = abc_30082_new_n5203
* NET  6483 = abc_30082_new_n5202
* NET  6484 = abc_30082_new_n5200
* NET  6485 = abc_30082_new_n5199
* NET  6486 = abc_30082_new_n5198
* NET  6487 = abc_30082_new_n5197
* NET  6488 = abc_30082_new_n5195
* NET  6489 = abc_30082_new_n5194
* NET  6490 = abc_30082_new_n5193
* NET  6491 = abc_30082_new_n5192
* NET  6492 = abc_30082_new_n5190
* NET  6493 = abc_30082_new_n5189
* NET  6494 = abc_30082_new_n5187
* NET  6495 = abc_30082_new_n5186
* NET  6496 = abc_30082_new_n5184
* NET  6497 = abc_30082_new_n5182
* NET  6498 = abc_30082_new_n5181
* NET  6499 = abc_30082_new_n5180
* NET  6500 = abc_30082_new_n5179
* NET  6501 = abc_30082_new_n5178
* NET  6502 = abc_30082_new_n5177
* NET  6503 = abc_30082_new_n5176
* NET  6504 = abc_30082_new_n5175
* NET  6505 = abc_30082_new_n5174
* NET  6506 = abc_30082_new_n5172
* NET  6507 = abc_30082_new_n5171
* NET  6508 = abc_30082_new_n5170
* NET  6509 = abc_30082_new_n5169
* NET  6510 = abc_30082_new_n5168
* NET  6511 = abc_30082_new_n5167
* NET  6512 = abc_30082_new_n5166
* NET  6513 = abc_30082_new_n5165
* NET  6514 = abc_30082_new_n5164
* NET  6515 = abc_30082_new_n5163
* NET  6516 = abc_30082_new_n5162
* NET  6517 = abc_30082_new_n5161
* NET  6518 = abc_30082_new_n5160
* NET  6519 = abc_30082_new_n5159
* NET  6520 = abc_30082_new_n5158
* NET  6521 = abc_30082_new_n5157
* NET  6522 = abc_30082_new_n5155
* NET  6523 = abc_30082_new_n5154
* NET  6524 = abc_30082_new_n5153
* NET  6525 = abc_30082_new_n5152
* NET  6526 = abc_30082_new_n5151
* NET  6527 = abc_30082_new_n5150
* NET  6528 = abc_30082_new_n5149
* NET  6529 = abc_30082_new_n5148
* NET  6530 = abc_30082_new_n5147
* NET  6531 = abc_30082_new_n5146
* NET  6532 = abc_30082_new_n5145
* NET  6533 = abc_30082_new_n5144
* NET  6534 = abc_30082_new_n5143
* NET  6535 = abc_30082_new_n5141
* NET  6536 = abc_30082_new_n5140
* NET  6537 = abc_30082_new_n5139
* NET  6538 = abc_30082_new_n5138
* NET  6539 = abc_30082_new_n5137
* NET  6540 = abc_30082_new_n5136
* NET  6541 = abc_30082_new_n5135
* NET  6542 = abc_30082_new_n5134
* NET  6543 = abc_30082_new_n5133
* NET  6544 = abc_30082_new_n5132
* NET  6545 = abc_30082_new_n5131
* NET  6546 = abc_30082_new_n5130
* NET  6547 = abc_30082_new_n5129
* NET  6548 = abc_30082_new_n5128
* NET  6549 = abc_30082_new_n5127
* NET  6550 = abc_30082_new_n5126
* NET  6551 = abc_30082_new_n5124
* NET  6552 = abc_30082_new_n5123
* NET  6553 = abc_30082_new_n5122
* NET  6554 = abc_30082_new_n5121
* NET  6555 = abc_30082_new_n5120
* NET  6556 = abc_30082_new_n5119
* NET  6557 = abc_30082_new_n5118
* NET  6558 = abc_30082_new_n5117
* NET  6559 = abc_30082_new_n5116
* NET  6560 = abc_30082_new_n5115
* NET  6561 = abc_30082_new_n5114
* NET  6562 = abc_30082_new_n5113
* NET  6563 = abc_30082_new_n5112
* NET  6564 = abc_30082_new_n5111
* NET  6565 = abc_30082_new_n5109
* NET  6566 = abc_30082_new_n5108
* NET  6567 = abc_30082_new_n5107
* NET  6568 = abc_30082_new_n5106
* NET  6569 = abc_30082_new_n5105
* NET  6570 = abc_30082_new_n5104
* NET  6571 = abc_30082_new_n5103
* NET  6572 = abc_30082_new_n5102
* NET  6573 = abc_30082_new_n5101
* NET  6574 = abc_30082_new_n5100
* NET  6575 = abc_30082_new_n5099
* NET  6576 = abc_30082_new_n5098
* NET  6577 = abc_30082_new_n5097
* NET  6578 = abc_30082_new_n5096
* NET  6579 = abc_30082_new_n5094
* NET  6580 = abc_30082_new_n5093
* NET  6581 = abc_30082_new_n5092
* NET  6582 = abc_30082_new_n5091
* NET  6583 = abc_30082_new_n5090
* NET  6584 = abc_30082_new_n5089
* NET  6585 = abc_30082_new_n5088
* NET  6586 = abc_30082_new_n5087
* NET  6587 = abc_30082_new_n5086
* NET  6588 = abc_30082_new_n5085
* NET  6589 = abc_30082_new_n5084
* NET  6590 = abc_30082_new_n5083
* NET  6591 = abc_30082_new_n5082
* NET  6592 = abc_30082_new_n5081
* NET  6593 = abc_30082_new_n5080
* NET  6594 = abc_30082_new_n5078
* NET  6595 = abc_30082_new_n5077
* NET  6596 = abc_30082_new_n5076
* NET  6597 = abc_30082_new_n5075
* NET  6598 = abc_30082_new_n5074
* NET  6599 = abc_30082_new_n5073
* NET  6600 = abc_30082_new_n5072
* NET  6601 = abc_30082_new_n5071
* NET  6602 = abc_30082_new_n5070
* NET  6603 = abc_30082_new_n5069
* NET  6604 = abc_30082_new_n5068
* NET  6605 = abc_30082_new_n5067
* NET  6606 = abc_30082_new_n5066
* NET  6607 = abc_30082_new_n5065
* NET  6608 = abc_30082_new_n5064
* NET  6609 = abc_30082_new_n5062
* NET  6610 = abc_30082_new_n5061
* NET  6611 = abc_30082_new_n5060
* NET  6612 = abc_30082_new_n5059
* NET  6613 = abc_30082_new_n5058
* NET  6614 = abc_30082_new_n5057
* NET  6615 = abc_30082_new_n5056
* NET  6616 = abc_30082_new_n5055
* NET  6617 = abc_30082_new_n5054
* NET  6618 = abc_30082_new_n5053
* NET  6619 = abc_30082_new_n5052
* NET  6620 = abc_30082_new_n5051
* NET  6621 = abc_30082_new_n5049
* NET  6622 = abc_30082_new_n5048
* NET  6623 = abc_30082_new_n5047
* NET  6624 = abc_30082_new_n5046
* NET  6625 = abc_30082_new_n5045
* NET  6626 = abc_30082_new_n5044
* NET  6627 = abc_30082_new_n5043
* NET  6628 = abc_30082_new_n5042
* NET  6629 = abc_30082_new_n5041
* NET  6630 = abc_30082_new_n5040
* NET  6631 = abc_30082_new_n5039
* NET  6632 = abc_30082_new_n5038
* NET  6633 = abc_30082_new_n5037
* NET  6634 = abc_30082_new_n5036
* NET  6635 = abc_30082_new_n5035
* NET  6636 = abc_30082_new_n5034
* NET  6637 = abc_30082_new_n5032
* NET  6638 = abc_30082_new_n5031
* NET  6639 = abc_30082_new_n5030
* NET  6640 = abc_30082_new_n5029
* NET  6641 = abc_30082_new_n5028
* NET  6642 = abc_30082_new_n5027
* NET  6643 = abc_30082_new_n5026
* NET  6644 = abc_30082_new_n5025
* NET  6645 = abc_30082_new_n5024
* NET  6646 = abc_30082_new_n5023
* NET  6647 = abc_30082_new_n5022
* NET  6648 = abc_30082_new_n5021
* NET  6649 = abc_30082_new_n5020
* NET  6650 = abc_30082_new_n5019
* NET  6651 = abc_30082_new_n5017
* NET  6652 = abc_30082_new_n5016
* NET  6653 = abc_30082_new_n5015
* NET  6654 = abc_30082_new_n5014
* NET  6655 = abc_30082_new_n5013
* NET  6656 = abc_30082_new_n5012
* NET  6657 = abc_30082_new_n5011
* NET  6658 = abc_30082_new_n5010
* NET  6659 = abc_30082_new_n5009
* NET  6660 = abc_30082_new_n5008
* NET  6661 = abc_30082_new_n5007
* NET  6662 = abc_30082_new_n5006
* NET  6663 = abc_30082_new_n5005
* NET  6664 = abc_30082_new_n5004
* NET  6665 = abc_30082_new_n5002
* NET  6666 = abc_30082_new_n5001
* NET  6667 = abc_30082_new_n5000
* NET  6668 = abc_30082_new_n4999
* NET  6669 = abc_30082_new_n4998
* NET  6670 = abc_30082_new_n4997
* NET  6671 = abc_30082_new_n4996
* NET  6672 = abc_30082_new_n4995
* NET  6673 = abc_30082_new_n4994
* NET  6674 = abc_30082_new_n4993
* NET  6675 = abc_30082_new_n4992
* NET  6676 = abc_30082_new_n4991
* NET  6677 = abc_30082_new_n4990
* NET  6678 = abc_30082_new_n4989
* NET  6679 = abc_30082_new_n4987
* NET  6680 = abc_30082_new_n4986
* NET  6681 = abc_30082_new_n4985
* NET  6682 = abc_30082_new_n4984
* NET  6683 = abc_30082_new_n4983
* NET  6684 = abc_30082_new_n4982
* NET  6685 = abc_30082_new_n4981
* NET  6686 = abc_30082_new_n4980
* NET  6687 = abc_30082_new_n4979
* NET  6688 = abc_30082_new_n4978
* NET  6689 = abc_30082_new_n4977
* NET  6690 = abc_30082_new_n4976
* NET  6691 = abc_30082_new_n4975
* NET  6692 = abc_30082_new_n4974
* NET  6693 = abc_30082_new_n4973
* NET  6694 = abc_30082_new_n4971
* NET  6695 = abc_30082_new_n4970
* NET  6696 = abc_30082_new_n4969
* NET  6697 = abc_30082_new_n4968
* NET  6698 = abc_30082_new_n4967
* NET  6699 = abc_30082_new_n4966
* NET  6700 = abc_30082_new_n4965
* NET  6701 = abc_30082_new_n4964
* NET  6702 = abc_30082_new_n4963
* NET  6703 = abc_30082_new_n4962
* NET  6704 = abc_30082_new_n4961
* NET  6705 = abc_30082_new_n4960
* NET  6706 = abc_30082_new_n4959
* NET  6707 = abc_30082_new_n4957
* NET  6708 = abc_30082_new_n4956
* NET  6709 = abc_30082_new_n4955
* NET  6710 = abc_30082_new_n4954
* NET  6711 = abc_30082_new_n4953
* NET  6712 = abc_30082_new_n4952
* NET  6713 = abc_30082_new_n4951
* NET  6714 = abc_30082_new_n4950
* NET  6715 = abc_30082_new_n4949
* NET  6716 = abc_30082_new_n4948
* NET  6717 = abc_30082_new_n4947
* NET  6718 = abc_30082_new_n4946
* NET  6719 = abc_30082_new_n4945
* NET  6720 = abc_30082_new_n4944
* NET  6721 = abc_30082_new_n4942
* NET  6722 = abc_30082_new_n4941
* NET  6723 = abc_30082_new_n4940
* NET  6724 = abc_30082_new_n4939
* NET  6725 = abc_30082_new_n4938
* NET  6726 = abc_30082_new_n4937
* NET  6727 = abc_30082_new_n4936
* NET  6728 = abc_30082_new_n4935
* NET  6729 = abc_30082_new_n4934
* NET  6730 = abc_30082_new_n4933
* NET  6731 = abc_30082_new_n4932
* NET  6732 = abc_30082_new_n4931
* NET  6733 = abc_30082_new_n4930
* NET  6734 = abc_30082_new_n4928
* NET  6735 = abc_30082_new_n4927
* NET  6736 = abc_30082_new_n4926
* NET  6737 = abc_30082_new_n4925
* NET  6738 = abc_30082_new_n4924
* NET  6739 = abc_30082_new_n4923
* NET  6740 = abc_30082_new_n4922
* NET  6741 = abc_30082_new_n4921
* NET  6742 = abc_30082_new_n4920
* NET  6743 = abc_30082_new_n4919
* NET  6744 = abc_30082_new_n4918
* NET  6745 = abc_30082_new_n4917
* NET  6746 = abc_30082_new_n4916
* NET  6747 = abc_30082_new_n4915
* NET  6748 = abc_30082_new_n4913
* NET  6749 = abc_30082_new_n4912
* NET  6750 = abc_30082_new_n4911
* NET  6751 = abc_30082_new_n4910
* NET  6752 = abc_30082_new_n4909
* NET  6753 = abc_30082_new_n4908
* NET  6754 = abc_30082_new_n4907
* NET  6755 = abc_30082_new_n4906
* NET  6756 = abc_30082_new_n4905
* NET  6757 = abc_30082_new_n4904
* NET  6758 = abc_30082_new_n4903
* NET  6759 = abc_30082_new_n4902
* NET  6760 = abc_30082_new_n4901
* NET  6761 = abc_30082_new_n4900
* NET  6762 = abc_30082_new_n4898
* NET  6763 = abc_30082_new_n4897
* NET  6764 = abc_30082_new_n4896
* NET  6765 = abc_30082_new_n4895
* NET  6766 = abc_30082_new_n4894
* NET  6767 = abc_30082_new_n4893
* NET  6768 = abc_30082_new_n4892
* NET  6769 = abc_30082_new_n4891
* NET  6770 = abc_30082_new_n4890
* NET  6771 = abc_30082_new_n4889
* NET  6772 = abc_30082_new_n4888
* NET  6773 = abc_30082_new_n4887
* NET  6774 = abc_30082_new_n4886
* NET  6775 = abc_30082_new_n4885
* NET  6776 = abc_30082_new_n4883
* NET  6777 = abc_30082_new_n4882
* NET  6778 = abc_30082_new_n4881
* NET  6779 = abc_30082_new_n4880
* NET  6780 = abc_30082_new_n4879
* NET  6781 = abc_30082_new_n4878
* NET  6782 = abc_30082_new_n4877
* NET  6783 = abc_30082_new_n4876
* NET  6784 = abc_30082_new_n4875
* NET  6785 = abc_30082_new_n4874
* NET  6786 = abc_30082_new_n4873
* NET  6787 = abc_30082_new_n4872
* NET  6788 = abc_30082_new_n4871
* NET  6789 = abc_30082_new_n4869
* NET  6790 = abc_30082_new_n4868
* NET  6791 = abc_30082_new_n4867
* NET  6792 = abc_30082_new_n4866
* NET  6793 = abc_30082_new_n4865
* NET  6794 = abc_30082_new_n4864
* NET  6795 = abc_30082_new_n4863
* NET  6796 = abc_30082_new_n4862
* NET  6797 = abc_30082_new_n4861
* NET  6798 = abc_30082_new_n4860
* NET  6799 = abc_30082_new_n4859
* NET  6800 = abc_30082_new_n4858
* NET  6801 = abc_30082_new_n4857
* NET  6802 = abc_30082_new_n4856
* NET  6803 = abc_30082_new_n4855
* NET  6804 = abc_30082_new_n4853
* NET  6805 = abc_30082_new_n4852
* NET  6806 = abc_30082_new_n4851
* NET  6807 = abc_30082_new_n4850
* NET  6808 = abc_30082_new_n4849
* NET  6809 = abc_30082_new_n4848
* NET  6810 = abc_30082_new_n4847
* NET  6811 = abc_30082_new_n4846
* NET  6812 = abc_30082_new_n4845
* NET  6813 = abc_30082_new_n4844
* NET  6814 = abc_30082_new_n4843
* NET  6815 = abc_30082_new_n4842
* NET  6816 = abc_30082_new_n4841
* NET  6817 = abc_30082_new_n4840
* NET  6818 = abc_30082_new_n4838
* NET  6819 = abc_30082_new_n4837
* NET  6820 = abc_30082_new_n4836
* NET  6821 = abc_30082_new_n4835
* NET  6822 = abc_30082_new_n4834
* NET  6823 = abc_30082_new_n4833
* NET  6824 = abc_30082_new_n4832
* NET  6825 = abc_30082_new_n4831
* NET  6826 = abc_30082_new_n4830
* NET  6827 = abc_30082_new_n4829
* NET  6828 = abc_30082_new_n4828
* NET  6829 = abc_30082_new_n4827
* NET  6830 = abc_30082_new_n4826
* NET  6831 = abc_30082_new_n4824
* NET  6832 = abc_30082_new_n4823
* NET  6833 = abc_30082_new_n4822
* NET  6834 = abc_30082_new_n4821
* NET  6835 = abc_30082_new_n4820
* NET  6836 = abc_30082_new_n4819
* NET  6837 = abc_30082_new_n4818
* NET  6838 = abc_30082_new_n4817
* NET  6839 = abc_30082_new_n4816
* NET  6840 = abc_30082_new_n4815
* NET  6841 = abc_30082_new_n4814
* NET  6842 = abc_30082_new_n4813
* NET  6843 = abc_30082_new_n4812
* NET  6844 = abc_30082_new_n4811
* NET  6845 = abc_30082_new_n4810
* NET  6846 = abc_30082_new_n4809
* NET  6847 = abc_30082_new_n4807
* NET  6848 = abc_30082_new_n4806
* NET  6849 = abc_30082_new_n4805
* NET  6850 = abc_30082_new_n4804
* NET  6851 = abc_30082_new_n4803
* NET  6852 = abc_30082_new_n4802
* NET  6853 = abc_30082_new_n4801
* NET  6854 = abc_30082_new_n4800
* NET  6855 = abc_30082_new_n4799
* NET  6856 = abc_30082_new_n4798
* NET  6857 = abc_30082_new_n4797
* NET  6858 = abc_30082_new_n4796
* NET  6859 = abc_30082_new_n4795
* NET  6860 = abc_30082_new_n4794
* NET  6861 = abc_30082_new_n4792
* NET  6862 = abc_30082_new_n4791
* NET  6863 = abc_30082_new_n4790
* NET  6864 = abc_30082_new_n4789
* NET  6865 = abc_30082_new_n4788
* NET  6866 = abc_30082_new_n4787
* NET  6867 = abc_30082_new_n4786
* NET  6868 = abc_30082_new_n4785
* NET  6869 = abc_30082_new_n4784
* NET  6870 = abc_30082_new_n4783
* NET  6871 = abc_30082_new_n4782
* NET  6872 = abc_30082_new_n4781
* NET  6873 = abc_30082_new_n4779
* NET  6874 = abc_30082_new_n4778
* NET  6875 = abc_30082_new_n4777
* NET  6876 = abc_30082_new_n4776
* NET  6877 = abc_30082_new_n4775
* NET  6878 = abc_30082_new_n4774
* NET  6879 = abc_30082_new_n4773
* NET  6880 = abc_30082_new_n4772
* NET  6881 = abc_30082_new_n4771
* NET  6882 = abc_30082_new_n4770
* NET  6883 = abc_30082_new_n4769
* NET  6884 = abc_30082_new_n4768
* NET  6885 = abc_30082_new_n4767
* NET  6886 = abc_30082_new_n4766
* NET  6887 = abc_30082_new_n4765
* NET  6888 = abc_30082_new_n4764
* NET  6889 = abc_30082_new_n4762
* NET  6890 = abc_30082_new_n4761
* NET  6891 = abc_30082_new_n4760
* NET  6892 = abc_30082_new_n4759
* NET  6893 = abc_30082_new_n4758
* NET  6894 = abc_30082_new_n4757
* NET  6895 = abc_30082_new_n4756
* NET  6896 = abc_30082_new_n4755
* NET  6897 = abc_30082_new_n4754
* NET  6898 = abc_30082_new_n4753
* NET  6899 = abc_30082_new_n4752
* NET  6900 = abc_30082_new_n4751
* NET  6901 = abc_30082_new_n4750
* NET  6902 = abc_30082_new_n4749
* NET  6903 = abc_30082_new_n4748
* NET  6904 = abc_30082_new_n4747
* NET  6905 = abc_30082_new_n4746
* NET  6906 = abc_30082_new_n4744
* NET  6907 = abc_30082_new_n4743
* NET  6908 = abc_30082_new_n4742
* NET  6909 = abc_30082_new_n4741
* NET  6910 = abc_30082_new_n4740
* NET  6911 = abc_30082_new_n4739
* NET  6912 = abc_30082_new_n4738
* NET  6913 = abc_30082_new_n4737
* NET  6914 = abc_30082_new_n4736
* NET  6915 = abc_30082_new_n4735
* NET  6916 = abc_30082_new_n4734
* NET  6917 = abc_30082_new_n4733
* NET  6918 = abc_30082_new_n4731
* NET  6919 = abc_30082_new_n4730
* NET  6920 = abc_30082_new_n4729
* NET  6921 = abc_30082_new_n4728
* NET  6922 = abc_30082_new_n4727
* NET  6923 = abc_30082_new_n4726
* NET  6924 = abc_30082_new_n4725
* NET  6925 = abc_30082_new_n4724
* NET  6926 = abc_30082_new_n4723
* NET  6927 = abc_30082_new_n4722
* NET  6928 = abc_30082_new_n4721
* NET  6929 = abc_30082_new_n4720
* NET  6930 = abc_30082_new_n4719
* NET  6931 = abc_30082_new_n4718
* NET  6932 = abc_30082_new_n4717
* NET  6933 = abc_30082_new_n4716
* NET  6934 = abc_30082_new_n4714
* NET  6935 = abc_30082_new_n4713
* NET  6936 = abc_30082_new_n4712
* NET  6937 = abc_30082_new_n4711
* NET  6938 = abc_30082_new_n4710
* NET  6939 = abc_30082_new_n4709
* NET  6940 = abc_30082_new_n4708
* NET  6941 = abc_30082_new_n4707_hfns_2
* NET  6942 = abc_30082_new_n4707_hfns_1
* NET  6943 = abc_30082_new_n4707_hfns_0
* NET  6944 = abc_30082_new_n4707
* NET  6945 = abc_30082_new_n4706
* NET  6946 = abc_30082_new_n4705_hfns_2
* NET  6947 = abc_30082_new_n4705_hfns_1
* NET  6948 = abc_30082_new_n4705_hfns_0
* NET  6949 = abc_30082_new_n4705
* NET  6950 = abc_30082_new_n4704
* NET  6951 = abc_30082_new_n4703
* NET  6952 = abc_30082_new_n4702
* NET  6953 = abc_30082_new_n4701
* NET  6954 = abc_30082_new_n4700
* NET  6955 = abc_30082_new_n4699
* NET  6956 = abc_30082_new_n4698
* NET  6957 = abc_30082_new_n4697
* NET  6958 = abc_30082_new_n4696
* NET  6959 = abc_30082_new_n4695
* NET  6960 = abc_30082_new_n4694
* NET  6961 = abc_30082_new_n4693
* NET  6962 = abc_30082_new_n4692
* NET  6963 = abc_30082_new_n4691
* NET  6964 = abc_30082_new_n4690
* NET  6965 = abc_30082_new_n4689
* NET  6966 = abc_30082_new_n4688
* NET  6967 = abc_30082_new_n4687
* NET  6968 = abc_30082_new_n4686
* NET  6969 = abc_30082_new_n4685
* NET  6970 = abc_30082_new_n4684
* NET  6971 = abc_30082_new_n4683
* NET  6972 = abc_30082_new_n4682
* NET  6973 = abc_30082_new_n4681
* NET  6974 = abc_30082_new_n4680
* NET  6975 = abc_30082_new_n4679
* NET  6976 = abc_30082_new_n4678
* NET  6977 = abc_30082_new_n4677
* NET  6978 = abc_30082_new_n4676
* NET  6979 = abc_30082_new_n4675
* NET  6980 = abc_30082_new_n4674
* NET  6981 = abc_30082_new_n4673
* NET  6982 = abc_30082_new_n4672
* NET  6983 = abc_30082_new_n4671
* NET  6984 = abc_30082_new_n4670
* NET  6985 = abc_30082_new_n4669
* NET  6986 = abc_30082_new_n4668
* NET  6987 = abc_30082_new_n4667
* NET  6988 = abc_30082_new_n4666
* NET  6989 = abc_30082_new_n4665
* NET  6990 = abc_30082_new_n4664
* NET  6991 = abc_30082_new_n4663
* NET  6992 = abc_30082_new_n4662
* NET  6993 = abc_30082_new_n4661
* NET  6994 = abc_30082_new_n4660
* NET  6995 = abc_30082_new_n4659
* NET  6996 = abc_30082_new_n4658
* NET  6997 = abc_30082_new_n4657
* NET  6998 = abc_30082_new_n4656
* NET  6999 = abc_30082_new_n4655
* NET  7000 = abc_30082_new_n4654
* NET  7001 = abc_30082_new_n4653
* NET  7002 = abc_30082_new_n4652
* NET  7003 = abc_30082_new_n4651
* NET  7004 = abc_30082_new_n4650
* NET  7005 = abc_30082_new_n4649
* NET  7006 = abc_30082_new_n4648
* NET  7007 = abc_30082_new_n4647
* NET  7008 = abc_30082_new_n4646
* NET  7009 = abc_30082_new_n4645
* NET  7010 = abc_30082_new_n4644
* NET  7011 = abc_30082_new_n4643
* NET  7012 = abc_30082_new_n4642
* NET  7013 = abc_30082_new_n4641
* NET  7014 = abc_30082_new_n4640
* NET  7015 = abc_30082_new_n4639
* NET  7016 = abc_30082_new_n4638
* NET  7017 = abc_30082_new_n4637
* NET  7018 = abc_30082_new_n4636
* NET  7019 = abc_30082_new_n4635
* NET  7020 = abc_30082_new_n4634
* NET  7021 = abc_30082_new_n4633
* NET  7022 = abc_30082_new_n4632
* NET  7023 = abc_30082_new_n4631
* NET  7024 = abc_30082_new_n4630
* NET  7025 = abc_30082_new_n4629
* NET  7026 = abc_30082_new_n4628
* NET  7027 = abc_30082_new_n4627
* NET  7028 = abc_30082_new_n4626
* NET  7029 = abc_30082_new_n4625
* NET  7030 = abc_30082_new_n4624
* NET  7031 = abc_30082_new_n4623
* NET  7032 = abc_30082_new_n4622
* NET  7033 = abc_30082_new_n4621
* NET  7034 = abc_30082_new_n4620
* NET  7035 = abc_30082_new_n4619
* NET  7036 = abc_30082_new_n4618
* NET  7037 = abc_30082_new_n4617
* NET  7038 = abc_30082_new_n4616
* NET  7039 = abc_30082_new_n4615
* NET  7040 = abc_30082_new_n4614
* NET  7041 = abc_30082_new_n4613
* NET  7042 = abc_30082_new_n4612
* NET  7043 = abc_30082_new_n4611
* NET  7044 = abc_30082_new_n4610
* NET  7045 = abc_30082_new_n4609
* NET  7046 = abc_30082_new_n4608
* NET  7047 = abc_30082_new_n4607
* NET  7048 = abc_30082_new_n4606
* NET  7049 = abc_30082_new_n4605
* NET  7050 = abc_30082_new_n4604
* NET  7051 = abc_30082_new_n4603
* NET  7052 = abc_30082_new_n4602
* NET  7053 = abc_30082_new_n4601
* NET  7054 = abc_30082_new_n4600
* NET  7055 = abc_30082_new_n4599
* NET  7056 = abc_30082_new_n4598
* NET  7057 = abc_30082_new_n4597
* NET  7058 = abc_30082_new_n4596
* NET  7059 = abc_30082_new_n4595
* NET  7060 = abc_30082_new_n4594
* NET  7061 = abc_30082_new_n4593
* NET  7062 = abc_30082_new_n4592
* NET  7063 = abc_30082_new_n4591
* NET  7064 = abc_30082_new_n4590
* NET  7065 = abc_30082_new_n4589
* NET  7066 = abc_30082_new_n4588
* NET  7067 = abc_30082_new_n4587
* NET  7068 = abc_30082_new_n4586
* NET  7069 = abc_30082_new_n4585
* NET  7070 = abc_30082_new_n4584
* NET  7071 = abc_30082_new_n4583
* NET  7072 = abc_30082_new_n4582
* NET  7073 = abc_30082_new_n4581
* NET  7074 = abc_30082_new_n4580
* NET  7075 = abc_30082_new_n4579
* NET  7076 = abc_30082_new_n4578
* NET  7077 = abc_30082_new_n4577
* NET  7078 = abc_30082_new_n4576
* NET  7079 = abc_30082_new_n4575
* NET  7080 = abc_30082_new_n4574
* NET  7081 = abc_30082_new_n4573
* NET  7082 = abc_30082_new_n4572
* NET  7083 = abc_30082_new_n4571
* NET  7084 = abc_30082_new_n4570
* NET  7085 = abc_30082_new_n4569
* NET  7086 = abc_30082_new_n4568
* NET  7087 = abc_30082_new_n4567
* NET  7088 = abc_30082_new_n4566
* NET  7089 = abc_30082_new_n4565
* NET  7090 = abc_30082_new_n4564
* NET  7091 = abc_30082_new_n4563
* NET  7092 = abc_30082_new_n4562
* NET  7093 = abc_30082_new_n4561
* NET  7094 = abc_30082_new_n4560
* NET  7095 = abc_30082_new_n4559
* NET  7096 = abc_30082_new_n4558
* NET  7097 = abc_30082_new_n4557
* NET  7098 = abc_30082_new_n4556
* NET  7099 = abc_30082_new_n4555
* NET  7100 = abc_30082_new_n4554
* NET  7101 = abc_30082_new_n4553
* NET  7102 = abc_30082_new_n4552
* NET  7103 = abc_30082_new_n4551
* NET  7104 = abc_30082_new_n4550
* NET  7105 = abc_30082_new_n4549
* NET  7106 = abc_30082_new_n4548
* NET  7107 = abc_30082_new_n4547
* NET  7108 = abc_30082_new_n4546
* NET  7109 = abc_30082_new_n4545
* NET  7110 = abc_30082_new_n4544
* NET  7111 = abc_30082_new_n4543
* NET  7112 = abc_30082_new_n4542
* NET  7113 = abc_30082_new_n4541
* NET  7114 = abc_30082_new_n4540
* NET  7115 = abc_30082_new_n4539
* NET  7116 = abc_30082_new_n4538
* NET  7117 = abc_30082_new_n4537
* NET  7118 = abc_30082_new_n4536
* NET  7119 = abc_30082_new_n4535
* NET  7120 = abc_30082_new_n4534
* NET  7121 = abc_30082_new_n4533
* NET  7122 = abc_30082_new_n4532
* NET  7123 = abc_30082_new_n4531
* NET  7124 = abc_30082_new_n4530
* NET  7125 = abc_30082_new_n4529
* NET  7126 = abc_30082_new_n4528
* NET  7127 = abc_30082_new_n4527
* NET  7128 = abc_30082_new_n4526
* NET  7129 = abc_30082_new_n4525
* NET  7130 = abc_30082_new_n4524
* NET  7131 = abc_30082_new_n4523
* NET  7132 = abc_30082_new_n4522
* NET  7133 = abc_30082_new_n4521
* NET  7134 = abc_30082_new_n4520
* NET  7135 = abc_30082_new_n4519
* NET  7136 = abc_30082_new_n4518
* NET  7137 = abc_30082_new_n4517
* NET  7138 = abc_30082_new_n4516
* NET  7139 = abc_30082_new_n4515
* NET  7140 = abc_30082_new_n4514
* NET  7141 = abc_30082_new_n4513
* NET  7142 = abc_30082_new_n4512
* NET  7143 = abc_30082_new_n4511
* NET  7144 = abc_30082_new_n4510
* NET  7145 = abc_30082_new_n4509
* NET  7146 = abc_30082_new_n4508
* NET  7147 = abc_30082_new_n4507
* NET  7148 = abc_30082_new_n4506
* NET  7149 = abc_30082_new_n4505
* NET  7150 = abc_30082_new_n4504
* NET  7151 = abc_30082_new_n4503
* NET  7152 = abc_30082_new_n4502
* NET  7153 = abc_30082_new_n4501
* NET  7154 = abc_30082_new_n4500
* NET  7155 = abc_30082_new_n4499
* NET  7156 = abc_30082_new_n4498
* NET  7157 = abc_30082_new_n4497
* NET  7158 = abc_30082_new_n4496
* NET  7159 = abc_30082_new_n4495
* NET  7160 = abc_30082_new_n4494
* NET  7161 = abc_30082_new_n4493
* NET  7162 = abc_30082_new_n4492
* NET  7163 = abc_30082_new_n4491
* NET  7164 = abc_30082_new_n4490
* NET  7165 = abc_30082_new_n4489
* NET  7166 = abc_30082_new_n4488
* NET  7167 = abc_30082_new_n4487
* NET  7168 = abc_30082_new_n4486
* NET  7169 = abc_30082_new_n4485
* NET  7170 = abc_30082_new_n4484
* NET  7171 = abc_30082_new_n4483
* NET  7172 = abc_30082_new_n4482
* NET  7173 = abc_30082_new_n4481
* NET  7174 = abc_30082_new_n4480
* NET  7175 = abc_30082_new_n4479
* NET  7176 = abc_30082_new_n4478
* NET  7177 = abc_30082_new_n4477
* NET  7178 = abc_30082_new_n4476
* NET  7179 = abc_30082_new_n4475
* NET  7180 = abc_30082_new_n4474
* NET  7181 = abc_30082_new_n4472
* NET  7182 = abc_30082_new_n4471
* NET  7183 = abc_30082_new_n4470
* NET  7184 = abc_30082_new_n4469
* NET  7185 = abc_30082_new_n4468
* NET  7186 = abc_30082_new_n4467
* NET  7187 = abc_30082_new_n4466
* NET  7188 = abc_30082_new_n4465
* NET  7189 = abc_30082_new_n4464
* NET  7190 = abc_30082_new_n4463
* NET  7191 = abc_30082_new_n4462
* NET  7192 = abc_30082_new_n4461
* NET  7193 = abc_30082_new_n4460
* NET  7194 = abc_30082_new_n4459
* NET  7195 = abc_30082_new_n4458
* NET  7196 = abc_30082_new_n4457
* NET  7197 = abc_30082_new_n4455
* NET  7198 = abc_30082_new_n4454
* NET  7199 = abc_30082_new_n4453
* NET  7200 = abc_30082_new_n4452
* NET  7201 = abc_30082_new_n4451
* NET  7202 = abc_30082_new_n4450
* NET  7203 = abc_30082_new_n4449
* NET  7204 = abc_30082_new_n4448
* NET  7205 = abc_30082_new_n4447
* NET  7206 = abc_30082_new_n4446
* NET  7207 = abc_30082_new_n4445
* NET  7208 = abc_30082_new_n4444
* NET  7209 = abc_30082_new_n4443
* NET  7210 = abc_30082_new_n4442
* NET  7211 = abc_30082_new_n4441
* NET  7212 = abc_30082_new_n4440
* NET  7213 = abc_30082_new_n4439
* NET  7214 = abc_30082_new_n4437
* NET  7215 = abc_30082_new_n4436
* NET  7216 = abc_30082_new_n4435
* NET  7217 = abc_30082_new_n4434
* NET  7218 = abc_30082_new_n4433
* NET  7219 = abc_30082_new_n4432
* NET  7220 = abc_30082_new_n4431
* NET  7221 = abc_30082_new_n4430
* NET  7222 = abc_30082_new_n4429
* NET  7223 = abc_30082_new_n4428
* NET  7224 = abc_30082_new_n4427
* NET  7225 = abc_30082_new_n4426
* NET  7226 = abc_30082_new_n4425
* NET  7227 = abc_30082_new_n4424
* NET  7228 = abc_30082_new_n4423
* NET  7229 = abc_30082_new_n4422
* NET  7230 = abc_30082_new_n4421
* NET  7231 = abc_30082_new_n4420
* NET  7232 = abc_30082_new_n4418
* NET  7233 = abc_30082_new_n4417
* NET  7234 = abc_30082_new_n4416
* NET  7235 = abc_30082_new_n4415
* NET  7236 = abc_30082_new_n4414
* NET  7237 = abc_30082_new_n4413
* NET  7238 = abc_30082_new_n4412
* NET  7239 = abc_30082_new_n4411
* NET  7240 = abc_30082_new_n4410
* NET  7241 = abc_30082_new_n4409
* NET  7242 = abc_30082_new_n4408
* NET  7243 = abc_30082_new_n4407
* NET  7244 = abc_30082_new_n4406
* NET  7245 = abc_30082_new_n4405
* NET  7246 = abc_30082_new_n4404
* NET  7247 = abc_30082_new_n4403
* NET  7248 = abc_30082_new_n4402
* NET  7249 = abc_30082_new_n4401
* NET  7250 = abc_30082_new_n4399
* NET  7251 = abc_30082_new_n4398
* NET  7252 = abc_30082_new_n4397
* NET  7253 = abc_30082_new_n4396
* NET  7254 = abc_30082_new_n4395
* NET  7255 = abc_30082_new_n4394
* NET  7256 = abc_30082_new_n4393
* NET  7257 = abc_30082_new_n4392
* NET  7258 = abc_30082_new_n4391
* NET  7259 = abc_30082_new_n4390
* NET  7260 = abc_30082_new_n4389
* NET  7261 = abc_30082_new_n4388
* NET  7262 = abc_30082_new_n4387
* NET  7263 = abc_30082_new_n4386
* NET  7264 = abc_30082_new_n4385
* NET  7265 = abc_30082_new_n4384
* NET  7266 = abc_30082_new_n4383
* NET  7267 = abc_30082_new_n4382
* NET  7268 = abc_30082_new_n4380
* NET  7269 = abc_30082_new_n4379
* NET  7270 = abc_30082_new_n4378
* NET  7271 = abc_30082_new_n4377
* NET  7272 = abc_30082_new_n4376
* NET  7273 = abc_30082_new_n4375
* NET  7274 = abc_30082_new_n4374
* NET  7275 = abc_30082_new_n4373
* NET  7276 = abc_30082_new_n4372
* NET  7277 = abc_30082_new_n4371
* NET  7278 = abc_30082_new_n4370
* NET  7279 = abc_30082_new_n4369
* NET  7280 = abc_30082_new_n4368
* NET  7281 = abc_30082_new_n4367
* NET  7282 = abc_30082_new_n4366
* NET  7283 = abc_30082_new_n4365
* NET  7284 = abc_30082_new_n4364
* NET  7285 = abc_30082_new_n4363
* NET  7286 = abc_30082_new_n4361
* NET  7287 = abc_30082_new_n4360
* NET  7288 = abc_30082_new_n4359
* NET  7289 = abc_30082_new_n4358
* NET  7290 = abc_30082_new_n4357
* NET  7291 = abc_30082_new_n4356
* NET  7292 = abc_30082_new_n4355
* NET  7293 = abc_30082_new_n4354
* NET  7294 = abc_30082_new_n4353
* NET  7295 = abc_30082_new_n4352
* NET  7296 = abc_30082_new_n4351
* NET  7297 = abc_30082_new_n4350
* NET  7298 = abc_30082_new_n4349
* NET  7299 = abc_30082_new_n4348
* NET  7300 = abc_30082_new_n4347
* NET  7301 = abc_30082_new_n4346
* NET  7302 = abc_30082_new_n4345
* NET  7303 = abc_30082_new_n4344
* NET  7304 = abc_30082_new_n4342
* NET  7305 = abc_30082_new_n4341
* NET  7306 = abc_30082_new_n4340
* NET  7307 = abc_30082_new_n4339
* NET  7308 = abc_30082_new_n4338
* NET  7309 = abc_30082_new_n4337
* NET  7310 = abc_30082_new_n4336
* NET  7311 = abc_30082_new_n4335
* NET  7312 = abc_30082_new_n4334
* NET  7313 = abc_30082_new_n4333
* NET  7314 = abc_30082_new_n4332
* NET  7315 = abc_30082_new_n4331
* NET  7316 = abc_30082_new_n4330
* NET  7317 = abc_30082_new_n4329
* NET  7318 = abc_30082_new_n4328
* NET  7319 = abc_30082_new_n4327
* NET  7320 = abc_30082_new_n4326
* NET  7321 = abc_30082_new_n4325
* NET  7322 = abc_30082_new_n4323
* NET  7323 = abc_30082_new_n4322
* NET  7324 = abc_30082_new_n4321
* NET  7325 = abc_30082_new_n4320
* NET  7326 = abc_30082_new_n4319
* NET  7327 = abc_30082_new_n4318
* NET  7328 = abc_30082_new_n4317
* NET  7329 = abc_30082_new_n4316
* NET  7330 = abc_30082_new_n4315
* NET  7331 = abc_30082_new_n4314
* NET  7332 = abc_30082_new_n4313
* NET  7333 = abc_30082_new_n4312
* NET  7334 = abc_30082_new_n4311
* NET  7335 = abc_30082_new_n4310
* NET  7336 = abc_30082_new_n4309
* NET  7337 = abc_30082_new_n4308
* NET  7338 = abc_30082_new_n4307
* NET  7339 = abc_30082_new_n4306
* NET  7340 = abc_30082_new_n4304
* NET  7341 = abc_30082_new_n4303
* NET  7342 = abc_30082_new_n4302
* NET  7343 = abc_30082_new_n4301
* NET  7344 = abc_30082_new_n4300
* NET  7345 = abc_30082_new_n4299
* NET  7346 = abc_30082_new_n4298
* NET  7347 = abc_30082_new_n4297
* NET  7348 = abc_30082_new_n4296
* NET  7349 = abc_30082_new_n4295
* NET  7350 = abc_30082_new_n4294
* NET  7351 = abc_30082_new_n4293
* NET  7352 = abc_30082_new_n4292
* NET  7353 = abc_30082_new_n4291
* NET  7354 = abc_30082_new_n4290
* NET  7355 = abc_30082_new_n4289
* NET  7356 = abc_30082_new_n4288
* NET  7357 = abc_30082_new_n4287
* NET  7358 = abc_30082_new_n4285
* NET  7359 = abc_30082_new_n4284
* NET  7360 = abc_30082_new_n4283
* NET  7361 = abc_30082_new_n4282
* NET  7362 = abc_30082_new_n4281
* NET  7363 = abc_30082_new_n4280
* NET  7364 = abc_30082_new_n4279
* NET  7365 = abc_30082_new_n4278
* NET  7366 = abc_30082_new_n4277
* NET  7367 = abc_30082_new_n4276
* NET  7368 = abc_30082_new_n4275
* NET  7369 = abc_30082_new_n4274
* NET  7370 = abc_30082_new_n4273
* NET  7371 = abc_30082_new_n4272
* NET  7372 = abc_30082_new_n4271
* NET  7373 = abc_30082_new_n4270
* NET  7374 = abc_30082_new_n4269
* NET  7375 = abc_30082_new_n4268
* NET  7376 = abc_30082_new_n4266
* NET  7377 = abc_30082_new_n4265
* NET  7378 = abc_30082_new_n4264
* NET  7379 = abc_30082_new_n4263
* NET  7380 = abc_30082_new_n4262
* NET  7381 = abc_30082_new_n4261
* NET  7382 = abc_30082_new_n4260
* NET  7383 = abc_30082_new_n4259
* NET  7384 = abc_30082_new_n4258
* NET  7385 = abc_30082_new_n4257
* NET  7386 = abc_30082_new_n4256
* NET  7387 = abc_30082_new_n4255
* NET  7388 = abc_30082_new_n4254
* NET  7389 = abc_30082_new_n4253
* NET  7390 = abc_30082_new_n4252
* NET  7391 = abc_30082_new_n4251
* NET  7392 = abc_30082_new_n4250
* NET  7393 = abc_30082_new_n4249
* NET  7394 = abc_30082_new_n4247
* NET  7395 = abc_30082_new_n4246
* NET  7396 = abc_30082_new_n4245
* NET  7397 = abc_30082_new_n4244
* NET  7398 = abc_30082_new_n4243
* NET  7399 = abc_30082_new_n4242
* NET  7400 = abc_30082_new_n4241
* NET  7401 = abc_30082_new_n4240
* NET  7402 = abc_30082_new_n4239
* NET  7403 = abc_30082_new_n4238
* NET  7404 = abc_30082_new_n4237
* NET  7405 = abc_30082_new_n4236
* NET  7406 = abc_30082_new_n4235
* NET  7407 = abc_30082_new_n4234
* NET  7408 = abc_30082_new_n4233
* NET  7409 = abc_30082_new_n4232
* NET  7410 = abc_30082_new_n4231
* NET  7411 = abc_30082_new_n4230
* NET  7412 = abc_30082_new_n4228
* NET  7413 = abc_30082_new_n4227
* NET  7414 = abc_30082_new_n4226
* NET  7415 = abc_30082_new_n4225
* NET  7416 = abc_30082_new_n4224
* NET  7417 = abc_30082_new_n4223
* NET  7418 = abc_30082_new_n4222
* NET  7419 = abc_30082_new_n4221
* NET  7420 = abc_30082_new_n4220
* NET  7421 = abc_30082_new_n4219
* NET  7422 = abc_30082_new_n4218
* NET  7423 = abc_30082_new_n4217
* NET  7424 = abc_30082_new_n4216
* NET  7425 = abc_30082_new_n4215
* NET  7426 = abc_30082_new_n4214
* NET  7427 = abc_30082_new_n4213
* NET  7428 = abc_30082_new_n4212
* NET  7429 = abc_30082_new_n4211
* NET  7430 = abc_30082_new_n4209
* NET  7431 = abc_30082_new_n4208
* NET  7432 = abc_30082_new_n4207
* NET  7433 = abc_30082_new_n4206
* NET  7434 = abc_30082_new_n4205
* NET  7435 = abc_30082_new_n4204
* NET  7436 = abc_30082_new_n4203
* NET  7437 = abc_30082_new_n4202
* NET  7438 = abc_30082_new_n4201
* NET  7439 = abc_30082_new_n4200
* NET  7440 = abc_30082_new_n4199
* NET  7441 = abc_30082_new_n4198
* NET  7442 = abc_30082_new_n4197
* NET  7443 = abc_30082_new_n4196
* NET  7444 = abc_30082_new_n4195
* NET  7445 = abc_30082_new_n4194
* NET  7446 = abc_30082_new_n4193
* NET  7447 = abc_30082_new_n4192
* NET  7448 = abc_30082_new_n4190
* NET  7449 = abc_30082_new_n4189
* NET  7450 = abc_30082_new_n4188
* NET  7451 = abc_30082_new_n4187
* NET  7452 = abc_30082_new_n4186
* NET  7453 = abc_30082_new_n4185
* NET  7454 = abc_30082_new_n4184
* NET  7455 = abc_30082_new_n4183
* NET  7456 = abc_30082_new_n4182
* NET  7457 = abc_30082_new_n4181
* NET  7458 = abc_30082_new_n4180
* NET  7459 = abc_30082_new_n4179
* NET  7460 = abc_30082_new_n4178
* NET  7461 = abc_30082_new_n4177
* NET  7462 = abc_30082_new_n4176
* NET  7463 = abc_30082_new_n4175
* NET  7464 = abc_30082_new_n4174
* NET  7465 = abc_30082_new_n4173
* NET  7466 = abc_30082_new_n4171
* NET  7467 = abc_30082_new_n4170
* NET  7468 = abc_30082_new_n4169
* NET  7469 = abc_30082_new_n4168
* NET  7470 = abc_30082_new_n4167
* NET  7471 = abc_30082_new_n4166
* NET  7472 = abc_30082_new_n4165
* NET  7473 = abc_30082_new_n4164
* NET  7474 = abc_30082_new_n4163
* NET  7475 = abc_30082_new_n4162
* NET  7476 = abc_30082_new_n4161
* NET  7477 = abc_30082_new_n4160
* NET  7478 = abc_30082_new_n4159
* NET  7479 = abc_30082_new_n4158
* NET  7480 = abc_30082_new_n4157
* NET  7481 = abc_30082_new_n4156
* NET  7482 = abc_30082_new_n4155
* NET  7483 = abc_30082_new_n4154
* NET  7484 = abc_30082_new_n4153
* NET  7485 = abc_30082_new_n4152
* NET  7486 = abc_30082_new_n4151
* NET  7487 = abc_30082_new_n4150
* NET  7488 = abc_30082_new_n4148
* NET  7489 = abc_30082_new_n4147
* NET  7490 = abc_30082_new_n4146
* NET  7491 = abc_30082_new_n4145
* NET  7492 = abc_30082_new_n4144
* NET  7493 = abc_30082_new_n4143
* NET  7494 = abc_30082_new_n4142
* NET  7495 = abc_30082_new_n4141
* NET  7496 = abc_30082_new_n4140
* NET  7497 = abc_30082_new_n4139
* NET  7498 = abc_30082_new_n4138
* NET  7499 = abc_30082_new_n4137
* NET  7500 = abc_30082_new_n4136
* NET  7501 = abc_30082_new_n4135
* NET  7502 = abc_30082_new_n4134
* NET  7503 = abc_30082_new_n4133
* NET  7504 = abc_30082_new_n4132
* NET  7505 = abc_30082_new_n4131
* NET  7506 = abc_30082_new_n4130
* NET  7507 = abc_30082_new_n4128
* NET  7508 = abc_30082_new_n4127
* NET  7509 = abc_30082_new_n4126
* NET  7510 = abc_30082_new_n4125
* NET  7511 = abc_30082_new_n4124
* NET  7512 = abc_30082_new_n4123
* NET  7513 = abc_30082_new_n4122
* NET  7514 = abc_30082_new_n4121
* NET  7515 = abc_30082_new_n4120
* NET  7516 = abc_30082_new_n4119
* NET  7517 = abc_30082_new_n4118
* NET  7518 = abc_30082_new_n4117
* NET  7519 = abc_30082_new_n4116
* NET  7520 = abc_30082_new_n4115
* NET  7521 = abc_30082_new_n4114
* NET  7522 = abc_30082_new_n4113
* NET  7523 = abc_30082_new_n4112
* NET  7524 = abc_30082_new_n4111
* NET  7525 = abc_30082_new_n4110
* NET  7526 = abc_30082_new_n4108
* NET  7527 = abc_30082_new_n4107
* NET  7528 = abc_30082_new_n4106
* NET  7529 = abc_30082_new_n4105
* NET  7530 = abc_30082_new_n4104
* NET  7531 = abc_30082_new_n4103
* NET  7532 = abc_30082_new_n4102
* NET  7533 = abc_30082_new_n4101
* NET  7534 = abc_30082_new_n4100
* NET  7535 = abc_30082_new_n4099
* NET  7536 = abc_30082_new_n4098
* NET  7537 = abc_30082_new_n4097
* NET  7538 = abc_30082_new_n4096
* NET  7539 = abc_30082_new_n4095
* NET  7540 = abc_30082_new_n4094
* NET  7541 = abc_30082_new_n4093
* NET  7542 = abc_30082_new_n4092
* NET  7543 = abc_30082_new_n4091
* NET  7544 = abc_30082_new_n4090
* NET  7545 = abc_30082_new_n4088
* NET  7546 = abc_30082_new_n4087
* NET  7547 = abc_30082_new_n4086
* NET  7548 = abc_30082_new_n4085
* NET  7549 = abc_30082_new_n4084
* NET  7550 = abc_30082_new_n4083
* NET  7551 = abc_30082_new_n4082
* NET  7552 = abc_30082_new_n4081
* NET  7553 = abc_30082_new_n4080
* NET  7554 = abc_30082_new_n4079
* NET  7555 = abc_30082_new_n4078
* NET  7556 = abc_30082_new_n4077
* NET  7557 = abc_30082_new_n4076
* NET  7558 = abc_30082_new_n4075
* NET  7559 = abc_30082_new_n4074
* NET  7560 = abc_30082_new_n4073
* NET  7561 = abc_30082_new_n4072
* NET  7562 = abc_30082_new_n4071
* NET  7563 = abc_30082_new_n4070
* NET  7564 = abc_30082_new_n4068
* NET  7565 = abc_30082_new_n4067
* NET  7566 = abc_30082_new_n4066
* NET  7567 = abc_30082_new_n4065
* NET  7568 = abc_30082_new_n4064
* NET  7569 = abc_30082_new_n4063
* NET  7570 = abc_30082_new_n4062
* NET  7571 = abc_30082_new_n4061
* NET  7572 = abc_30082_new_n4060
* NET  7573 = abc_30082_new_n4059
* NET  7574 = abc_30082_new_n4058
* NET  7575 = abc_30082_new_n4057
* NET  7576 = abc_30082_new_n4056
* NET  7577 = abc_30082_new_n4055
* NET  7578 = abc_30082_new_n4054
* NET  7579 = abc_30082_new_n4053
* NET  7580 = abc_30082_new_n4052
* NET  7581 = abc_30082_new_n4051
* NET  7582 = abc_30082_new_n4050
* NET  7583 = abc_30082_new_n4048
* NET  7584 = abc_30082_new_n4047
* NET  7585 = abc_30082_new_n4046
* NET  7586 = abc_30082_new_n4045
* NET  7587 = abc_30082_new_n4044
* NET  7588 = abc_30082_new_n4043
* NET  7589 = abc_30082_new_n4042
* NET  7590 = abc_30082_new_n4041
* NET  7591 = abc_30082_new_n4040
* NET  7592 = abc_30082_new_n4039
* NET  7593 = abc_30082_new_n4038
* NET  7594 = abc_30082_new_n4037
* NET  7595 = abc_30082_new_n4036
* NET  7596 = abc_30082_new_n4035
* NET  7597 = abc_30082_new_n4034
* NET  7598 = abc_30082_new_n4033
* NET  7599 = abc_30082_new_n4032
* NET  7600 = abc_30082_new_n4031
* NET  7601 = abc_30082_new_n4030
* NET  7602 = abc_30082_new_n4028
* NET  7603 = abc_30082_new_n4027
* NET  7604 = abc_30082_new_n4026
* NET  7605 = abc_30082_new_n4025
* NET  7606 = abc_30082_new_n4024
* NET  7607 = abc_30082_new_n4023
* NET  7608 = abc_30082_new_n4022
* NET  7609 = abc_30082_new_n4021
* NET  7610 = abc_30082_new_n4020
* NET  7611 = abc_30082_new_n4019
* NET  7612 = abc_30082_new_n4018_hfns_2
* NET  7613 = abc_30082_new_n4018_hfns_1
* NET  7614 = abc_30082_new_n4018_hfns_0
* NET  7615 = abc_30082_new_n4018
* NET  7616 = abc_30082_new_n4017
* NET  7617 = abc_30082_new_n4016
* NET  7618 = abc_30082_new_n4015
* NET  7619 = abc_30082_new_n4014
* NET  7620 = abc_30082_new_n4013
* NET  7621 = abc_30082_new_n4012
* NET  7622 = abc_30082_new_n4011
* NET  7623 = abc_30082_new_n4010
* NET  7624 = abc_30082_new_n4009
* NET  7625 = abc_30082_new_n4008
* NET  7626 = abc_30082_new_n4007
* NET  7627 = abc_30082_new_n4005
* NET  7628 = abc_30082_new_n4004
* NET  7629 = abc_30082_new_n4003
* NET  7630 = abc_30082_new_n4002
* NET  7631 = abc_30082_new_n4001
* NET  7632 = abc_30082_new_n4000
* NET  7633 = abc_30082_new_n3999
* NET  7634 = abc_30082_new_n3998
* NET  7635 = abc_30082_new_n3997
* NET  7636 = abc_30082_new_n3996
* NET  7637 = abc_30082_new_n3995
* NET  7638 = abc_30082_new_n3994
* NET  7639 = abc_30082_new_n3993
* NET  7640 = abc_30082_new_n3992
* NET  7641 = abc_30082_new_n3991
* NET  7642 = abc_30082_new_n3990
* NET  7643 = abc_30082_new_n3989
* NET  7644 = abc_30082_new_n3988
* NET  7645 = abc_30082_new_n3987
* NET  7646 = abc_30082_new_n3986
* NET  7647 = abc_30082_new_n3984
* NET  7648 = abc_30082_new_n3983
* NET  7649 = abc_30082_new_n3982
* NET  7650 = abc_30082_new_n3981
* NET  7651 = abc_30082_new_n3980
* NET  7652 = abc_30082_new_n3979
* NET  7653 = abc_30082_new_n3978
* NET  7654 = abc_30082_new_n3977
* NET  7655 = abc_30082_new_n3976
* NET  7656 = abc_30082_new_n3975
* NET  7657 = abc_30082_new_n3974
* NET  7658 = abc_30082_new_n3973
* NET  7659 = abc_30082_new_n3972
* NET  7660 = abc_30082_new_n3971
* NET  7661 = abc_30082_new_n3970
* NET  7662 = abc_30082_new_n3969
* NET  7663 = abc_30082_new_n3968
* NET  7664 = abc_30082_new_n3967
* NET  7665 = abc_30082_new_n3966
* NET  7666 = abc_30082_new_n3965
* NET  7667 = abc_30082_new_n3964
* NET  7668 = abc_30082_new_n3963
* NET  7669 = abc_30082_new_n3962
* NET  7670 = abc_30082_new_n3960
* NET  7671 = abc_30082_new_n3959
* NET  7672 = abc_30082_new_n3958
* NET  7673 = abc_30082_new_n3957
* NET  7674 = abc_30082_new_n3956
* NET  7675 = abc_30082_new_n3955
* NET  7676 = abc_30082_new_n3954
* NET  7677 = abc_30082_new_n3953
* NET  7678 = abc_30082_new_n3952
* NET  7679 = abc_30082_new_n3951
* NET  7680 = abc_30082_new_n3950
* NET  7681 = abc_30082_new_n3949
* NET  7682 = abc_30082_new_n3948
* NET  7683 = abc_30082_new_n3947
* NET  7684 = abc_30082_new_n3946
* NET  7685 = abc_30082_new_n3945
* NET  7686 = abc_30082_new_n3944
* NET  7687 = abc_30082_new_n3943
* NET  7688 = abc_30082_new_n3942
* NET  7689 = abc_30082_new_n3941
* NET  7690 = abc_30082_new_n3940
* NET  7691 = abc_30082_new_n3939
* NET  7692 = abc_30082_new_n3938
* NET  7693 = abc_30082_new_n3936
* NET  7694 = abc_30082_new_n3935
* NET  7695 = abc_30082_new_n3934
* NET  7696 = abc_30082_new_n3933
* NET  7697 = abc_30082_new_n3932
* NET  7698 = abc_30082_new_n3931
* NET  7699 = abc_30082_new_n3930
* NET  7700 = abc_30082_new_n3929
* NET  7701 = abc_30082_new_n3928
* NET  7702 = abc_30082_new_n3927
* NET  7703 = abc_30082_new_n3926
* NET  7704 = abc_30082_new_n3925
* NET  7705 = abc_30082_new_n3924
* NET  7706 = abc_30082_new_n3923
* NET  7707 = abc_30082_new_n3922
* NET  7708 = abc_30082_new_n3921
* NET  7709 = abc_30082_new_n3920
* NET  7710 = abc_30082_new_n3919
* NET  7711 = abc_30082_new_n3918
* NET  7712 = abc_30082_new_n3917
* NET  7713 = abc_30082_new_n3916
* NET  7714 = abc_30082_new_n3915
* NET  7715 = abc_30082_new_n3913
* NET  7716 = abc_30082_new_n3912
* NET  7717 = abc_30082_new_n3911
* NET  7718 = abc_30082_new_n3910
* NET  7719 = abc_30082_new_n3909
* NET  7720 = abc_30082_new_n3908
* NET  7721 = abc_30082_new_n3907
* NET  7722 = abc_30082_new_n3906
* NET  7723 = abc_30082_new_n3905
* NET  7724 = abc_30082_new_n3904
* NET  7725 = abc_30082_new_n3903
* NET  7726 = abc_30082_new_n3902
* NET  7727 = abc_30082_new_n3901
* NET  7728 = abc_30082_new_n3900
* NET  7729 = abc_30082_new_n3899
* NET  7730 = abc_30082_new_n3898
* NET  7731 = abc_30082_new_n3897
* NET  7732 = abc_30082_new_n3896
* NET  7733 = abc_30082_new_n3895
* NET  7734 = abc_30082_new_n3894
* NET  7735 = abc_30082_new_n3893
* NET  7736 = abc_30082_new_n3892
* NET  7737 = abc_30082_new_n3891
* NET  7738 = abc_30082_new_n3890
* NET  7739 = abc_30082_new_n3888
* NET  7740 = abc_30082_new_n3887
* NET  7741 = abc_30082_new_n3886
* NET  7742 = abc_30082_new_n3885
* NET  7743 = abc_30082_new_n3884
* NET  7744 = abc_30082_new_n3883
* NET  7745 = abc_30082_new_n3882
* NET  7746 = abc_30082_new_n3881
* NET  7747 = abc_30082_new_n3880
* NET  7748 = abc_30082_new_n3879
* NET  7749 = abc_30082_new_n3878
* NET  7750 = abc_30082_new_n3877
* NET  7751 = abc_30082_new_n3876
* NET  7752 = abc_30082_new_n3875
* NET  7753 = abc_30082_new_n3874
* NET  7754 = abc_30082_new_n3873
* NET  7755 = abc_30082_new_n3872
* NET  7756 = abc_30082_new_n3871
* NET  7757 = abc_30082_new_n3870
* NET  7758 = abc_30082_new_n3869
* NET  7759 = abc_30082_new_n3868
* NET  7760 = abc_30082_new_n3867
* NET  7761 = abc_30082_new_n3866
* NET  7762 = abc_30082_new_n3864
* NET  7763 = abc_30082_new_n3863
* NET  7764 = abc_30082_new_n3862
* NET  7765 = abc_30082_new_n3861
* NET  7766 = abc_30082_new_n3860
* NET  7767 = abc_30082_new_n3859
* NET  7768 = abc_30082_new_n3858
* NET  7769 = abc_30082_new_n3857
* NET  7770 = abc_30082_new_n3856
* NET  7771 = abc_30082_new_n3855
* NET  7772 = abc_30082_new_n3854
* NET  7773 = abc_30082_new_n3853
* NET  7774 = abc_30082_new_n3852
* NET  7775 = abc_30082_new_n3851
* NET  7776 = abc_30082_new_n3850
* NET  7777 = abc_30082_new_n3849
* NET  7778 = abc_30082_new_n3848
* NET  7779 = abc_30082_new_n3847
* NET  7780 = abc_30082_new_n3846
* NET  7781 = abc_30082_new_n3844
* NET  7782 = abc_30082_new_n3843
* NET  7783 = abc_30082_new_n3842
* NET  7784 = abc_30082_new_n3841
* NET  7785 = abc_30082_new_n3840
* NET  7786 = abc_30082_new_n3839
* NET  7787 = abc_30082_new_n3838
* NET  7788 = abc_30082_new_n3837
* NET  7789 = abc_30082_new_n3836
* NET  7790 = abc_30082_new_n3835
* NET  7791 = abc_30082_new_n3834_hfns_2
* NET  7792 = abc_30082_new_n3834_hfns_1
* NET  7793 = abc_30082_new_n3834_hfns_0
* NET  7794 = abc_30082_new_n3834
* NET  7795 = abc_30082_new_n3833
* NET  7796 = abc_30082_new_n3832
* NET  7797 = abc_30082_new_n3831
* NET  7798 = abc_30082_new_n3830
* NET  7799 = abc_30082_new_n3829
* NET  7800 = abc_30082_new_n3828
* NET  7801 = abc_30082_new_n3827
* NET  7802 = abc_30082_new_n3826
* NET  7803 = abc_30082_new_n3825
* NET  7804 = abc_30082_new_n3824
* NET  7805 = abc_30082_new_n3823
* NET  7806 = abc_30082_new_n3821
* NET  7807 = abc_30082_new_n3820
* NET  7808 = abc_30082_new_n3819_hfns_2
* NET  7809 = abc_30082_new_n3819_hfns_1
* NET  7810 = abc_30082_new_n3819_hfns_0
* NET  7811 = abc_30082_new_n3819
* NET  7812 = abc_30082_new_n3817
* NET  7813 = abc_30082_new_n3816
* NET  7814 = abc_30082_new_n3814
* NET  7815 = abc_30082_new_n3813
* NET  7816 = abc_30082_new_n3812
* NET  7817 = abc_30082_new_n3810
* NET  7818 = abc_30082_new_n3809
* NET  7819 = abc_30082_new_n3808
* NET  7820 = abc_30082_new_n3807
* NET  7821 = abc_30082_new_n3806
* NET  7822 = abc_30082_new_n3805
* NET  7823 = abc_30082_new_n3804
* NET  7824 = abc_30082_new_n3803
* NET  7825 = abc_30082_new_n3801
* NET  7826 = abc_30082_new_n3800
* NET  7827 = abc_30082_new_n3799
* NET  7828 = abc_30082_new_n3798
* NET  7829 = abc_30082_new_n3796
* NET  7830 = abc_30082_new_n3795
* NET  7831 = abc_30082_new_n3794
* NET  7832 = abc_30082_new_n3793
* NET  7833 = abc_30082_new_n3792
* NET  7834 = abc_30082_new_n3791
* NET  7835 = abc_30082_new_n3790
* NET  7836 = abc_30082_new_n3789
* NET  7837 = abc_30082_new_n3788
* NET  7838 = abc_30082_new_n3787
* NET  7839 = abc_30082_new_n3786
* NET  7840 = abc_30082_new_n3785
* NET  7841 = abc_30082_new_n3784
* NET  7842 = abc_30082_new_n3783
* NET  7843 = abc_30082_new_n3781
* NET  7844 = abc_30082_new_n3780
* NET  7845 = abc_30082_new_n3779
* NET  7846 = abc_30082_new_n3777
* NET  7847 = abc_30082_new_n3776
* NET  7848 = abc_30082_new_n3775
* NET  7849 = abc_30082_new_n3774
* NET  7850 = abc_30082_new_n3773
* NET  7851 = abc_30082_new_n3772
* NET  7852 = abc_30082_new_n3771
* NET  7853 = abc_30082_new_n3770
* NET  7854 = abc_30082_new_n3769
* NET  7855 = abc_30082_new_n3768_hfns_2
* NET  7856 = abc_30082_new_n3768_hfns_1
* NET  7857 = abc_30082_new_n3768_hfns_0
* NET  7858 = abc_30082_new_n3768
* NET  7859 = abc_30082_new_n3767
* NET  7860 = abc_30082_new_n3766
* NET  7861 = abc_30082_new_n3765
* NET  7862 = abc_30082_new_n3764
* NET  7863 = abc_30082_new_n3763
* NET  7864 = abc_30082_new_n3762
* NET  7865 = abc_30082_new_n3761
* NET  7866 = abc_30082_new_n3760
* NET  7867 = abc_30082_new_n3759
* NET  7868 = abc_30082_new_n3758
* NET  7869 = abc_30082_new_n3756
* NET  7870 = abc_30082_new_n3755
* NET  7871 = abc_30082_new_n3750
* NET  7872 = abc_30082_new_n3749
* NET  7873 = abc_30082_new_n3748
* NET  7874 = abc_30082_new_n3747
* NET  7875 = abc_30082_new_n3745
* NET  7876 = abc_30082_new_n3744
* NET  7877 = abc_30082_new_n3743
* NET  7878 = abc_30082_new_n3742
* NET  7879 = abc_30082_new_n3741_hfns_2
* NET  7880 = abc_30082_new_n3741_hfns_1
* NET  7881 = abc_30082_new_n3741_hfns_0
* NET  7882 = abc_30082_new_n3741
* NET  7883 = abc_30082_new_n3740_hfns_3
* NET  7884 = abc_30082_new_n3740_hfns_2
* NET  7885 = abc_30082_new_n3740_hfns_1
* NET  7886 = abc_30082_new_n3740_hfns_0
* NET  7887 = abc_30082_new_n3740
* NET  7888 = abc_30082_new_n3739
* NET  7889 = abc_30082_new_n3738
* NET  7890 = abc_30082_new_n3737
* NET  7891 = abc_30082_new_n3736
* NET  7892 = abc_30082_new_n3735
* NET  7893 = abc_30082_new_n3734
* NET  7894 = abc_30082_new_n3733
* NET  7895 = abc_30082_new_n3732
* NET  7896 = abc_30082_new_n3731
* NET  7897 = abc_30082_new_n3730
* NET  7898 = abc_30082_new_n3729
* NET  7899 = abc_30082_new_n3728
* NET  7900 = abc_30082_new_n3727
* NET  7901 = abc_30082_new_n3726
* NET  7902 = abc_30082_new_n3725
* NET  7903 = abc_30082_new_n3724_hfns_2
* NET  7904 = abc_30082_new_n3724_hfns_1
* NET  7905 = abc_30082_new_n3724_hfns_0
* NET  7906 = abc_30082_new_n3724
* NET  7907 = abc_30082_new_n3723
* NET  7908 = abc_30082_new_n3722
* NET  7909 = abc_30082_new_n3721
* NET  7910 = abc_30082_new_n3720
* NET  7911 = abc_30082_new_n3719
* NET  7912 = abc_30082_new_n3718
* NET  7913 = abc_30082_new_n3717
* NET  7914 = abc_30082_new_n3716
* NET  7915 = abc_30082_new_n3715
* NET  7916 = abc_30082_new_n3714_hfns_2
* NET  7917 = abc_30082_new_n3714_hfns_1
* NET  7918 = abc_30082_new_n3714_hfns_0
* NET  7919 = abc_30082_new_n3714
* NET  7920 = abc_30082_new_n3713
* NET  7921 = abc_30082_new_n3712
* NET  7922 = abc_30082_new_n3711
* NET  7923 = abc_30082_new_n3710
* NET  7924 = abc_30082_new_n3709
* NET  7925 = abc_30082_new_n3708
* NET  7926 = abc_30082_new_n3706
* NET  7927 = abc_30082_new_n3704
* NET  7928 = abc_30082_new_n3703
* NET  7929 = abc_30082_new_n3702_hfns_2
* NET  7930 = abc_30082_new_n3702_hfns_1
* NET  7931 = abc_30082_new_n3702_hfns_0
* NET  7932 = abc_30082_new_n3702
* NET  7933 = abc_30082_new_n3701
* NET  7934 = abc_30082_new_n3700
* NET  7935 = abc_30082_new_n3699
* NET  7936 = abc_30082_new_n3698
* NET  7937 = abc_30082_new_n3697
* NET  7938 = abc_30082_new_n3696
* NET  7939 = abc_30082_new_n3695
* NET  7940 = abc_30082_new_n3694
* NET  7941 = abc_30082_new_n3693
* NET  7942 = abc_30082_new_n3692
* NET  7943 = abc_30082_new_n3691
* NET  7944 = abc_30082_new_n3690
* NET  7945 = abc_30082_new_n3689
* NET  7946 = abc_30082_new_n3688
* NET  7947 = abc_30082_new_n3687
* NET  7948 = abc_30082_new_n3686
* NET  7949 = abc_30082_new_n3685
* NET  7950 = abc_30082_new_n3684
* NET  7951 = abc_30082_new_n3683
* NET  7952 = abc_30082_new_n3682
* NET  7953 = abc_30082_new_n3681
* NET  7954 = abc_30082_new_n3680
* NET  7955 = abc_30082_new_n3679
* NET  7956 = abc_30082_new_n3678
* NET  7957 = abc_30082_new_n3677
* NET  7958 = abc_30082_new_n3676
* NET  7959 = abc_30082_new_n3675
* NET  7960 = abc_30082_new_n3674
* NET  7961 = abc_30082_new_n3673
* NET  7962 = abc_30082_new_n3672
* NET  7963 = abc_30082_new_n3671
* NET  7964 = abc_30082_new_n3670
* NET  7965 = abc_30082_new_n3669
* NET  7966 = abc_30082_new_n3668
* NET  7967 = abc_30082_new_n3667
* NET  7968 = abc_30082_new_n3666
* NET  7969 = abc_30082_new_n3665
* NET  7970 = abc_30082_new_n3664_hfns_2
* NET  7971 = abc_30082_new_n3664_hfns_1
* NET  7972 = abc_30082_new_n3664_hfns_0
* NET  7973 = abc_30082_new_n3664
* NET  7974 = abc_30082_new_n3663
* NET  7975 = abc_30082_new_n3662
* NET  7976 = abc_30082_new_n3661
* NET  7977 = abc_30082_new_n3660
* NET  7978 = abc_30082_new_n3659
* NET  7979 = abc_30082_new_n3658
* NET  7980 = abc_30082_new_n3657
* NET  7981 = abc_30082_new_n3656
* NET  7982 = abc_30082_new_n3655
* NET  7983 = abc_30082_new_n3654
* NET  7984 = abc_30082_new_n3653
* NET  7985 = abc_30082_new_n3652
* NET  7986 = abc_30082_new_n3651
* NET  7987 = abc_30082_new_n3650
* NET  7988 = abc_30082_new_n3649
* NET  7989 = abc_30082_new_n3648_hfns_2
* NET  7990 = abc_30082_new_n3648_hfns_1
* NET  7991 = abc_30082_new_n3648_hfns_0
* NET  7992 = abc_30082_new_n3648
* NET  7993 = abc_30082_new_n3646
* NET  7994 = abc_30082_new_n3644
* NET  7995 = abc_30082_new_n3643
* NET  7996 = abc_30082_new_n3642
* NET  7997 = abc_30082_new_n3641
* NET  7998 = abc_30082_new_n3640
* NET  7999 = abc_30082_new_n3639
* NET  8000 = abc_30082_new_n3638_hfns_2
* NET  8001 = abc_30082_new_n3638_hfns_1
* NET  8002 = abc_30082_new_n3638_hfns_0
* NET  8003 = abc_30082_new_n3638
* NET  8004 = abc_30082_new_n3637
* NET  8005 = abc_30082_new_n3636
* NET  8006 = abc_30082_new_n3635
* NET  8007 = abc_30082_new_n3634
* NET  8008 = abc_30082_new_n3633
* NET  8009 = abc_30082_new_n3632
* NET  8010 = abc_30082_new_n3631_hfns_3
* NET  8011 = abc_30082_new_n3631_hfns_2
* NET  8012 = abc_30082_new_n3631_hfns_1
* NET  8013 = abc_30082_new_n3631_hfns_0
* NET  8014 = abc_30082_new_n3631
* NET  8015 = abc_30082_new_n3630_hfns_2
* NET  8016 = abc_30082_new_n3630_hfns_1
* NET  8017 = abc_30082_new_n3630_hfns_0
* NET  8018 = abc_30082_new_n3630
* NET  8019 = abc_30082_new_n3629_hfns_6
* NET  8020 = abc_30082_new_n3629_hfns_5
* NET  8021 = abc_30082_new_n3629_hfns_4
* NET  8022 = abc_30082_new_n3629_hfns_3
* NET  8023 = abc_30082_new_n3629_hfns_2
* NET  8024 = abc_30082_new_n3629_hfns_1
* NET  8025 = abc_30082_new_n3629_hfns_0
* NET  8026 = abc_30082_new_n3629
* NET  8027 = abc_30082_new_n3628_hfns_9
* NET  8028 = abc_30082_new_n3628_hfns_8
* NET  8029 = abc_30082_new_n3628_hfns_7
* NET  8030 = abc_30082_new_n3628_hfns_6
* NET  8031 = abc_30082_new_n3628_hfns_5
* NET  8032 = abc_30082_new_n3628_hfns_4
* NET  8033 = abc_30082_new_n3628_hfns_3
* NET  8034 = abc_30082_new_n3628_hfns_2
* NET  8035 = abc_30082_new_n3628_hfns_1
* NET  8036 = abc_30082_new_n3628_hfns_0
* NET  8037 = abc_30082_new_n3628
* NET  8038 = abc_30082_new_n3627
* NET  8039 = abc_30082_new_n3626
* NET  8040 = abc_30082_new_n3625
* NET  8041 = abc_30082_new_n3624
* NET  8042 = abc_30082_new_n3623
* NET  8043 = abc_30082_new_n3622
* NET  8044 = abc_30082_new_n3621
* NET  8045 = abc_30082_new_n3620
* NET  8046 = abc_30082_new_n3619
* NET  8047 = abc_30082_new_n3618
* NET  8048 = abc_30082_new_n3617
* NET  8049 = abc_30082_new_n3616
* NET  8050 = abc_30082_new_n3615
* NET  8051 = abc_30082_new_n3614
* NET  8052 = abc_30082_new_n3613
* NET  8053 = abc_30082_new_n3612
* NET  8054 = abc_30082_new_n3611
* NET  8055 = abc_30082_new_n3610
* NET  8056 = abc_30082_new_n3609
* NET  8057 = abc_30082_new_n3608
* NET  8058 = abc_30082_new_n3607
* NET  8059 = abc_30082_new_n3606
* NET  8060 = abc_30082_new_n3605
* NET  8061 = abc_30082_new_n3604
* NET  8062 = abc_30082_new_n3603
* NET  8063 = abc_30082_new_n3602
* NET  8064 = abc_30082_new_n3601
* NET  8065 = abc_30082_new_n3600
* NET  8066 = abc_30082_new_n3599
* NET  8067 = abc_30082_new_n3598
* NET  8068 = abc_30082_new_n3597
* NET  8069 = abc_30082_new_n3596
* NET  8070 = abc_30082_new_n3595
* NET  8071 = abc_30082_new_n3594
* NET  8072 = abc_30082_new_n3593
* NET  8073 = abc_30082_new_n3592
* NET  8074 = abc_30082_new_n3591
* NET  8075 = abc_30082_new_n3590
* NET  8076 = abc_30082_new_n3589
* NET  8077 = abc_30082_new_n3588
* NET  8078 = abc_30082_new_n3587
* NET  8079 = abc_30082_new_n3586
* NET  8080 = abc_30082_new_n3585
* NET  8081 = abc_30082_new_n3584
* NET  8082 = abc_30082_new_n3583
* NET  8083 = abc_30082_new_n3582
* NET  8084 = abc_30082_new_n3581
* NET  8085 = abc_30082_new_n3580
* NET  8086 = abc_30082_new_n3579
* NET  8087 = abc_30082_new_n3578
* NET  8088 = abc_30082_new_n3577
* NET  8089 = abc_30082_new_n3576
* NET  8090 = abc_30082_new_n3575
* NET  8091 = abc_30082_new_n3574
* NET  8092 = abc_30082_new_n3573
* NET  8093 = abc_30082_new_n3572
* NET  8094 = abc_30082_new_n3571
* NET  8095 = abc_30082_new_n3570
* NET  8096 = abc_30082_new_n3569
* NET  8097 = abc_30082_new_n3568
* NET  8098 = abc_30082_new_n3567
* NET  8099 = abc_30082_new_n3566
* NET  8100 = abc_30082_new_n3565
* NET  8101 = abc_30082_new_n3564
* NET  8102 = abc_30082_new_n3563
* NET  8103 = abc_30082_new_n3562
* NET  8104 = abc_30082_new_n3561
* NET  8105 = abc_30082_new_n3560
* NET  8106 = abc_30082_new_n3559
* NET  8107 = abc_30082_new_n3558
* NET  8108 = abc_30082_new_n3557
* NET  8109 = abc_30082_new_n3556
* NET  8110 = abc_30082_new_n3555
* NET  8111 = abc_30082_new_n3554
* NET  8112 = abc_30082_new_n3553
* NET  8113 = abc_30082_new_n3552
* NET  8114 = abc_30082_new_n3551
* NET  8115 = abc_30082_new_n3550
* NET  8116 = abc_30082_new_n3549
* NET  8117 = abc_30082_new_n3548
* NET  8118 = abc_30082_new_n3547
* NET  8119 = abc_30082_new_n3546
* NET  8120 = abc_30082_new_n3545
* NET  8121 = abc_30082_new_n3544
* NET  8122 = abc_30082_new_n3543
* NET  8123 = abc_30082_new_n3542
* NET  8124 = abc_30082_new_n3541
* NET  8125 = abc_30082_new_n3540
* NET  8126 = abc_30082_new_n3539
* NET  8127 = abc_30082_new_n3538
* NET  8128 = abc_30082_new_n3537
* NET  8129 = abc_30082_new_n3536
* NET  8130 = abc_30082_new_n3535
* NET  8131 = abc_30082_new_n3534
* NET  8132 = abc_30082_new_n3533
* NET  8133 = abc_30082_new_n3532
* NET  8134 = abc_30082_new_n3531
* NET  8135 = abc_30082_new_n3530
* NET  8136 = abc_30082_new_n3529
* NET  8137 = abc_30082_new_n3528
* NET  8138 = abc_30082_new_n3527
* NET  8139 = abc_30082_new_n3526
* NET  8140 = abc_30082_new_n3525
* NET  8141 = abc_30082_new_n3524
* NET  8142 = abc_30082_new_n3523
* NET  8143 = abc_30082_new_n3522
* NET  8144 = abc_30082_new_n3521
* NET  8145 = abc_30082_new_n3520
* NET  8146 = abc_30082_new_n3519
* NET  8147 = abc_30082_new_n3518
* NET  8148 = abc_30082_new_n3517
* NET  8149 = abc_30082_new_n3516
* NET  8150 = abc_30082_new_n3515
* NET  8151 = abc_30082_new_n3514
* NET  8152 = abc_30082_new_n3513
* NET  8153 = abc_30082_new_n3512
* NET  8154 = abc_30082_new_n3511
* NET  8155 = abc_30082_new_n3510
* NET  8156 = abc_30082_new_n3509
* NET  8157 = abc_30082_new_n3508
* NET  8158 = abc_30082_new_n3507
* NET  8159 = abc_30082_new_n3506
* NET  8160 = abc_30082_new_n3505
* NET  8161 = abc_30082_new_n3504
* NET  8162 = abc_30082_new_n3503
* NET  8163 = abc_30082_new_n3502
* NET  8164 = abc_30082_new_n3501
* NET  8165 = abc_30082_new_n3500
* NET  8166 = abc_30082_new_n3499
* NET  8167 = abc_30082_new_n3498
* NET  8168 = abc_30082_new_n3497
* NET  8169 = abc_30082_new_n3496
* NET  8170 = abc_30082_new_n3495
* NET  8171 = abc_30082_new_n3494
* NET  8172 = abc_30082_new_n3493
* NET  8173 = abc_30082_new_n3492
* NET  8174 = abc_30082_new_n3491
* NET  8175 = abc_30082_new_n3490
* NET  8176 = abc_30082_new_n3489
* NET  8177 = abc_30082_new_n3488
* NET  8178 = abc_30082_new_n3487
* NET  8179 = abc_30082_new_n3486
* NET  8180 = abc_30082_new_n3485
* NET  8181 = abc_30082_new_n3484
* NET  8182 = abc_30082_new_n3483
* NET  8183 = abc_30082_new_n3482
* NET  8184 = abc_30082_new_n3481
* NET  8185 = abc_30082_new_n3480
* NET  8186 = abc_30082_new_n3479
* NET  8187 = abc_30082_new_n3478
* NET  8188 = abc_30082_new_n3477
* NET  8189 = abc_30082_new_n3476
* NET  8190 = abc_30082_new_n3475
* NET  8191 = abc_30082_new_n3474
* NET  8192 = abc_30082_new_n3473
* NET  8193 = abc_30082_new_n3472
* NET  8194 = abc_30082_new_n3471
* NET  8195 = abc_30082_new_n3470
* NET  8196 = abc_30082_new_n3469
* NET  8197 = abc_30082_new_n3468
* NET  8198 = abc_30082_new_n3467
* NET  8199 = abc_30082_new_n3466
* NET  8200 = abc_30082_new_n3465
* NET  8201 = abc_30082_new_n3464
* NET  8202 = abc_30082_new_n3463
* NET  8203 = abc_30082_new_n3462
* NET  8204 = abc_30082_new_n3461
* NET  8205 = abc_30082_new_n3460_hfns_2
* NET  8206 = abc_30082_new_n3460_hfns_1
* NET  8207 = abc_30082_new_n3460_hfns_0
* NET  8208 = abc_30082_new_n3460
* NET  8209 = abc_30082_new_n3459_hfns_6
* NET  8210 = abc_30082_new_n3459_hfns_5
* NET  8211 = abc_30082_new_n3459_hfns_4
* NET  8212 = abc_30082_new_n3459_hfns_3
* NET  8213 = abc_30082_new_n3459_hfns_2
* NET  8214 = abc_30082_new_n3459_hfns_1
* NET  8215 = abc_30082_new_n3459_hfns_0
* NET  8216 = abc_30082_new_n3459
* NET  8217 = abc_30082_new_n3458_hfns_9
* NET  8218 = abc_30082_new_n3458_hfns_8
* NET  8219 = abc_30082_new_n3458_hfns_7
* NET  8220 = abc_30082_new_n3458_hfns_6
* NET  8221 = abc_30082_new_n3458_hfns_5
* NET  8222 = abc_30082_new_n3458_hfns_4
* NET  8223 = abc_30082_new_n3458_hfns_3
* NET  8224 = abc_30082_new_n3458_hfns_2
* NET  8225 = abc_30082_new_n3458_hfns_1
* NET  8226 = abc_30082_new_n3458_hfns_0
* NET  8227 = abc_30082_new_n3458
* NET  8228 = abc_30082_new_n3457
* NET  8229 = abc_30082_new_n3456
* NET  8230 = abc_30082_new_n3455
* NET  8231 = abc_30082_new_n3454
* NET  8232 = abc_30082_new_n3453
* NET  8233 = abc_30082_new_n3452
* NET  8234 = abc_30082_new_n3451
* NET  8235 = abc_30082_new_n3450
* NET  8236 = abc_30082_new_n3449
* NET  8237 = abc_30082_new_n3448
* NET  8238 = abc_30082_new_n3447
* NET  8239 = abc_30082_new_n3446
* NET  8240 = abc_30082_new_n3445
* NET  8241 = abc_30082_new_n3444
* NET  8242 = abc_30082_new_n3443
* NET  8243 = abc_30082_new_n3442_hfns_2
* NET  8244 = abc_30082_new_n3442_hfns_1
* NET  8245 = abc_30082_new_n3442_hfns_0
* NET  8246 = abc_30082_new_n3442
* NET  8247 = abc_30082_new_n3441
* NET  8248 = abc_30082_new_n3440
* NET  8249 = abc_30082_new_n3439
* NET  8250 = abc_30082_new_n3438
* NET  8251 = abc_30082_new_n3437
* NET  8252 = abc_30082_new_n3436
* NET  8253 = abc_30082_new_n3435
* NET  8254 = abc_30082_new_n3434
* NET  8255 = abc_30082_new_n3433
* NET  8256 = abc_30082_new_n3432
* NET  8257 = abc_30082_new_n3431
* NET  8258 = abc_30082_new_n3430
* NET  8259 = abc_30082_new_n3429
* NET  8260 = abc_30082_new_n3428
* NET  8261 = abc_30082_new_n3427
* NET  8262 = abc_30082_new_n3426
* NET  8263 = abc_30082_new_n3425
* NET  8264 = abc_30082_new_n3424
* NET  8265 = abc_30082_new_n3423
* NET  8266 = abc_30082_new_n3422
* NET  8267 = abc_30082_new_n3421
* NET  8268 = abc_30082_new_n3420
* NET  8269 = abc_30082_new_n3419
* NET  8270 = abc_30082_new_n3418
* NET  8271 = abc_30082_new_n3417
* NET  8272 = abc_30082_new_n3416
* NET  8273 = abc_30082_new_n3415
* NET  8274 = abc_30082_new_n3414
* NET  8275 = abc_30082_new_n3413_hfns_4
* NET  8276 = abc_30082_new_n3413_hfns_3
* NET  8277 = abc_30082_new_n3413_hfns_2
* NET  8278 = abc_30082_new_n3413_hfns_1
* NET  8279 = abc_30082_new_n3413_hfns_0
* NET  8280 = abc_30082_new_n3413
* NET  8281 = abc_30082_new_n3412
* NET  8282 = abc_30082_new_n3411
* NET  8283 = abc_30082_new_n3410
* NET  8284 = abc_30082_new_n3409
* NET  8285 = abc_30082_new_n3408
* NET  8286 = abc_30082_new_n3407
* NET  8287 = abc_30082_new_n3406
* NET  8288 = abc_30082_new_n3405_hfns_2
* NET  8289 = abc_30082_new_n3405_hfns_1
* NET  8290 = abc_30082_new_n3405_hfns_0
* NET  8291 = abc_30082_new_n3405
* NET  8292 = abc_30082_new_n3404_hfns_3
* NET  8293 = abc_30082_new_n3404_hfns_2
* NET  8294 = abc_30082_new_n3404_hfns_1
* NET  8295 = abc_30082_new_n3404_hfns_0
* NET  8296 = abc_30082_new_n3404
* NET  8297 = abc_30082_new_n3403
* NET  8298 = abc_30082_new_n3402
* NET  8299 = abc_30082_new_n3401
* NET  8300 = abc_30082_new_n3400
* NET  8301 = abc_30082_new_n3399
* NET  8302 = abc_30082_new_n3398
* NET  8303 = abc_30082_new_n3397
* NET  8304 = abc_30082_new_n3396
* NET  8305 = abc_30082_new_n3395
* NET  8306 = abc_30082_new_n3394
* NET  8307 = abc_30082_new_n3393
* NET  8308 = abc_30082_new_n3392
* NET  8309 = abc_30082_new_n3391
* NET  8310 = abc_30082_new_n3390
* NET  8311 = abc_30082_new_n3389
* NET  8312 = abc_30082_new_n3388
* NET  8313 = abc_30082_new_n3387
* NET  8314 = abc_30082_new_n3386
* NET  8315 = abc_30082_new_n3385
* NET  8316 = abc_30082_new_n3384
* NET  8317 = abc_30082_new_n3383
* NET  8318 = abc_30082_new_n3382
* NET  8319 = abc_30082_new_n3381
* NET  8320 = abc_30082_new_n3380
* NET  8321 = abc_30082_new_n3379
* NET  8322 = abc_30082_new_n3378
* NET  8323 = abc_30082_new_n3377
* NET  8324 = abc_30082_new_n3376
* NET  8325 = abc_30082_new_n3375
* NET  8326 = abc_30082_new_n3374
* NET  8327 = abc_30082_new_n3373
* NET  8328 = abc_30082_new_n3372
* NET  8329 = abc_30082_new_n3371
* NET  8330 = abc_30082_new_n3370
* NET  8331 = abc_30082_new_n3369
* NET  8332 = abc_30082_new_n3368
* NET  8333 = abc_30082_new_n3367
* NET  8334 = abc_30082_new_n3366
* NET  8335 = abc_30082_new_n3365
* NET  8336 = abc_30082_new_n3364
* NET  8337 = abc_30082_new_n3363
* NET  8338 = abc_30082_new_n3362
* NET  8339 = abc_30082_new_n3361
* NET  8340 = abc_30082_new_n3360
* NET  8341 = abc_30082_new_n3359
* NET  8342 = abc_30082_new_n3358
* NET  8343 = abc_30082_new_n3357
* NET  8344 = abc_30082_new_n3356
* NET  8345 = abc_30082_new_n3355
* NET  8346 = abc_30082_new_n3354
* NET  8347 = abc_30082_new_n3353
* NET  8348 = abc_30082_new_n3352
* NET  8349 = abc_30082_new_n3351
* NET  8350 = abc_30082_new_n3350
* NET  8351 = abc_30082_new_n3349
* NET  8352 = abc_30082_new_n3348
* NET  8353 = abc_30082_new_n3347
* NET  8354 = abc_30082_new_n3346
* NET  8355 = abc_30082_new_n3345
* NET  8356 = abc_30082_new_n3344
* NET  8357 = abc_30082_new_n3343
* NET  8358 = abc_30082_new_n3342
* NET  8359 = abc_30082_new_n3341
* NET  8360 = abc_30082_new_n3340
* NET  8361 = abc_30082_new_n3339
* NET  8362 = abc_30082_new_n3338
* NET  8363 = abc_30082_new_n3337
* NET  8364 = abc_30082_new_n3336
* NET  8365 = abc_30082_new_n3335
* NET  8366 = abc_30082_new_n3334
* NET  8367 = abc_30082_new_n3333
* NET  8368 = abc_30082_new_n3332
* NET  8369 = abc_30082_new_n3331
* NET  8370 = abc_30082_new_n3330
* NET  8371 = abc_30082_new_n3329
* NET  8372 = abc_30082_new_n3328
* NET  8373 = abc_30082_new_n3327
* NET  8374 = abc_30082_new_n3326
* NET  8375 = abc_30082_new_n3325
* NET  8376 = abc_30082_new_n3324
* NET  8377 = abc_30082_new_n3323
* NET  8378 = abc_30082_new_n3322
* NET  8379 = abc_30082_new_n3321
* NET  8380 = abc_30082_new_n3320
* NET  8381 = abc_30082_new_n3319
* NET  8382 = abc_30082_new_n3318
* NET  8383 = abc_30082_new_n3317
* NET  8384 = abc_30082_new_n3316
* NET  8385 = abc_30082_new_n3315
* NET  8386 = abc_30082_new_n3314
* NET  8387 = abc_30082_new_n3313
* NET  8388 = abc_30082_new_n3312
* NET  8389 = abc_30082_new_n3311
* NET  8390 = abc_30082_new_n3310
* NET  8391 = abc_30082_new_n3309
* NET  8392 = abc_30082_new_n3308
* NET  8393 = abc_30082_new_n3307
* NET  8394 = abc_30082_new_n3306
* NET  8395 = abc_30082_new_n3305_hfns_4
* NET  8396 = abc_30082_new_n3305_hfns_3
* NET  8397 = abc_30082_new_n3305_hfns_2
* NET  8398 = abc_30082_new_n3305_hfns_1
* NET  8399 = abc_30082_new_n3305_hfns_0
* NET  8400 = abc_30082_new_n3305
* NET  8401 = abc_30082_new_n3304
* NET  8402 = abc_30082_new_n3303
* NET  8403 = abc_30082_new_n3302
* NET  8404 = abc_30082_new_n3301
* NET  8405 = abc_30082_new_n3300
* NET  8406 = abc_30082_new_n3299
* NET  8407 = abc_30082_new_n3298_hfns_2
* NET  8408 = abc_30082_new_n3298_hfns_1
* NET  8409 = abc_30082_new_n3298_hfns_0
* NET  8410 = abc_30082_new_n3298
* NET  8411 = abc_30082_new_n3297
* NET  8412 = abc_30082_new_n3296
* NET  8413 = abc_30082_new_n3295
* NET  8414 = abc_30082_new_n3294_hfns_2
* NET  8415 = abc_30082_new_n3294_hfns_1
* NET  8416 = abc_30082_new_n3294_hfns_0
* NET  8417 = abc_30082_new_n3294
* NET  8418 = abc_30082_new_n3293
* NET  8419 = abc_30082_new_n3292
* NET  8420 = abc_30082_new_n3291
* NET  8421 = abc_30082_new_n3290
* NET  8422 = abc_30082_new_n3289
* NET  8423 = abc_30082_new_n11150
* NET  8424 = abc_30082_new_n11149
* NET  8425 = abc_30082_new_n11148
* NET  8426 = abc_30082_new_n11147
* NET  8427 = abc_30082_new_n11114_hfns_2
* NET  8428 = abc_30082_new_n11114_hfns_1
* NET  8429 = abc_30082_new_n11114_hfns_0
* NET  8430 = abc_30082_new_n11114
* NET  8431 = abc_30082_new_n11113
* NET  8432 = abc_30082_new_n11080_hfns_2
* NET  8433 = abc_30082_new_n11080_hfns_1
* NET  8434 = abc_30082_new_n11080_hfns_0
* NET  8435 = abc_30082_new_n11080
* NET  8436 = abc_30082_new_n11079
* NET  8437 = abc_30082_new_n11046_hfns_2
* NET  8438 = abc_30082_new_n11046_hfns_1
* NET  8439 = abc_30082_new_n11046_hfns_0
* NET  8440 = abc_30082_new_n11046
* NET  8441 = abc_30082_new_n11045
* NET  8442 = abc_30082_new_n11012_hfns_2
* NET  8443 = abc_30082_new_n11012_hfns_1
* NET  8444 = abc_30082_new_n11012_hfns_0
* NET  8445 = abc_30082_new_n11012
* NET  8446 = abc_30082_new_n11011
* NET  8447 = abc_30082_new_n10978_hfns_2
* NET  8448 = abc_30082_new_n10978_hfns_1
* NET  8449 = abc_30082_new_n10978_hfns_0
* NET  8450 = abc_30082_new_n10978
* NET  8451 = abc_30082_new_n10977
* NET  8452 = abc_30082_new_n10944_hfns_2
* NET  8453 = abc_30082_new_n10944_hfns_1
* NET  8454 = abc_30082_new_n10944_hfns_0
* NET  8455 = abc_30082_new_n10944
* NET  8456 = abc_30082_new_n10943
* NET  8457 = abc_30082_new_n10942
* NET  8458 = abc_30082_new_n10909_hfns_2
* NET  8459 = abc_30082_new_n10909_hfns_1
* NET  8460 = abc_30082_new_n10909_hfns_0
* NET  8461 = abc_30082_new_n10909
* NET  8462 = abc_30082_new_n10908
* NET  8463 = abc_30082_new_n10875_hfns_2
* NET  8464 = abc_30082_new_n10875_hfns_1
* NET  8465 = abc_30082_new_n10875_hfns_0
* NET  8466 = abc_30082_new_n10875
* NET  8467 = abc_30082_new_n10874
* NET  8468 = abc_30082_new_n10841_hfns_2
* NET  8469 = abc_30082_new_n10841_hfns_1
* NET  8470 = abc_30082_new_n10841_hfns_0
* NET  8471 = abc_30082_new_n10841
* NET  8472 = abc_30082_new_n10840
* NET  8473 = abc_30082_new_n10807_hfns_2
* NET  8474 = abc_30082_new_n10807_hfns_1
* NET  8475 = abc_30082_new_n10807_hfns_0
* NET  8476 = abc_30082_new_n10807
* NET  8477 = abc_30082_new_n10806
* NET  8478 = abc_30082_new_n10773_hfns_2
* NET  8479 = abc_30082_new_n10773_hfns_1
* NET  8480 = abc_30082_new_n10773_hfns_0
* NET  8481 = abc_30082_new_n10773
* NET  8482 = abc_30082_new_n10772
* NET  8483 = abc_30082_new_n10739_hfns_2
* NET  8484 = abc_30082_new_n10739_hfns_1
* NET  8485 = abc_30082_new_n10739_hfns_0
* NET  8486 = abc_30082_new_n10739
* NET  8487 = abc_30082_new_n10738
* NET  8488 = abc_30082_new_n10705_hfns_2
* NET  8489 = abc_30082_new_n10705_hfns_1
* NET  8490 = abc_30082_new_n10705_hfns_0
* NET  8491 = abc_30082_new_n10705
* NET  8492 = abc_30082_new_n10704
* NET  8493 = abc_30082_new_n10671_hfns_2
* NET  8494 = abc_30082_new_n10671_hfns_1
* NET  8495 = abc_30082_new_n10671_hfns_0
* NET  8496 = abc_30082_new_n10671
* NET  8497 = abc_30082_new_n10670
* NET  8498 = abc_30082_new_n10637_hfns_2
* NET  8499 = abc_30082_new_n10637_hfns_1
* NET  8500 = abc_30082_new_n10637_hfns_0
* NET  8501 = abc_30082_new_n10637
* NET  8502 = abc_30082_new_n10636
* NET  8503 = abc_30082_new_n10634
* NET  8504 = abc_30082_new_n10633
* NET  8505 = abc_30082_new_n10632
* NET  8506 = abc_30082_new_n10631
* NET  8507 = abc_30082_new_n10629
* NET  8508 = abc_30082_new_n10628
* NET  8509 = abc_30082_new_n10627
* NET  8510 = abc_30082_new_n10626
* NET  8511 = abc_30082_new_n10624
* NET  8512 = abc_30082_new_n10623
* NET  8513 = abc_30082_new_n10622
* NET  8514 = abc_30082_new_n10621
* NET  8515 = abc_30082_new_n10619
* NET  8516 = abc_30082_new_n10618
* NET  8517 = abc_30082_new_n10617
* NET  8518 = abc_30082_new_n10616
* NET  8519 = abc_30082_new_n10614
* NET  8520 = abc_30082_new_n10613
* NET  8521 = abc_30082_new_n10612
* NET  8522 = abc_30082_new_n10611
* NET  8523 = abc_30082_new_n10609
* NET  8524 = abc_30082_new_n10608
* NET  8525 = abc_30082_new_n10607
* NET  8526 = abc_30082_new_n10606
* NET  8527 = abc_30082_new_n10604
* NET  8528 = abc_30082_new_n10603
* NET  8529 = abc_30082_new_n10602
* NET  8530 = abc_30082_new_n10601
* NET  8531 = abc_30082_new_n10599
* NET  8532 = abc_30082_new_n10598
* NET  8533 = abc_30082_new_n10597
* NET  8534 = abc_30082_new_n10596
* NET  8535 = abc_30082_new_n10594
* NET  8536 = abc_30082_new_n10593
* NET  8537 = abc_30082_new_n10592
* NET  8538 = abc_30082_new_n10591
* NET  8539 = abc_30082_new_n10589
* NET  8540 = abc_30082_new_n10588
* NET  8541 = abc_30082_new_n10587
* NET  8542 = abc_30082_new_n10586
* NET  8543 = abc_30082_new_n10584
* NET  8544 = abc_30082_new_n10583
* NET  8545 = abc_30082_new_n10582
* NET  8546 = abc_30082_new_n10581
* NET  8547 = abc_30082_new_n10580
* NET  8548 = abc_30082_new_n10578
* NET  8549 = abc_30082_new_n10577
* NET  8550 = abc_30082_new_n10576
* NET  8551 = abc_30082_new_n10575
* NET  8552 = abc_30082_new_n10573
* NET  8553 = abc_30082_new_n10572
* NET  8554 = abc_30082_new_n10571
* NET  8555 = abc_30082_new_n10570
* NET  8556 = abc_30082_new_n10568
* NET  8557 = abc_30082_new_n10567
* NET  8558 = abc_30082_new_n10566
* NET  8559 = abc_30082_new_n10565
* NET  8560 = abc_30082_new_n10563
* NET  8561 = abc_30082_new_n10562
* NET  8562 = abc_30082_new_n10561
* NET  8563 = abc_30082_new_n10560
* NET  8564 = abc_30082_new_n10558
* NET  8565 = abc_30082_new_n10557
* NET  8566 = abc_30082_new_n10556
* NET  8567 = abc_30082_new_n10555
* NET  8568 = abc_30082_new_n10553
* NET  8569 = abc_30082_new_n10552
* NET  8570 = abc_30082_new_n10551
* NET  8571 = abc_30082_new_n10550
* NET  8572 = abc_30082_new_n10548
* NET  8573 = abc_30082_new_n10547
* NET  8574 = abc_30082_new_n10546
* NET  8575 = abc_30082_new_n10545
* NET  8576 = abc_30082_new_n10543
* NET  8577 = abc_30082_new_n10542
* NET  8578 = abc_30082_new_n10541
* NET  8579 = abc_30082_new_n10540
* NET  8580 = abc_30082_new_n10539
* NET  8581 = abc_30082_new_n10537
* NET  8582 = abc_30082_new_n10536
* NET  8583 = abc_30082_new_n10534
* NET  8584 = abc_30082_new_n10533
* NET  8585 = abc_30082_new_n10531
* NET  8586 = abc_30082_new_n10530
* NET  8587 = abc_30082_new_n10528
* NET  8588 = abc_30082_new_n10527
* NET  8589 = abc_30082_new_n10525
* NET  8590 = abc_30082_new_n10524
* NET  8591 = abc_30082_new_n10522
* NET  8592 = abc_30082_new_n10521
* NET  8593 = abc_30082_new_n10519
* NET  8594 = abc_30082_new_n10518
* NET  8595 = abc_30082_new_n10516
* NET  8596 = abc_30082_new_n10515
* NET  8597 = abc_30082_new_n10513
* NET  8598 = abc_30082_new_n10512
* NET  8599 = abc_30082_new_n10510
* NET  8600 = abc_30082_new_n10509
* NET  8601 = abc_30082_new_n10507
* NET  8602 = abc_30082_new_n10506
* NET  8603 = abc_30082_new_n10504
* NET  8604 = abc_30082_new_n10503
* NET  8605 = abc_30082_new_n10502
* NET  8606 = abc_30082_new_n10501
* NET  8607 = abc_30082_new_n10500
* NET  8608 = abc_30082_new_n10499
* NET  8609 = abc_30082_new_n10498
* NET  8610 = abc_30082_new_n10497
* NET  8611 = abc_30082_new_n10495
* NET  8612 = abc_30082_new_n10494
* NET  8613 = abc_30082_new_n10493
* NET  8614 = abc_30082_new_n10492
* NET  8615 = abc_30082_new_n10490
* NET  8616 = abc_30082_new_n10489
* NET  8617 = abc_30082_new_n10487
* NET  8618 = abc_30082_new_n10485
* NET  8619 = abc_30082_new_n10483
* NET  8620 = abc_30082_new_n10481
* NET  8621 = abc_30082_new_n10479
* NET  8622 = abc_30082_new_n10478
* NET  8623 = abc_30082_new_n10477
* NET  8624 = abc_30082_new_n10475
* NET  8625 = abc_30082_new_n10474
* NET  8626 = abc_30082_new_n10473
* NET  8627 = abc_30082_new_n10472
* NET  8628 = abc_30082_new_n10470
* NET  8629 = abc_30082_new_n10469
* NET  8630 = abc_30082_new_n10468
* NET  8631 = abc_30082_new_n10467
* NET  8632 = abc_30082_new_n10465
* NET  8633 = abc_30082_new_n10464
* NET  8634 = abc_30082_new_n10463
* NET  8635 = abc_30082_new_n10462
* NET  8636 = abc_30082_new_n10460
* NET  8637 = abc_30082_new_n10459
* NET  8638 = abc_30082_new_n10458
* NET  8639 = abc_30082_new_n10457
* NET  8640 = abc_30082_new_n10456
* NET  8641 = abc_30082_new_n10423_hfns_2
* NET  8642 = abc_30082_new_n10423_hfns_1
* NET  8643 = abc_30082_new_n10423_hfns_0
* NET  8644 = abc_30082_new_n10423
* NET  8645 = abc_30082_new_n10422
* NET  8646 = abc_30082_new_n10420
* NET  8647 = abc_30082_new_n10419
* NET  8648 = abc_30082_new_n10417
* NET  8649 = abc_30082_new_n10416
* NET  8650 = abc_30082_new_n10415
* NET  8651 = abc_30082_new_n10414
* NET  8652 = abc_30082_new_n10413
* NET  8653 = abc_30082_new_n10412
* NET  8654 = abc_30082_new_n10411
* NET  8655 = abc_30082_new_n10410
* NET  8656 = abc_30082_new_n10409
* NET  8657 = abc_30082_new_n10408
* NET  8658 = abc_30082_new_n10406
* NET  8659 = abc_30082_new_n10404
* NET  8660 = abc_30082_new_n10403
* NET  8661 = abc_30082_new_n10402
* NET  8662 = abc_30082_new_n10400
* NET  8663 = abc_30082_new_n10398
* NET  8664 = abc_30082_new_n10365_hfns_2
* NET  8665 = abc_30082_new_n10365_hfns_1
* NET  8666 = abc_30082_new_n10365_hfns_0
* NET  8667 = abc_30082_new_n10365
* NET  8668 = abc_30082_new_n10364
* NET  8669 = abc_30082_new_n10362
* NET  8670 = abc_30082_new_n10361
* NET  8671 = abc_30082_new_n10359
* NET  8672 = abc_30082_new_n10358
* NET  8673 = abc_30082_new_n10356
* NET  8674 = abc_30082_new_n10355
* NET  8675 = abc_30082_new_n10353
* NET  8676 = abc_30082_new_n10352
* NET  8677 = abc_30082_new_n10351
* NET  8678 = abc_30082_new_n10349
* NET  8679 = abc_30082_new_n10348
* NET  8680 = abc_30082_new_n10347
* NET  8681 = abc_30082_new_n10345
* NET  8682 = abc_30082_new_n10344
* NET  8683 = abc_30082_new_n10343
* NET  8684 = abc_30082_new_n10341
* NET  8685 = abc_30082_new_n10340
* NET  8686 = abc_30082_new_n10339
* NET  8687 = abc_30082_new_n10338
* NET  8688 = abc_30082_new_n10309
* NET  8689 = abc_30082_new_n10308
* NET  8690 = abc_30082_new_n10306
* NET  8691 = abc_30082_new_n10305
* NET  8692 = abc_30082_new_n10304
* NET  8693 = abc_30082_new_n10303
* NET  8694 = abc_30082_new_n10302
* NET  8695 = abc_30082_new_n10301
* NET  8696 = abc_30082_new_n10299
* NET  8697 = abc_30082_new_n10298
* NET  8698 = abc_30082_new_n10297
* NET  8699 = abc_30082_new_n10295
* NET  8700 = abc_30082_new_n10294
* NET  8701 = abc_30082_new_n10293
* NET  8702 = abc_30082_new_n10292
* NET  8703 = abc_30082_new_n10290
* NET  8704 = abc_30082_new_n10289
* NET  8705 = abc_30082_new_n10288
* NET  8706 = abc_30082_new_n10287
* NET  8707 = abc_30082_new_n10286
* NET  8708 = abc_30082_new_n10285
* NET  8709 = abc_30082_new_n10284
* NET  8710 = abc_30082_new_n10283
* NET  8711 = abc_30082_new_n10282
* NET  8712 = abc_30082_new_n10281
* NET  8713 = abc_30082_new_n10280
* NET  8714 = abc_30082_new_n10279
* NET  8715 = abc_30082_new_n10278
* NET  8716 = abc_30082_new_n10277
* NET  8717 = abc_30082_new_n10276
* NET  8718 = abc_30082_new_n10275
* NET  8719 = abc_30082_new_n10274
* NET  8720 = abc_30082_new_n10273
* NET  8721 = abc_30082_new_n10272
* NET  8722 = abc_30082_new_n10271
* NET  8723 = abc_30082_new_n10270
* NET  8724 = abc_30082_new_n10269
* NET  8725 = abc_30082_new_n10268
* NET  8726 = abc_30082_new_n10267
* NET  8727 = abc_30082_new_n10265
* NET  8728 = abc_30082_new_n10263
* NET  8729 = abc_30082_new_n10262
* NET  8730 = abc_30082_new_n10261
* NET  8731 = abc_30082_new_n10259
* NET  8732 = abc_30082_new_n10258
* NET  8733 = abc_30082_new_n10257
* NET  8734 = abc_30082_new_n10255
* NET  8735 = abc_30082_new_n10254
* NET  8736 = abc_30082_new_n10252
* NET  8737 = abc_30082_new_n10251
* NET  8738 = abc_30082_new_n10250
* NET  8739 = abc_30082_new_n10248
* NET  8740 = abc_30082_new_n10247
* NET  8741 = abc_30082_new_n10246
* NET  8742 = abc_30082_new_n10244
* NET  8743 = abc_30082_new_n10243
* NET  8744 = abc_30082_new_n10242
* NET  8745 = abc_30082_new_n10240
* NET  8746 = abc_30082_new_n10239
* NET  8747 = abc_30082_new_n10238
* NET  8748 = abc_30082_new_n10236
* NET  8749 = abc_30082_new_n10235
* NET  8750 = abc_30082_new_n10234
* NET  8751 = abc_30082_new_n10233
* NET  8752 = abc_30082_new_n10231
* NET  8753 = abc_30082_new_n10230
* NET  8754 = abc_30082_new_n10229
* NET  8755 = abc_30082_new_n10228
* NET  8756 = abc_30082_new_n10226
* NET  8757 = abc_30082_new_n10225
* NET  8758 = abc_30082_new_n10224
* NET  8759 = abc_30082_new_n10222
* NET  8760 = abc_30082_new_n10221
* NET  8761 = abc_30082_new_n10220
* NET  8762 = abc_30082_new_n10218
* NET  8763 = abc_30082_new_n10217
* NET  8764 = abc_30082_new_n10216
* NET  8765 = abc_30082_new_n10215
* NET  8766 = abc_30082_new_n10214
* NET  8767 = abc_30082_new_n10213
* NET  8768 = abc_30082_new_n10212
* NET  8769 = abc_30082_new_n10211
* NET  8770 = abc_30082_new_n10209
* NET  8771 = abc_30082_new_n10207
* NET  8772 = abc_30082_new_n10206
* NET  8773 = abc_30082_new_n10204
* NET  8774 = abc_30082_new_n10203
* NET  8775 = abc_30082_new_n10201
* NET  8776 = abc_30082_new_n10200
* NET  8777 = abc_30082_new_n10198
* NET  8778 = abc_30082_new_n10197
* NET  8779 = abc_30082_new_n10196
* NET  8780 = abc_30082_new_n10195
* NET  8781 = abc_30082_new_n10193
* NET  8782 = abc_30082_new_n10192
* NET  8783 = abc_30082_new_n10190
* NET  8784 = abc_30082_new_n10189
* NET  8785 = abc_30082_new_n10188
* NET  8786 = abc_30082_new_n10187
* NET  8787 = abc_30082_new_n10185
* NET  8788 = abc_30082_new_n10183
* NET  8789 = abc_30082_new_n10182
* NET  8790 = abc_30082_new_n10181
* NET  8791 = abc_30082_new_n10179
* NET  8792 = abc_30082_new_n10177
* NET  8793 = abc_30082_new_n10175
* NET  8794 = abc_30082_new_n10174
* NET  8795 = abc_30082_new_n10173
* NET  8796 = abc_30082_new_n10171
* NET  8797 = abc_30082_new_n10169
* NET  8798 = abc_30082_new_n10168
* NET  8799 = abc_30082_new_n10167
* NET  8800 = abc_30082_new_n10165
* NET  8801 = abc_30082_new_n10164
* NET  8802 = abc_30082_new_n10162
* NET  8803 = abc_30082_new_n10160
* NET  8804 = abc_30082_new_n10158
* NET  8805 = abc_30082_new_n10156
* NET  8806 = abc_30082_new_n10155
* NET  8807 = abc_30082_new_n10154
* NET  8808 = abc_30082_new_n10153
* NET  8809 = abc_30082_new_n10151
* NET  8810 = abc_30082_new_n10150
* NET  8811 = abc_30082_new_n10149
* NET  8812 = abc_30082_new_n10148
* NET  8813 = abc_30082_new_n10146
* NET  8814 = abc_30082_new_n10145
* NET  8815 = abc_30082_new_n10144
* NET  8816 = abc_30082_new_n10143
* NET  8817 = abc_30082_new_n10141
* NET  8818 = abc_30082_new_n10140
* NET  8819 = abc_30082_new_n10139
* NET  8820 = abc_30082_new_n10138
* NET  8821 = abc_30082_new_n10136
* NET  8822 = abc_30082_new_n10135
* NET  8823 = abc_30082_new_n10134
* NET  8824 = abc_30082_new_n10133
* NET  8825 = abc_30082_new_n10131
* NET  8826 = abc_30082_new_n10130
* NET  8827 = abc_30082_new_n10129
* NET  8828 = abc_30082_new_n10128
* NET  8829 = abc_30082_new_n10127
* NET  8830 = abc_30082_new_n10126_hfns_2
* NET  8831 = abc_30082_new_n10126_hfns_1
* NET  8832 = abc_30082_new_n10126_hfns_0
* NET  8833 = abc_30082_new_n10126
* NET  8834 = abc_30082_new_n10124
* NET  8835 = abc_30082_new_n10123
* NET  8836 = abc_30082_new_n10122
* NET  8837 = abc_30082_new_n10121
* NET  8838 = abc_30082_new_n10119
* NET  8839 = abc_30082_new_n10118
* NET  8840 = abc_30082_new_n10116
* NET  8841 = abc_30082_new_n10115
* NET  8842 = abc_30082_new_n10113
* NET  8843 = abc_30082_new_n10111
* NET  8844 = abc_30082_new_n10109
* NET  8845 = abc_30082_new_n10108
* NET  8846 = abc_30082_new_n10106
* NET  8847 = abc_30082_new_n10104
* NET  8848 = abc_30082_new_n10100
* NET  8849 = abc_30082_new_n10099
* NET  8850 = abc_30082_new_n10097
* NET  8851 = abc_30082_new_n10096
* NET  8852 = abc_30082_new_n10095
* NET  8853 = abc_30082_new_n10094
* NET  8854 = abc_30082_new_n10093
* NET  8855 = abc_30082_new_n10091
* NET  8856 = abc_30082_new_n10090
* NET  8857 = abc_30082_new_n10089
* NET  8858 = abc_30082_new_n10087
* NET  8859 = abc_30082_new_n10086
* NET  8860 = abc_30082_new_n10084
* NET  8861 = abc_30082_new_n10083
* NET  8862 = abc_30082_new_n10082
* NET  8863 = abc_30082_new_n10081
* NET  8864 = abc_30082_new_n10080
* NET  8865 = abc_30082_new_n10079
* NET  8866 = abc_30082_new_n10077
* NET  8867 = abc_30082_new_n10076
* NET  8868 = abc_30082_new_n10075
* NET  8869 = abc_30082_new_n10074
* NET  8870 = abc_30082_new_n10073
* NET  8871 = abc_30082_new_n10072
* NET  8872 = abc_30082_new_n10071
* NET  8873 = abc_30082_new_n10070
* NET  8874 = abc_30082_new_n10069
* NET  8875 = abc_30082_new_n10068
* NET  8876 = abc_30082_new_n10067
* NET  8877 = abc_30082_new_n10066
* NET  8878 = abc_30082_new_n10065
* NET  8879 = abc_30082_new_n10064
* NET  8880 = abc_30082_new_n10063
* NET  8881 = abc_30082_new_n10062
* NET  8882 = abc_30082_new_n10061
* NET  8883 = abc_30082_new_n10060
* NET  8884 = abc_30082_new_n10059
* NET  8885 = abc_30082_new_n10058
* NET  8886 = abc_30082_new_n10057
* NET  8887 = abc_30082_new_n10056
* NET  8888 = abc_30082_new_n10055
* NET  8889 = abc_30082_new_n10054
* NET  8890 = abc_30082_new_n10053
* NET  8891 = abc_30082_new_n10052
* NET  8892 = abc_30082_new_n10051
* NET  8893 = abc_30082_new_n10050
* NET  8894 = abc_30082_new_n10049
* NET  8895 = abc_30082_new_n10048
* NET  8896 = abc_30082_new_n10047
* NET  8897 = abc_30082_new_n10046
* NET  8898 = abc_30082_new_n10045
* NET  8899 = abc_30082_new_n10044
* NET  8900 = abc_30082_new_n10043
* NET  8901 = abc_30082_new_n10041
* NET  8902 = abc_30082_new_n10040
* NET  8903 = abc_30082_new_n10039
* NET  8904 = abc_30082_new_n10038
* NET  8905 = abc_30082_new_n10037
* NET  8906 = abc_30082_new_n10036
* NET  8907 = abc_30082_new_n10035
* NET  8908 = abc_30082_new_n10034
* NET  8909 = abc_30082_new_n10033
* NET  8910 = abc_30082_new_n10032
* NET  8911 = abc_30082_new_n10031
* NET  8912 = abc_30082_new_n10030
* NET  8913 = abc_30082_new_n10029
* NET  8914 = abc_30082_new_n10028
* NET  8915 = abc_30082_new_n10027
* NET  8916 = abc_30082_new_n10026
* NET  8917 = abc_30082_new_n10025
* NET  8918 = abc_30082_new_n10024
* NET  8919 = abc_30082_new_n10023
* NET  8920 = abc_30082_new_n10022
* NET  8921 = abc_30082_new_n10021
* NET  8922 = abc_30082_new_n10020
* NET  8923 = abc_30082_new_n10019
* NET  8924 = abc_30082_new_n10018
* NET  8925 = abc_30082_new_n10017
* NET  8926 = abc_30082_new_n10016
* NET  8927 = abc_30082_new_n10015
* NET  8928 = abc_30082_new_n10014
* NET  8929 = abc_30082_new_n10013
* NET  8930 = abc_30082_new_n10012
* NET  8931 = abc_30082_new_n10011
* NET  8932 = abc_30082_new_n10010
* NET  8933 = abc_30082_new_n10009
* NET  8934 = abc_30082_new_n10008
* NET  8935 = abc_30082_new_n10007
* NET  8936 = abc_30082_new_n10005
* NET  8937 = abc_30082_new_n10004
* NET  8938 = abc_30082_new_n10003
* NET  8939 = abc_30082_new_n10002
* NET  8940 = abc_30082_new_n10001
* NET  8941 = abc_30082_new_n10000
* NET  8942 = abc_30082_auto_rtlil_cc_2608_muxgate_30081
* NET  8943 = abc_30082_auto_rtlil_cc_2608_muxgate_30077
* NET  8944 = abc_30082_auto_rtlil_cc_2608_muxgate_30075
* NET  8945 = abc_30082_auto_rtlil_cc_2608_muxgate_30073
* NET  8946 = abc_30082_auto_rtlil_cc_2608_muxgate_30071
* NET  8947 = abc_30082_auto_rtlil_cc_2608_muxgate_30069
* NET  8948 = abc_30082_auto_rtlil_cc_2608_muxgate_30067
* NET  8949 = abc_30082_auto_rtlil_cc_2608_muxgate_30065
* NET  8950 = abc_30082_auto_rtlil_cc_2608_muxgate_30063
* NET  8951 = abc_30082_auto_rtlil_cc_2608_muxgate_30061
* NET  8952 = abc_30082_auto_rtlil_cc_2608_muxgate_30059
* NET  8953 = abc_30082_auto_rtlil_cc_2608_muxgate_30057
* NET  8954 = abc_30082_auto_rtlil_cc_2608_muxgate_30055
* NET  8955 = abc_30082_auto_rtlil_cc_2608_muxgate_30053
* NET  8956 = abc_30082_auto_rtlil_cc_2608_muxgate_30051
* NET  8957 = abc_30082_auto_rtlil_cc_2608_muxgate_30049
* NET  8958 = abc_30082_auto_rtlil_cc_2608_muxgate_30047
* NET  8959 = abc_30082_auto_rtlil_cc_2608_muxgate_30045
* NET  8960 = abc_30082_auto_rtlil_cc_2608_muxgate_30043
* NET  8961 = abc_30082_auto_rtlil_cc_2608_muxgate_30041
* NET  8962 = abc_30082_auto_rtlil_cc_2608_muxgate_30039
* NET  8963 = abc_30082_auto_rtlil_cc_2608_muxgate_30037
* NET  8964 = abc_30082_auto_rtlil_cc_2608_muxgate_30035
* NET  8965 = abc_30082_auto_rtlil_cc_2608_muxgate_30033
* NET  8966 = abc_30082_auto_rtlil_cc_2608_muxgate_30031
* NET  8967 = abc_30082_auto_rtlil_cc_2608_muxgate_30029
* NET  8968 = abc_30082_auto_rtlil_cc_2608_muxgate_30027
* NET  8969 = abc_30082_auto_rtlil_cc_2608_muxgate_30025
* NET  8970 = abc_30082_auto_rtlil_cc_2608_muxgate_30023
* NET  8971 = abc_30082_auto_rtlil_cc_2608_muxgate_30021
* NET  8972 = abc_30082_auto_rtlil_cc_2608_muxgate_30019
* NET  8973 = abc_30082_auto_rtlil_cc_2608_muxgate_30017
* NET  8974 = abc_30082_auto_rtlil_cc_2608_muxgate_30015
* NET  8975 = abc_30082_auto_rtlil_cc_2608_muxgate_30013
* NET  8976 = abc_30082_auto_rtlil_cc_2608_muxgate_30011
* NET  8977 = abc_30082_auto_rtlil_cc_2608_muxgate_30009
* NET  8978 = abc_30082_auto_rtlil_cc_2608_muxgate_30007
* NET  8979 = abc_30082_auto_rtlil_cc_2608_muxgate_30005
* NET  8980 = abc_30082_auto_rtlil_cc_2608_muxgate_30003
* NET  8981 = abc_30082_auto_rtlil_cc_2608_muxgate_30001
* NET  8982 = abc_30082_auto_rtlil_cc_2608_muxgate_29999
* NET  8983 = abc_30082_auto_rtlil_cc_2608_muxgate_29997
* NET  8984 = abc_30082_auto_rtlil_cc_2608_muxgate_29995
* NET  8985 = abc_30082_auto_rtlil_cc_2608_muxgate_29993
* NET  8986 = abc_30082_auto_rtlil_cc_2608_muxgate_29991
* NET  8987 = abc_30082_auto_rtlil_cc_2608_muxgate_29989
* NET  8988 = abc_30082_auto_rtlil_cc_2608_muxgate_29987
* NET  8989 = abc_30082_auto_rtlil_cc_2608_muxgate_29985
* NET  8990 = abc_30082_auto_rtlil_cc_2608_muxgate_29983
* NET  8991 = abc_30082_auto_rtlil_cc_2608_muxgate_29981
* NET  8992 = abc_30082_auto_rtlil_cc_2608_muxgate_29979
* NET  8993 = abc_30082_auto_rtlil_cc_2608_muxgate_29977
* NET  8994 = abc_30082_auto_rtlil_cc_2608_muxgate_29975
* NET  8995 = abc_30082_auto_rtlil_cc_2608_muxgate_29973
* NET  8996 = abc_30082_auto_rtlil_cc_2608_muxgate_29971
* NET  8997 = abc_30082_auto_rtlil_cc_2608_muxgate_29969
* NET  8998 = abc_30082_auto_rtlil_cc_2608_muxgate_29967
* NET  8999 = abc_30082_auto_rtlil_cc_2608_muxgate_29965
* NET  9000 = abc_30082_auto_rtlil_cc_2608_muxgate_29963
* NET  9001 = abc_30082_auto_rtlil_cc_2608_muxgate_29961
* NET  9002 = abc_30082_auto_rtlil_cc_2608_muxgate_29959
* NET  9003 = abc_30082_auto_rtlil_cc_2608_muxgate_29957
* NET  9004 = abc_30082_auto_rtlil_cc_2608_muxgate_29955
* NET  9005 = abc_30082_auto_rtlil_cc_2608_muxgate_29953
* NET  9006 = abc_30082_auto_rtlil_cc_2608_muxgate_29951
* NET  9007 = abc_30082_auto_rtlil_cc_2608_muxgate_29949
* NET  9008 = abc_30082_auto_rtlil_cc_2608_muxgate_29947
* NET  9009 = abc_30082_auto_rtlil_cc_2608_muxgate_29945
* NET  9010 = abc_30082_auto_rtlil_cc_2608_muxgate_29943
* NET  9011 = abc_30082_auto_rtlil_cc_2608_muxgate_29941
* NET  9012 = abc_30082_auto_rtlil_cc_2608_muxgate_29939
* NET  9013 = abc_30082_auto_rtlil_cc_2608_muxgate_29937
* NET  9014 = abc_30082_auto_rtlil_cc_2608_muxgate_29935
* NET  9015 = abc_30082_auto_rtlil_cc_2608_muxgate_29933
* NET  9016 = abc_30082_auto_rtlil_cc_2608_muxgate_29931
* NET  9017 = abc_30082_auto_rtlil_cc_2608_muxgate_29929
* NET  9018 = abc_30082_auto_rtlil_cc_2608_muxgate_29927
* NET  9019 = abc_30082_auto_rtlil_cc_2608_muxgate_29925
* NET  9020 = abc_30082_auto_rtlil_cc_2608_muxgate_29923
* NET  9021 = abc_30082_auto_rtlil_cc_2608_muxgate_29921
* NET  9022 = abc_30082_auto_rtlil_cc_2608_muxgate_29919
* NET  9023 = abc_30082_auto_rtlil_cc_2608_muxgate_29917
* NET  9024 = abc_30082_auto_rtlil_cc_2608_muxgate_29915
* NET  9025 = abc_30082_auto_rtlil_cc_2608_muxgate_29913
* NET  9026 = abc_30082_auto_rtlil_cc_2608_muxgate_29911
* NET  9027 = abc_30082_auto_rtlil_cc_2608_muxgate_29909
* NET  9028 = abc_30082_auto_rtlil_cc_2608_muxgate_29907
* NET  9029 = abc_30082_auto_rtlil_cc_2608_muxgate_29905
* NET  9030 = abc_30082_auto_rtlil_cc_2608_muxgate_29903
* NET  9031 = abc_30082_auto_rtlil_cc_2608_muxgate_29901
* NET  9032 = abc_30082_auto_rtlil_cc_2608_muxgate_29899
* NET  9033 = abc_30082_auto_rtlil_cc_2608_muxgate_29897
* NET  9034 = abc_30082_auto_rtlil_cc_2608_muxgate_29895
* NET  9035 = abc_30082_auto_rtlil_cc_2608_muxgate_29893
* NET  9036 = abc_30082_auto_rtlil_cc_2608_muxgate_29891
* NET  9037 = abc_30082_auto_rtlil_cc_2608_muxgate_29889
* NET  9038 = abc_30082_auto_rtlil_cc_2608_muxgate_29887
* NET  9039 = abc_30082_auto_rtlil_cc_2608_muxgate_29885
* NET  9040 = abc_30082_auto_rtlil_cc_2608_muxgate_29883
* NET  9041 = abc_30082_auto_rtlil_cc_2608_muxgate_29881
* NET  9042 = abc_30082_auto_rtlil_cc_2608_muxgate_29879
* NET  9043 = abc_30082_auto_rtlil_cc_2608_muxgate_29877
* NET  9044 = abc_30082_auto_rtlil_cc_2608_muxgate_29875
* NET  9045 = abc_30082_auto_rtlil_cc_2608_muxgate_29873
* NET  9046 = abc_30082_auto_rtlil_cc_2608_muxgate_29871
* NET  9047 = abc_30082_auto_rtlil_cc_2608_muxgate_29869
* NET  9048 = abc_30082_auto_rtlil_cc_2608_muxgate_29867
* NET  9049 = abc_30082_auto_rtlil_cc_2608_muxgate_29865
* NET  9050 = abc_30082_auto_rtlil_cc_2608_muxgate_29863
* NET  9051 = abc_30082_auto_rtlil_cc_2608_muxgate_29861
* NET  9052 = abc_30082_auto_rtlil_cc_2608_muxgate_29859
* NET  9053 = abc_30082_auto_rtlil_cc_2608_muxgate_29857
* NET  9054 = abc_30082_auto_rtlil_cc_2608_muxgate_29855
* NET  9055 = abc_30082_auto_rtlil_cc_2608_muxgate_29853
* NET  9056 = abc_30082_auto_rtlil_cc_2608_muxgate_29851
* NET  9057 = abc_30082_auto_rtlil_cc_2608_muxgate_29849
* NET  9058 = abc_30082_auto_rtlil_cc_2608_muxgate_29847
* NET  9059 = abc_30082_auto_rtlil_cc_2608_muxgate_29845
* NET  9060 = abc_30082_auto_rtlil_cc_2608_muxgate_29843
* NET  9061 = abc_30082_auto_rtlil_cc_2608_muxgate_29841
* NET  9062 = abc_30082_auto_rtlil_cc_2608_muxgate_29839
* NET  9063 = abc_30082_auto_rtlil_cc_2608_muxgate_29837
* NET  9064 = abc_30082_auto_rtlil_cc_2608_muxgate_29835
* NET  9065 = abc_30082_auto_rtlil_cc_2608_muxgate_29833
* NET  9066 = abc_30082_auto_rtlil_cc_2608_muxgate_29831
* NET  9067 = abc_30082_auto_rtlil_cc_2608_muxgate_29829
* NET  9068 = abc_30082_auto_rtlil_cc_2608_muxgate_29827
* NET  9069 = abc_30082_auto_rtlil_cc_2608_muxgate_29825
* NET  9070 = abc_30082_auto_rtlil_cc_2608_muxgate_29823
* NET  9071 = abc_30082_auto_rtlil_cc_2608_muxgate_29821
* NET  9072 = abc_30082_auto_rtlil_cc_2608_muxgate_29819
* NET  9073 = abc_30082_auto_rtlil_cc_2608_muxgate_29817
* NET  9074 = abc_30082_auto_rtlil_cc_2608_muxgate_29815
* NET  9075 = abc_30082_auto_rtlil_cc_2608_muxgate_29813
* NET  9076 = abc_30082_auto_rtlil_cc_2608_muxgate_29811
* NET  9077 = abc_30082_auto_rtlil_cc_2608_muxgate_29809
* NET  9078 = abc_30082_auto_rtlil_cc_2608_muxgate_29807
* NET  9079 = abc_30082_auto_rtlil_cc_2608_muxgate_29805
* NET  9080 = abc_30082_auto_rtlil_cc_2608_muxgate_29803
* NET  9081 = abc_30082_auto_rtlil_cc_2608_muxgate_29801
* NET  9082 = abc_30082_auto_rtlil_cc_2608_muxgate_29799
* NET  9083 = abc_30082_auto_rtlil_cc_2608_muxgate_29797
* NET  9084 = abc_30082_auto_rtlil_cc_2608_muxgate_29795
* NET  9085 = abc_30082_auto_rtlil_cc_2608_muxgate_29793
* NET  9086 = abc_30082_auto_rtlil_cc_2608_muxgate_29791
* NET  9087 = abc_30082_auto_rtlil_cc_2608_muxgate_29789
* NET  9088 = abc_30082_auto_rtlil_cc_2608_muxgate_29787
* NET  9089 = abc_30082_auto_rtlil_cc_2608_muxgate_29785
* NET  9090 = abc_30082_auto_rtlil_cc_2608_muxgate_29783
* NET  9091 = abc_30082_auto_rtlil_cc_2608_muxgate_29781
* NET  9092 = abc_30082_auto_rtlil_cc_2608_muxgate_29779
* NET  9093 = abc_30082_auto_rtlil_cc_2608_muxgate_29777
* NET  9094 = abc_30082_auto_rtlil_cc_2608_muxgate_29775
* NET  9095 = abc_30082_auto_rtlil_cc_2608_muxgate_29773
* NET  9096 = abc_30082_auto_rtlil_cc_2608_muxgate_29771
* NET  9097 = abc_30082_auto_rtlil_cc_2608_muxgate_29769
* NET  9098 = abc_30082_auto_rtlil_cc_2608_muxgate_29767
* NET  9099 = abc_30082_auto_rtlil_cc_2608_muxgate_29765
* NET  9100 = abc_30082_auto_rtlil_cc_2608_muxgate_29763
* NET  9101 = abc_30082_auto_rtlil_cc_2608_muxgate_29761
* NET  9102 = abc_30082_auto_rtlil_cc_2608_muxgate_29759
* NET  9103 = abc_30082_auto_rtlil_cc_2608_muxgate_29757
* NET  9104 = abc_30082_auto_rtlil_cc_2608_muxgate_29755
* NET  9105 = abc_30082_auto_rtlil_cc_2608_muxgate_29753
* NET  9106 = abc_30082_auto_rtlil_cc_2608_muxgate_29751
* NET  9107 = abc_30082_auto_rtlil_cc_2608_muxgate_29749
* NET  9108 = abc_30082_auto_rtlil_cc_2608_muxgate_29747
* NET  9109 = abc_30082_auto_rtlil_cc_2608_muxgate_29745
* NET  9110 = abc_30082_auto_rtlil_cc_2608_muxgate_29743
* NET  9111 = abc_30082_auto_rtlil_cc_2608_muxgate_29741
* NET  9112 = abc_30082_auto_rtlil_cc_2608_muxgate_29739
* NET  9113 = abc_30082_auto_rtlil_cc_2608_muxgate_29737
* NET  9114 = abc_30082_auto_rtlil_cc_2608_muxgate_29735
* NET  9115 = abc_30082_auto_rtlil_cc_2608_muxgate_29733
* NET  9116 = abc_30082_auto_rtlil_cc_2608_muxgate_29731
* NET  9117 = abc_30082_auto_rtlil_cc_2608_muxgate_29729
* NET  9118 = abc_30082_auto_rtlil_cc_2608_muxgate_29727
* NET  9119 = abc_30082_auto_rtlil_cc_2608_muxgate_29725
* NET  9120 = abc_30082_auto_rtlil_cc_2608_muxgate_29723
* NET  9121 = abc_30082_auto_rtlil_cc_2608_muxgate_29721
* NET  9122 = abc_30082_auto_rtlil_cc_2608_muxgate_29719
* NET  9123 = abc_30082_auto_rtlil_cc_2608_muxgate_29717
* NET  9124 = abc_30082_auto_rtlil_cc_2608_muxgate_29715
* NET  9125 = abc_30082_auto_rtlil_cc_2608_muxgate_29713
* NET  9126 = abc_30082_auto_rtlil_cc_2608_muxgate_29711
* NET  9127 = abc_30082_auto_rtlil_cc_2608_muxgate_29709
* NET  9128 = abc_30082_auto_rtlil_cc_2608_muxgate_29707
* NET  9129 = abc_30082_auto_rtlil_cc_2608_muxgate_29705
* NET  9130 = abc_30082_auto_rtlil_cc_2608_muxgate_29703
* NET  9131 = abc_30082_auto_rtlil_cc_2608_muxgate_29701
* NET  9132 = abc_30082_auto_rtlil_cc_2608_muxgate_29699
* NET  9133 = abc_30082_auto_rtlil_cc_2608_muxgate_29697
* NET  9134 = abc_30082_auto_rtlil_cc_2608_muxgate_29695
* NET  9135 = abc_30082_auto_rtlil_cc_2608_muxgate_29693
* NET  9136 = abc_30082_auto_rtlil_cc_2608_muxgate_29691
* NET  9137 = abc_30082_auto_rtlil_cc_2608_muxgate_29689
* NET  9138 = abc_30082_auto_rtlil_cc_2608_muxgate_29687
* NET  9139 = abc_30082_auto_rtlil_cc_2608_muxgate_29685
* NET  9140 = abc_30082_auto_rtlil_cc_2608_muxgate_29683
* NET  9141 = abc_30082_auto_rtlil_cc_2608_muxgate_29681
* NET  9142 = abc_30082_auto_rtlil_cc_2608_muxgate_29679
* NET  9143 = abc_30082_auto_rtlil_cc_2608_muxgate_29677
* NET  9144 = abc_30082_auto_rtlil_cc_2608_muxgate_29675
* NET  9145 = abc_30082_auto_rtlil_cc_2608_muxgate_29673
* NET  9146 = abc_30082_auto_rtlil_cc_2608_muxgate_29671
* NET  9147 = abc_30082_auto_rtlil_cc_2608_muxgate_29669
* NET  9148 = abc_30082_auto_rtlil_cc_2608_muxgate_29667
* NET  9149 = abc_30082_auto_rtlil_cc_2608_muxgate_29665
* NET  9150 = abc_30082_auto_rtlil_cc_2608_muxgate_29663
* NET  9151 = abc_30082_auto_rtlil_cc_2608_muxgate_29661
* NET  9152 = abc_30082_auto_rtlil_cc_2608_muxgate_29659
* NET  9153 = abc_30082_auto_rtlil_cc_2608_muxgate_29657
* NET  9154 = abc_30082_auto_rtlil_cc_2608_muxgate_29655
* NET  9155 = abc_30082_auto_rtlil_cc_2608_muxgate_29653
* NET  9156 = abc_30082_auto_rtlil_cc_2608_muxgate_29651
* NET  9157 = abc_30082_auto_rtlil_cc_2608_muxgate_29649
* NET  9158 = abc_30082_auto_rtlil_cc_2608_muxgate_29647
* NET  9159 = abc_30082_auto_rtlil_cc_2608_muxgate_29645
* NET  9160 = abc_30082_auto_rtlil_cc_2608_muxgate_29643
* NET  9161 = abc_30082_auto_rtlil_cc_2608_muxgate_29641
* NET  9162 = abc_30082_auto_rtlil_cc_2608_muxgate_29639
* NET  9163 = abc_30082_auto_rtlil_cc_2608_muxgate_29637
* NET  9164 = abc_30082_auto_rtlil_cc_2608_muxgate_29635
* NET  9165 = abc_30082_auto_rtlil_cc_2608_muxgate_29633
* NET  9166 = abc_30082_auto_rtlil_cc_2608_muxgate_29631
* NET  9167 = abc_30082_auto_rtlil_cc_2608_muxgate_29629
* NET  9168 = abc_30082_auto_rtlil_cc_2608_muxgate_29627
* NET  9169 = abc_30082_auto_rtlil_cc_2608_muxgate_29625
* NET  9170 = abc_30082_auto_rtlil_cc_2608_muxgate_29623
* NET  9171 = abc_30082_auto_rtlil_cc_2608_muxgate_29621
* NET  9172 = abc_30082_auto_rtlil_cc_2608_muxgate_29619
* NET  9173 = abc_30082_auto_rtlil_cc_2608_muxgate_29617
* NET  9174 = abc_30082_auto_rtlil_cc_2608_muxgate_29615
* NET  9175 = abc_30082_auto_rtlil_cc_2608_muxgate_29613
* NET  9176 = abc_30082_auto_rtlil_cc_2608_muxgate_29611
* NET  9177 = abc_30082_auto_rtlil_cc_2608_muxgate_29609
* NET  9178 = abc_30082_auto_rtlil_cc_2608_muxgate_29607
* NET  9179 = abc_30082_auto_rtlil_cc_2608_muxgate_29605
* NET  9180 = abc_30082_auto_rtlil_cc_2608_muxgate_29603
* NET  9181 = abc_30082_auto_rtlil_cc_2608_muxgate_29601
* NET  9182 = abc_30082_auto_rtlil_cc_2608_muxgate_29599
* NET  9183 = abc_30082_auto_rtlil_cc_2608_muxgate_29597
* NET  9184 = abc_30082_auto_rtlil_cc_2608_muxgate_29595
* NET  9185 = abc_30082_auto_rtlil_cc_2608_muxgate_29593
* NET  9186 = abc_30082_auto_rtlil_cc_2608_muxgate_29591
* NET  9187 = abc_30082_auto_rtlil_cc_2608_muxgate_29589
* NET  9188 = abc_30082_auto_rtlil_cc_2608_muxgate_29587
* NET  9189 = abc_30082_auto_rtlil_cc_2608_muxgate_29585
* NET  9190 = abc_30082_auto_rtlil_cc_2608_muxgate_29583
* NET  9191 = abc_30082_auto_rtlil_cc_2608_muxgate_29581
* NET  9192 = abc_30082_auto_rtlil_cc_2608_muxgate_29579
* NET  9193 = abc_30082_auto_rtlil_cc_2608_muxgate_29577
* NET  9194 = abc_30082_auto_rtlil_cc_2608_muxgate_29575
* NET  9195 = abc_30082_auto_rtlil_cc_2608_muxgate_29573
* NET  9196 = abc_30082_auto_rtlil_cc_2608_muxgate_29571
* NET  9197 = abc_30082_auto_rtlil_cc_2608_muxgate_29569
* NET  9198 = abc_30082_auto_rtlil_cc_2608_muxgate_29567
* NET  9199 = abc_30082_auto_rtlil_cc_2608_muxgate_29565
* NET  9200 = abc_30082_auto_rtlil_cc_2608_muxgate_29563
* NET  9201 = abc_30082_auto_rtlil_cc_2608_muxgate_29561
* NET  9202 = abc_30082_auto_rtlil_cc_2608_muxgate_29559
* NET  9203 = abc_30082_auto_rtlil_cc_2608_muxgate_29557
* NET  9204 = abc_30082_auto_rtlil_cc_2608_muxgate_29555
* NET  9205 = abc_30082_auto_rtlil_cc_2608_muxgate_29553
* NET  9206 = abc_30082_auto_rtlil_cc_2608_muxgate_29551
* NET  9207 = abc_30082_auto_rtlil_cc_2608_muxgate_29549
* NET  9208 = abc_30082_auto_rtlil_cc_2608_muxgate_29547
* NET  9209 = abc_30082_auto_rtlil_cc_2608_muxgate_29545
* NET  9210 = abc_30082_auto_rtlil_cc_2608_muxgate_29543
* NET  9211 = abc_30082_auto_rtlil_cc_2608_muxgate_29541
* NET  9212 = abc_30082_auto_rtlil_cc_2608_muxgate_29539
* NET  9213 = abc_30082_auto_rtlil_cc_2608_muxgate_29537
* NET  9214 = abc_30082_auto_rtlil_cc_2608_muxgate_29535
* NET  9215 = abc_30082_auto_rtlil_cc_2608_muxgate_29533
* NET  9216 = abc_30082_auto_rtlil_cc_2608_muxgate_29531
* NET  9217 = abc_30082_auto_rtlil_cc_2608_muxgate_29529
* NET  9218 = abc_30082_auto_rtlil_cc_2608_muxgate_29527
* NET  9219 = abc_30082_auto_rtlil_cc_2608_muxgate_29525
* NET  9220 = abc_30082_auto_rtlil_cc_2608_muxgate_29523
* NET  9221 = abc_30082_auto_rtlil_cc_2608_muxgate_29521
* NET  9222 = abc_30082_auto_rtlil_cc_2608_muxgate_29519
* NET  9223 = abc_30082_auto_rtlil_cc_2608_muxgate_29517
* NET  9224 = abc_30082_auto_rtlil_cc_2608_muxgate_29515
* NET  9225 = abc_30082_auto_rtlil_cc_2608_muxgate_29513
* NET  9226 = abc_30082_auto_rtlil_cc_2608_muxgate_29511
* NET  9227 = abc_30082_auto_rtlil_cc_2608_muxgate_29509
* NET  9228 = abc_30082_auto_rtlil_cc_2608_muxgate_29507
* NET  9229 = abc_30082_auto_rtlil_cc_2608_muxgate_29505
* NET  9230 = abc_30082_auto_rtlil_cc_2608_muxgate_29503
* NET  9231 = abc_30082_auto_rtlil_cc_2608_muxgate_29501
* NET  9232 = abc_30082_auto_rtlil_cc_2608_muxgate_29499
* NET  9233 = abc_30082_auto_rtlil_cc_2608_muxgate_29497
* NET  9234 = abc_30082_auto_rtlil_cc_2608_muxgate_29495
* NET  9235 = abc_30082_auto_rtlil_cc_2608_muxgate_29493
* NET  9236 = abc_30082_auto_rtlil_cc_2608_muxgate_29491
* NET  9237 = abc_30082_auto_rtlil_cc_2608_muxgate_29489
* NET  9238 = abc_30082_auto_rtlil_cc_2608_muxgate_29487
* NET  9239 = abc_30082_auto_rtlil_cc_2608_muxgate_29485
* NET  9240 = abc_30082_auto_rtlil_cc_2608_muxgate_29483
* NET  9241 = abc_30082_auto_rtlil_cc_2608_muxgate_29481
* NET  9242 = abc_30082_auto_rtlil_cc_2608_muxgate_29479
* NET  9243 = abc_30082_auto_rtlil_cc_2608_muxgate_29477
* NET  9244 = abc_30082_auto_rtlil_cc_2608_muxgate_29475
* NET  9245 = abc_30082_auto_rtlil_cc_2608_muxgate_29473
* NET  9246 = abc_30082_auto_rtlil_cc_2608_muxgate_29471
* NET  9247 = abc_30082_auto_rtlil_cc_2608_muxgate_29469
* NET  9248 = abc_30082_auto_rtlil_cc_2608_muxgate_29467
* NET  9249 = abc_30082_auto_rtlil_cc_2608_muxgate_29465
* NET  9250 = abc_30082_auto_rtlil_cc_2608_muxgate_29463
* NET  9251 = abc_30082_auto_rtlil_cc_2608_muxgate_29461
* NET  9252 = abc_30082_auto_rtlil_cc_2608_muxgate_29459
* NET  9253 = abc_30082_auto_rtlil_cc_2608_muxgate_29457
* NET  9254 = abc_30082_auto_rtlil_cc_2608_muxgate_29455
* NET  9255 = abc_30082_auto_rtlil_cc_2608_muxgate_29453
* NET  9256 = abc_30082_auto_rtlil_cc_2608_muxgate_29451
* NET  9257 = abc_30082_auto_rtlil_cc_2608_muxgate_29449
* NET  9258 = abc_30082_auto_rtlil_cc_2608_muxgate_29447
* NET  9259 = abc_30082_auto_rtlil_cc_2608_muxgate_29445
* NET  9260 = abc_30082_auto_rtlil_cc_2608_muxgate_29443
* NET  9261 = abc_30082_auto_rtlil_cc_2608_muxgate_29441
* NET  9262 = abc_30082_auto_rtlil_cc_2608_muxgate_29439
* NET  9263 = abc_30082_auto_rtlil_cc_2608_muxgate_29437
* NET  9264 = abc_30082_auto_rtlil_cc_2608_muxgate_29435
* NET  9265 = abc_30082_auto_rtlil_cc_2608_muxgate_29433
* NET  9266 = abc_30082_auto_rtlil_cc_2608_muxgate_29431
* NET  9267 = abc_30082_auto_rtlil_cc_2608_muxgate_29429
* NET  9268 = abc_30082_auto_rtlil_cc_2608_muxgate_29427
* NET  9269 = abc_30082_auto_rtlil_cc_2608_muxgate_29425
* NET  9270 = abc_30082_auto_rtlil_cc_2608_muxgate_29423
* NET  9271 = abc_30082_auto_rtlil_cc_2608_muxgate_29421
* NET  9272 = abc_30082_auto_rtlil_cc_2608_muxgate_29419
* NET  9273 = abc_30082_auto_rtlil_cc_2608_muxgate_29417
* NET  9274 = abc_30082_auto_rtlil_cc_2608_muxgate_29415
* NET  9275 = abc_30082_auto_rtlil_cc_2608_muxgate_29413
* NET  9276 = abc_30082_auto_rtlil_cc_2608_muxgate_29411
* NET  9277 = abc_30082_auto_rtlil_cc_2608_muxgate_29409
* NET  9278 = abc_30082_auto_rtlil_cc_2608_muxgate_29407
* NET  9279 = abc_30082_auto_rtlil_cc_2608_muxgate_29405
* NET  9280 = abc_30082_auto_rtlil_cc_2608_muxgate_29403
* NET  9281 = abc_30082_auto_rtlil_cc_2608_muxgate_29401
* NET  9282 = abc_30082_auto_rtlil_cc_2608_muxgate_29399
* NET  9283 = abc_30082_auto_rtlil_cc_2608_muxgate_29397
* NET  9284 = abc_30082_auto_rtlil_cc_2608_muxgate_29395
* NET  9285 = abc_30082_auto_rtlil_cc_2608_muxgate_29393
* NET  9286 = abc_30082_auto_rtlil_cc_2608_muxgate_29391
* NET  9287 = abc_30082_auto_rtlil_cc_2608_muxgate_29389
* NET  9288 = abc_30082_auto_rtlil_cc_2608_muxgate_29387
* NET  9289 = abc_30082_auto_rtlil_cc_2608_muxgate_29385
* NET  9290 = abc_30082_auto_rtlil_cc_2608_muxgate_29383
* NET  9291 = abc_30082_auto_rtlil_cc_2608_muxgate_29381
* NET  9292 = abc_30082_auto_rtlil_cc_2608_muxgate_29379
* NET  9293 = abc_30082_auto_rtlil_cc_2608_muxgate_29377
* NET  9294 = abc_30082_auto_rtlil_cc_2608_muxgate_29375
* NET  9295 = abc_30082_auto_rtlil_cc_2608_muxgate_29373
* NET  9296 = abc_30082_auto_rtlil_cc_2608_muxgate_29371
* NET  9297 = abc_30082_auto_rtlil_cc_2608_muxgate_29369
* NET  9298 = abc_30082_auto_rtlil_cc_2608_muxgate_29367
* NET  9299 = abc_30082_auto_rtlil_cc_2608_muxgate_29365
* NET  9300 = abc_30082_auto_rtlil_cc_2608_muxgate_29363
* NET  9301 = abc_30082_auto_rtlil_cc_2608_muxgate_29361
* NET  9302 = abc_30082_auto_rtlil_cc_2608_muxgate_29359
* NET  9303 = abc_30082_auto_rtlil_cc_2608_muxgate_29357
* NET  9304 = abc_30082_auto_rtlil_cc_2608_muxgate_29355
* NET  9305 = abc_30082_auto_rtlil_cc_2608_muxgate_29353
* NET  9306 = abc_30082_auto_rtlil_cc_2608_muxgate_29351
* NET  9307 = abc_30082_auto_rtlil_cc_2608_muxgate_29349
* NET  9308 = abc_30082_auto_rtlil_cc_2608_muxgate_29347
* NET  9309 = abc_30082_auto_rtlil_cc_2608_muxgate_29345
* NET  9310 = abc_30082_auto_rtlil_cc_2608_muxgate_29343
* NET  9311 = abc_30082_auto_rtlil_cc_2608_muxgate_29341
* NET  9312 = abc_30082_auto_rtlil_cc_2608_muxgate_29339
* NET  9313 = abc_30082_auto_rtlil_cc_2608_muxgate_29337
* NET  9314 = abc_30082_auto_rtlil_cc_2608_muxgate_29335
* NET  9315 = abc_30082_auto_rtlil_cc_2608_muxgate_29333
* NET  9316 = abc_30082_auto_rtlil_cc_2608_muxgate_29331
* NET  9317 = abc_30082_auto_rtlil_cc_2608_muxgate_29329
* NET  9318 = abc_30082_auto_rtlil_cc_2608_muxgate_29327
* NET  9319 = abc_30082_auto_rtlil_cc_2608_muxgate_29325
* NET  9320 = abc_30082_auto_rtlil_cc_2608_muxgate_29323
* NET  9321 = abc_30082_auto_rtlil_cc_2608_muxgate_29321
* NET  9322 = abc_30082_auto_rtlil_cc_2608_muxgate_29319
* NET  9323 = abc_30082_auto_rtlil_cc_2608_muxgate_29317
* NET  9324 = abc_30082_auto_rtlil_cc_2608_muxgate_29315
* NET  9325 = abc_30082_auto_rtlil_cc_2608_muxgate_29313
* NET  9326 = abc_30082_auto_rtlil_cc_2608_muxgate_29311
* NET  9327 = abc_30082_auto_rtlil_cc_2608_muxgate_29309
* NET  9328 = abc_30082_auto_rtlil_cc_2608_muxgate_29307
* NET  9329 = abc_30082_auto_rtlil_cc_2608_muxgate_29305
* NET  9330 = abc_30082_auto_rtlil_cc_2608_muxgate_29303
* NET  9331 = abc_30082_auto_rtlil_cc_2608_muxgate_29301
* NET  9332 = abc_30082_auto_rtlil_cc_2608_muxgate_29299
* NET  9333 = abc_30082_auto_rtlil_cc_2608_muxgate_29297
* NET  9334 = abc_30082_auto_rtlil_cc_2608_muxgate_29295
* NET  9335 = abc_30082_auto_rtlil_cc_2608_muxgate_29293
* NET  9336 = abc_30082_auto_rtlil_cc_2608_muxgate_29291
* NET  9337 = abc_30082_auto_rtlil_cc_2608_muxgate_29289
* NET  9338 = abc_30082_auto_rtlil_cc_2608_muxgate_29287
* NET  9339 = abc_30082_auto_rtlil_cc_2608_muxgate_29285
* NET  9340 = abc_30082_auto_rtlil_cc_2608_muxgate_29283
* NET  9341 = abc_30082_auto_rtlil_cc_2608_muxgate_29281
* NET  9342 = abc_30082_auto_rtlil_cc_2608_muxgate_29279
* NET  9343 = abc_30082_auto_rtlil_cc_2608_muxgate_29277
* NET  9344 = abc_30082_auto_rtlil_cc_2608_muxgate_29275
* NET  9345 = abc_30082_auto_rtlil_cc_2608_muxgate_29273
* NET  9346 = abc_30082_auto_rtlil_cc_2608_muxgate_29271
* NET  9347 = abc_30082_auto_rtlil_cc_2608_muxgate_29269
* NET  9348 = abc_30082_auto_rtlil_cc_2608_muxgate_29267
* NET  9349 = abc_30082_auto_rtlil_cc_2608_muxgate_29265
* NET  9350 = abc_30082_auto_rtlil_cc_2608_muxgate_29263
* NET  9351 = abc_30082_auto_rtlil_cc_2608_muxgate_29261
* NET  9352 = abc_30082_auto_rtlil_cc_2608_muxgate_29259
* NET  9353 = abc_30082_auto_rtlil_cc_2608_muxgate_29257
* NET  9354 = abc_30082_auto_rtlil_cc_2608_muxgate_29255
* NET  9355 = abc_30082_auto_rtlil_cc_2608_muxgate_29253
* NET  9356 = abc_30082_auto_rtlil_cc_2608_muxgate_29251
* NET  9357 = abc_30082_auto_rtlil_cc_2608_muxgate_29249
* NET  9358 = abc_30082_auto_rtlil_cc_2608_muxgate_29247
* NET  9359 = abc_30082_auto_rtlil_cc_2608_muxgate_29245
* NET  9360 = abc_30082_auto_rtlil_cc_2608_muxgate_29243
* NET  9361 = abc_30082_auto_rtlil_cc_2608_muxgate_29241
* NET  9362 = abc_30082_auto_rtlil_cc_2608_muxgate_29239
* NET  9363 = abc_30082_auto_rtlil_cc_2608_muxgate_29237
* NET  9364 = abc_30082_auto_rtlil_cc_2608_muxgate_29235
* NET  9365 = abc_30082_auto_rtlil_cc_2608_muxgate_29233
* NET  9366 = abc_30082_auto_rtlil_cc_2608_muxgate_29231
* NET  9367 = abc_30082_auto_rtlil_cc_2608_muxgate_29229
* NET  9368 = abc_30082_auto_rtlil_cc_2608_muxgate_29227
* NET  9369 = abc_30082_auto_rtlil_cc_2608_muxgate_29225
* NET  9370 = abc_30082_auto_rtlil_cc_2608_muxgate_29223
* NET  9371 = abc_30082_auto_rtlil_cc_2608_muxgate_29221
* NET  9372 = abc_30082_auto_rtlil_cc_2608_muxgate_29219
* NET  9373 = abc_30082_auto_rtlil_cc_2608_muxgate_29217
* NET  9374 = abc_30082_auto_rtlil_cc_2608_muxgate_29215
* NET  9375 = abc_30082_auto_rtlil_cc_2608_muxgate_29213
* NET  9376 = abc_30082_auto_rtlil_cc_2608_muxgate_29211
* NET  9377 = abc_30082_auto_rtlil_cc_2608_muxgate_29209
* NET  9378 = abc_30082_auto_rtlil_cc_2608_muxgate_29207
* NET  9379 = abc_30082_auto_rtlil_cc_2608_muxgate_29205
* NET  9380 = abc_30082_auto_rtlil_cc_2608_muxgate_29203
* NET  9381 = abc_30082_auto_rtlil_cc_2608_muxgate_29201
* NET  9382 = abc_30082_auto_rtlil_cc_2608_muxgate_29199
* NET  9383 = abc_30082_auto_rtlil_cc_2608_muxgate_29197
* NET  9384 = abc_30082_auto_rtlil_cc_2608_muxgate_29195
* NET  9385 = abc_30082_auto_rtlil_cc_2608_muxgate_29193
* NET  9386 = abc_30082_auto_rtlil_cc_2608_muxgate_29191
* NET  9387 = abc_30082_auto_rtlil_cc_2608_muxgate_29189
* NET  9388 = abc_30082_auto_rtlil_cc_2608_muxgate_29187
* NET  9389 = abc_30082_auto_rtlil_cc_2608_muxgate_29185
* NET  9390 = abc_30082_auto_rtlil_cc_2608_muxgate_29183
* NET  9391 = abc_30082_auto_rtlil_cc_2608_muxgate_29181
* NET  9392 = abc_30082_auto_rtlil_cc_2608_muxgate_29179
* NET  9393 = abc_30082_auto_rtlil_cc_2608_muxgate_29177
* NET  9394 = abc_30082_auto_rtlil_cc_2608_muxgate_29175
* NET  9395 = abc_30082_auto_rtlil_cc_2608_muxgate_29173
* NET  9396 = abc_30082_auto_rtlil_cc_2608_muxgate_29171
* NET  9397 = abc_30082_auto_rtlil_cc_2608_muxgate_29169
* NET  9398 = abc_30082_auto_rtlil_cc_2608_muxgate_29167
* NET  9399 = abc_30082_auto_rtlil_cc_2608_muxgate_29165
* NET  9400 = abc_30082_auto_rtlil_cc_2608_muxgate_29163
* NET  9401 = abc_30082_auto_rtlil_cc_2608_muxgate_29161
* NET  9402 = abc_30082_auto_rtlil_cc_2608_muxgate_29159
* NET  9403 = abc_30082_auto_rtlil_cc_2608_muxgate_29157
* NET  9404 = abc_30082_auto_rtlil_cc_2608_muxgate_29155
* NET  9405 = abc_30082_auto_rtlil_cc_2608_muxgate_29153
* NET  9406 = abc_30082_auto_rtlil_cc_2608_muxgate_29151
* NET  9407 = abc_30082_auto_rtlil_cc_2608_muxgate_29149
* NET  9408 = abc_30082_auto_rtlil_cc_2608_muxgate_29147
* NET  9409 = abc_30082_auto_rtlil_cc_2608_muxgate_29145
* NET  9410 = abc_30082_auto_rtlil_cc_2608_muxgate_29143
* NET  9411 = abc_30082_auto_rtlil_cc_2608_muxgate_29141
* NET  9412 = abc_30082_auto_rtlil_cc_2608_muxgate_29139
* NET  9413 = abc_30082_auto_rtlil_cc_2608_muxgate_29137
* NET  9414 = abc_30082_auto_rtlil_cc_2608_muxgate_29135
* NET  9415 = abc_30082_auto_rtlil_cc_2608_muxgate_29133
* NET  9416 = abc_30082_auto_rtlil_cc_2608_muxgate_29131
* NET  9417 = abc_30082_auto_rtlil_cc_2608_muxgate_29129
* NET  9418 = abc_30082_auto_rtlil_cc_2608_muxgate_29127
* NET  9419 = abc_30082_auto_rtlil_cc_2608_muxgate_29125
* NET  9420 = abc_30082_auto_rtlil_cc_2608_muxgate_29123
* NET  9421 = abc_30082_auto_rtlil_cc_2608_muxgate_29121
* NET  9422 = abc_30082_auto_rtlil_cc_2608_muxgate_29119
* NET  9423 = abc_30082_auto_rtlil_cc_2608_muxgate_29117
* NET  9424 = abc_30082_auto_rtlil_cc_2608_muxgate_29115
* NET  9425 = abc_30082_auto_rtlil_cc_2608_muxgate_29113
* NET  9426 = abc_30082_auto_rtlil_cc_2608_muxgate_29111
* NET  9427 = abc_30082_auto_rtlil_cc_2608_muxgate_29109
* NET  9428 = abc_30082_auto_rtlil_cc_2608_muxgate_29107
* NET  9429 = abc_30082_auto_rtlil_cc_2608_muxgate_29105
* NET  9430 = abc_30082_auto_rtlil_cc_2608_muxgate_29103
* NET  9431 = abc_30082_auto_rtlil_cc_2608_muxgate_29101
* NET  9432 = abc_30082_auto_rtlil_cc_2608_muxgate_29099
* NET  9433 = abc_30082_auto_rtlil_cc_2608_muxgate_29097
* NET  9434 = abc_30082_auto_rtlil_cc_2608_muxgate_29095
* NET  9435 = abc_30082_auto_rtlil_cc_2608_muxgate_29093
* NET  9436 = abc_30082_auto_rtlil_cc_2608_muxgate_29091
* NET  9437 = abc_30082_auto_rtlil_cc_2608_muxgate_29089
* NET  9438 = abc_30082_auto_rtlil_cc_2608_muxgate_29087
* NET  9439 = abc_30082_auto_rtlil_cc_2608_muxgate_29085
* NET  9440 = abc_30082_auto_rtlil_cc_2608_muxgate_29083
* NET  9441 = abc_30082_auto_rtlil_cc_2608_muxgate_29081
* NET  9442 = abc_30082_auto_rtlil_cc_2608_muxgate_29079
* NET  9443 = abc_30082_auto_rtlil_cc_2608_muxgate_29077
* NET  9444 = abc_30082_auto_rtlil_cc_2608_muxgate_29075
* NET  9445 = abc_30082_auto_rtlil_cc_2608_muxgate_29073
* NET  9446 = abc_30082_auto_rtlil_cc_2608_muxgate_29071
* NET  9447 = abc_30082_auto_rtlil_cc_2608_muxgate_29069
* NET  9448 = abc_30082_auto_rtlil_cc_2608_muxgate_29067
* NET  9449 = abc_30082_auto_rtlil_cc_2608_muxgate_29065
* NET  9450 = abc_30082_auto_rtlil_cc_2608_muxgate_29063
* NET  9451 = abc_30082_auto_rtlil_cc_2608_muxgate_29061
* NET  9452 = abc_30082_auto_rtlil_cc_2608_muxgate_29059
* NET  9453 = abc_30082_auto_rtlil_cc_2608_muxgate_29057
* NET  9454 = abc_30082_auto_rtlil_cc_2608_muxgate_29055
* NET  9455 = abc_30082_auto_rtlil_cc_2608_muxgate_29053
* NET  9456 = abc_30082_auto_rtlil_cc_2608_muxgate_29051
* NET  9457 = abc_30082_auto_rtlil_cc_2608_muxgate_29049
* NET  9458 = abc_30082_auto_rtlil_cc_2608_muxgate_29047
* NET  9459 = abc_30082_auto_rtlil_cc_2608_muxgate_29045
* NET  9460 = abc_30082_auto_rtlil_cc_2608_muxgate_29043
* NET  9461 = abc_30082_auto_rtlil_cc_2608_muxgate_29041
* NET  9462 = abc_30082_auto_rtlil_cc_2608_muxgate_29039
* NET  9463 = abc_30082_auto_rtlil_cc_2608_muxgate_29037
* NET  9464 = abc_30082_auto_rtlil_cc_2608_muxgate_29035
* NET  9465 = abc_30082_auto_rtlil_cc_2608_muxgate_29033
* NET  9466 = abc_30082_auto_rtlil_cc_2608_muxgate_29031
* NET  9467 = abc_30082_auto_rtlil_cc_2608_muxgate_29029
* NET  9468 = abc_30082_auto_rtlil_cc_2608_muxgate_29027
* NET  9469 = abc_30082_auto_rtlil_cc_2608_muxgate_29025
* NET  9470 = abc_30082_auto_rtlil_cc_2608_muxgate_29023
* NET  9471 = abc_30082_auto_rtlil_cc_2608_muxgate_29021
* NET  9472 = abc_30082_auto_rtlil_cc_2608_muxgate_29019
* NET  9473 = abc_30082_auto_rtlil_cc_2608_muxgate_29017
* NET  9474 = abc_30082_auto_rtlil_cc_2608_muxgate_29015
* NET  9475 = abc_30082_auto_rtlil_cc_2608_muxgate_29013
* NET  9476 = abc_30082_auto_rtlil_cc_2608_muxgate_29011
* NET  9477 = abc_30082_auto_rtlil_cc_2608_muxgate_29009
* NET  9478 = abc_30082_auto_rtlil_cc_2608_muxgate_29007
* NET  9479 = abc_30082_auto_rtlil_cc_2608_muxgate_29005
* NET  9480 = abc_30082_auto_rtlil_cc_2608_muxgate_29003
* NET  9481 = abc_30082_auto_rtlil_cc_2608_muxgate_29001
* NET  9482 = abc_30082_auto_rtlil_cc_2608_muxgate_28999
* NET  9483 = abc_30082_auto_rtlil_cc_2608_muxgate_28997
* NET  9484 = abc_30082_auto_rtlil_cc_2608_muxgate_28995
* NET  9485 = abc_30082_auto_rtlil_cc_2608_muxgate_28993
* NET  9486 = abc_30082_auto_rtlil_cc_2608_muxgate_28991
* NET  9487 = abc_30082_auto_rtlil_cc_2608_muxgate_28989
* NET  9488 = abc_30082_auto_rtlil_cc_2608_muxgate_28985
* NET  9489 = abc_30082_auto_rtlil_cc_2608_muxgate_28981
* NET  9490 = abc_30082_auto_rtlil_cc_2608_muxgate_28977
* NET  9491 = abc_30082_auto_rtlil_cc_2608_muxgate_28973
* NET  9492 = abc_30082_auto_rtlil_cc_2608_muxgate_28969
* NET  9493 = abc_30082_auto_rtlil_cc_2608_muxgate_28965
* NET  9494 = abc_30082_auto_rtlil_cc_2608_muxgate_28961
* NET  9495 = abc_30082_auto_rtlil_cc_2608_muxgate_28957
* NET  9496 = abc_30082_auto_rtlil_cc_2608_muxgate_28953
* NET  9497 = abc_30082_auto_rtlil_cc_2608_muxgate_28949
* NET  9498 = abc_30082_auto_rtlil_cc_2608_muxgate_28945
* NET  9499 = abc_30082_auto_rtlil_cc_2608_muxgate_28941
* NET  9500 = abc_30082_auto_rtlil_cc_2608_muxgate_28937
* NET  9501 = abc_30082_auto_rtlil_cc_2608_muxgate_28933
* NET  9502 = abc_30082_auto_rtlil_cc_2608_muxgate_28929
* NET  9503 = abc_30082_auto_rtlil_cc_2608_muxgate_28925
* NET  9504 = abc_30082_auto_rtlil_cc_2608_muxgate_28921
* NET  9505 = abc_30082_auto_rtlil_cc_2608_muxgate_28917
* NET  9506 = abc_30082_auto_rtlil_cc_2608_muxgate_28913
* NET  9507 = abc_30082_auto_rtlil_cc_2608_muxgate_28909
* NET  9508 = abc_30082_auto_rtlil_cc_2608_muxgate_28905
* NET  9509 = abc_30082_auto_rtlil_cc_2608_muxgate_28901
* NET  9510 = abc_30082_auto_rtlil_cc_2608_muxgate_28897
* NET  9511 = abc_30082_auto_rtlil_cc_2608_muxgate_28893
* NET  9512 = abc_30082_auto_rtlil_cc_2608_muxgate_28889
* NET  9513 = abc_30082_auto_rtlil_cc_2608_muxgate_28885
* NET  9514 = abc_30082_auto_rtlil_cc_2608_muxgate_28881
* NET  9515 = abc_30082_auto_rtlil_cc_2608_muxgate_28877
* NET  9516 = abc_30082_auto_rtlil_cc_2608_muxgate_28873
* NET  9517 = abc_30082_auto_rtlil_cc_2608_muxgate_28869
* NET  9518 = abc_30082_auto_rtlil_cc_2608_muxgate_28865
* NET  9519 = abc_30082_auto_rtlil_cc_2608_muxgate_28863
* NET  9520 = abc_30082_auto_rtlil_cc_2608_muxgate_28861
* NET  9521 = abc_30082_auto_rtlil_cc_2608_muxgate_28857
* NET  9522 = abc_30082_auto_rtlil_cc_2608_muxgate_28853
* NET  9523 = abc_30082_auto_rtlil_cc_2608_muxgate_28849
* NET  9524 = abc_30082_auto_rtlil_cc_2608_muxgate_28845
* NET  9525 = abc_30082_auto_rtlil_cc_2608_muxgate_28841
* NET  9526 = abc_30082_auto_rtlil_cc_2608_muxgate_28839
* NET  9527 = abc_30082_auto_rtlil_cc_2608_muxgate_28837
* NET  9528 = abc_30082_auto_rtlil_cc_2608_muxgate_28835
* NET  9529 = abc_30082_auto_rtlil_cc_2608_muxgate_28833
* NET  9530 = abc_30082_auto_rtlil_cc_2608_muxgate_28831
* NET  9531 = abc_30082_auto_rtlil_cc_2608_muxgate_28829
* NET  9532 = abc_30082_auto_rtlil_cc_2608_muxgate_28827
* NET  9533 = abc_30082_auto_rtlil_cc_2608_muxgate_28825
* NET  9534 = abc_30082_auto_rtlil_cc_2608_muxgate_28823
* NET  9535 = abc_30082_auto_rtlil_cc_2608_muxgate_28821
* NET  9536 = abc_30082_auto_rtlil_cc_2608_muxgate_28819
* NET  9537 = abc_30082_auto_rtlil_cc_2608_muxgate_28817
* NET  9538 = abc_30082_auto_rtlil_cc_2608_muxgate_28815
* NET  9539 = abc_30082_auto_rtlil_cc_2608_muxgate_28813
* NET  9540 = abc_30082_auto_rtlil_cc_2608_muxgate_28811
* NET  9541 = abc_30082_auto_rtlil_cc_2608_muxgate_28809
* NET  9542 = abc_30082_auto_rtlil_cc_2608_muxgate_28807
* NET  9543 = abc_30082_auto_rtlil_cc_2608_muxgate_28805
* NET  9544 = abc_30082_auto_rtlil_cc_2608_muxgate_28803
* NET  9545 = abc_30082_auto_rtlil_cc_2608_muxgate_28801
* NET  9546 = abc_30082_auto_rtlil_cc_2608_muxgate_28799
* NET  9547 = abc_30082_auto_rtlil_cc_2608_muxgate_28797
* NET  9548 = abc_30082_auto_rtlil_cc_2608_muxgate_28795
* NET  9549 = abc_30082_auto_rtlil_cc_2608_muxgate_28793
* NET  9550 = abc_30082_auto_rtlil_cc_2608_muxgate_28791
* NET  9551 = abc_30082_auto_rtlil_cc_2608_muxgate_28789
* NET  9552 = abc_30082_auto_rtlil_cc_2608_muxgate_28787
* NET  9553 = abc_30082_auto_rtlil_cc_2608_muxgate_28785
* NET  9554 = abc_30082_auto_rtlil_cc_2608_muxgate_28783
* NET  9555 = abc_30082_auto_rtlil_cc_2608_muxgate_28781
* NET  9556 = abc_30082_auto_rtlil_cc_2608_muxgate_28779
* NET  9557 = abc_30082_auto_rtlil_cc_2608_muxgate_28777
* NET  9558 = abc_30082_auto_rtlil_cc_2608_muxgate_28775
* NET  9559 = abc_30082_auto_rtlil_cc_2608_muxgate_28773
* NET  9560 = abc_30082_auto_rtlil_cc_2608_muxgate_28771
* NET  9561 = abc_30082_auto_rtlil_cc_2608_muxgate_28769
* NET  9562 = abc_30082_auto_rtlil_cc_2608_muxgate_28765
* NET  9563 = abc_30082_auto_rtlil_cc_2608_muxgate_28761
* NET  9564 = abc_30082_auto_rtlil_cc_2608_muxgate_28757
* NET  9565 = abc_30082_auto_rtlil_cc_2608_muxgate_28755
* NET  9566 = abc_30082_auto_rtlil_cc_2608_muxgate_28753
* NET  9567 = abc_30082_auto_rtlil_cc_2608_muxgate_28751
* NET  9568 = abc_30082_auto_rtlil_cc_2608_muxgate_28749
* NET  9569 = abc_30082_auto_rtlil_cc_2608_muxgate_28747
* NET  9570 = abc_30082_auto_rtlil_cc_2608_muxgate_28745
* NET  9571 = abc_30082_auto_rtlil_cc_2608_muxgate_28743
* NET  9572 = abc_30082_auto_rtlil_cc_2608_muxgate_28741
* NET  9573 = abc_30082_auto_rtlil_cc_2608_muxgate_28739
* NET  9574 = abc_30082_auto_rtlil_cc_2608_muxgate_28737
* NET  9575 = abc_30082_auto_rtlil_cc_2608_muxgate_28735
* NET  9576 = abc_30082_auto_rtlil_cc_2608_muxgate_28733
* NET  9577 = abc_30082_auto_rtlil_cc_2608_muxgate_28731
* NET  9578 = abc_30082_auto_rtlil_cc_2608_muxgate_28729
* NET  9579 = abc_30082_auto_rtlil_cc_2608_muxgate_28727
* NET  9580 = abc_30082_auto_rtlil_cc_2608_muxgate_28725
* NET  9581 = abc_30082_auto_rtlil_cc_2608_muxgate_28723
* NET  9582 = abc_30082_auto_rtlil_cc_2608_muxgate_28721
* NET  9583 = abc_30082_auto_rtlil_cc_2608_muxgate_28719
* NET  9584 = abc_30082_auto_rtlil_cc_2608_muxgate_28717
* NET  9585 = abc_30082_auto_rtlil_cc_2608_muxgate_28715
* NET  9586 = abc_30082_auto_rtlil_cc_2608_muxgate_28713
* NET  9587 = abc_30082_auto_rtlil_cc_2608_muxgate_28711
* NET  9588 = abc_30082_auto_rtlil_cc_2608_muxgate_28709
* NET  9589 = abc_30082_auto_rtlil_cc_2608_muxgate_28707
* NET  9590 = abc_30082_auto_rtlil_cc_2608_muxgate_28705
* NET  9591 = abc_30082_auto_rtlil_cc_2608_muxgate_28703
* NET  9592 = abc_30082_auto_rtlil_cc_2608_muxgate_28701
* NET  9593 = abc_30082_auto_rtlil_cc_2608_muxgate_28699
* NET  9594 = abc_30082_auto_rtlil_cc_2608_muxgate_28697
* NET  9595 = abc_30082_auto_rtlil_cc_2608_muxgate_28695
* NET  9596 = abc_30082_auto_rtlil_cc_2608_muxgate_28693
* NET  9597 = abc_30082_auto_rtlil_cc_2608_muxgate_28691
* NET  9598 = abc_30082_auto_rtlil_cc_2608_muxgate_28689
* NET  9599 = abc_30082_auto_rtlil_cc_2608_muxgate_28687
* NET  9600 = abc_30082_auto_rtlil_cc_2608_muxgate_28683
* NET  9601 = abc_30082_auto_rtlil_cc_2608_muxgate_28681
* NET  9602 = abc_30082_auto_rtlil_cc_2608_muxgate_28679
* NET  9603 = abc_30082_auto_rtlil_cc_2608_muxgate_28677
* NET  9604 = abc_30082_auto_rtlil_cc_2608_muxgate_28675
* NET  9605 = abc_30082_auto_rtlil_cc_2608_muxgate_28673
* NET  9606 = abc_30082_auto_rtlil_cc_2608_muxgate_28671
* NET  9607 = abc_30082_auto_rtlil_cc_2608_muxgate_28669
* NET  9608 = abc_30082_auto_rtlil_cc_2608_muxgate_28667
* NET  9609 = abc_30082_auto_rtlil_cc_2608_muxgate_28665
* NET  9610 = abc_30082_auto_rtlil_cc_2608_muxgate_28663
* NET  9611 = abc_30082_auto_rtlil_cc_2608_muxgate_28661
* NET  9612 = abc_30082_auto_rtlil_cc_2608_muxgate_28659
* NET  9613 = abc_30082_auto_rtlil_cc_2608_muxgate_28657
* NET  9614 = abc_30082_auto_rtlil_cc_2608_muxgate_28655
* NET  9615 = abc_30082_auto_rtlil_cc_2608_muxgate_28653
* NET  9616 = abc_30082_auto_rtlil_cc_2608_muxgate_28651
* NET  9617 = abc_30082_auto_rtlil_cc_2608_muxgate_28649
* NET  9618 = abc_30082_auto_rtlil_cc_2608_muxgate_28647
* NET  9619 = abc_30082_auto_rtlil_cc_2608_muxgate_28645
* NET  9620 = abc_30082_auto_rtlil_cc_2608_muxgate_28643
* NET  9621 = abc_30082_auto_rtlil_cc_2608_muxgate_28641
* NET  9622 = abc_30082_auto_rtlil_cc_2608_muxgate_28639
* NET  9623 = abc_30082_auto_rtlil_cc_2608_muxgate_28637
* NET  9624 = abc_30082_auto_rtlil_cc_2608_muxgate_28635
* NET  9625 = abc_30082_auto_rtlil_cc_2608_muxgate_28633
* NET  9626 = abc_30082_auto_rtlil_cc_2608_muxgate_28631
* NET  9627 = abc_30082_auto_rtlil_cc_2608_muxgate_28629
* NET  9628 = abc_30082_auto_rtlil_cc_2608_muxgate_28627
* NET  9629 = abc_30082_auto_rtlil_cc_2608_muxgate_28625
* NET  9630 = abc_30082_auto_rtlil_cc_2608_muxgate_28623
* NET  9631 = abc_30082_auto_rtlil_cc_2608_muxgate_28621
* NET  9632 = abc_30082_auto_rtlil_cc_2608_muxgate_28619
* NET  9633 = abc_30082_auto_rtlil_cc_2608_muxgate_28615
* NET  9634 = abc_30082_auto_rtlil_cc_2608_muxgate_28613
* NET  9635 = abc_30082_auto_rtlil_cc_2608_muxgate_28611
* NET  9636 = abc_30082_auto_rtlil_cc_2608_muxgate_28609
* NET  9637 = abc_30082_auto_rtlil_cc_2608_muxgate_28607
* NET  9638 = abc_30082_auto_rtlil_cc_2608_muxgate_28603
* NET  9639 = abc_30082_auto_rtlil_cc_2608_muxgate_28599
* NET  9640 = abc_30082_auto_rtlil_cc_2608_muxgate_28595
* NET  9641 = abc_30082_auto_rtlil_cc_2608_muxgate_28591
* NET  9642 = abc_30082_auto_rtlil_cc_2608_muxgate_28587
* NET  9643 = abc_30082_auto_rtlil_cc_2608_muxgate_28583
* NET  9644 = abc_30082_auto_rtlil_cc_2608_muxgate_28579
* NET  9645 = abc_30082_auto_rtlil_cc_2608_muxgate_28575
* NET  9646 = abc_30082_auto_rtlil_cc_2608_muxgate_28571
* NET  9647 = abc_30082_auto_rtlil_cc_2608_muxgate_28567
* NET  9648 = abc_30082_auto_rtlil_cc_2608_muxgate_28565
* NET  9649 = abc_30082_auto_rtlil_cc_2608_muxgate_28563
* NET  9650 = abc_30082_auto_rtlil_cc_2608_muxgate_28561
* NET  9651 = abc_30082_auto_rtlil_cc_2608_muxgate_28557
* NET  9652 = abc_30082_auto_rtlil_cc_2608_muxgate_28553
* NET  9653 = abc_30082_auto_rtlil_cc_2608_muxgate_28549
* NET  9654 = abc_30082_auto_rtlil_cc_2608_muxgate_28545
* NET  9655 = abc_30082_auto_rtlil_cc_2608_muxgate_28541
* NET  9656 = abc_30082_auto_rtlil_cc_2608_muxgate_28537
* NET  9657 = abc_30082_auto_rtlil_cc_2608_muxgate_28535
* NET  9658 = abc_30082_auto_rtlil_cc_2608_muxgate_28533
* NET  9659 = abc_30082_auto_rtlil_cc_2608_muxgate_28531
* NET  9660 = abc_30082_auto_rtlil_cc_2608_muxgate_28529
* NET  9661 = abc_30082_auto_rtlil_cc_2608_muxgate_28527
* NET  9662 = abc_30082_auto_rtlil_cc_2608_muxgate_28525
* NET  9663 = abc_30082_auto_rtlil_cc_2608_muxgate_28523
* NET  9664 = abc_30082_auto_rtlil_cc_2608_muxgate_28521
* NET  9665 = abc_30082_auto_rtlil_cc_2608_muxgate_28517
* NET  9666 = abc_30082_auto_rtlil_cc_2608_muxgate_28513
* NET  9667 = abc_30082_auto_rtlil_cc_2608_muxgate_28509
* NET  9668 = abc_30082_auto_rtlil_cc_2608_muxgate_28505
* NET  9669 = abc_30082_auto_rtlil_cc_2608_muxgate_28501
* NET  9670 = abc_30082_auto_rtlil_cc_2608_muxgate_28497
* NET  9671 = abc_30082_auto_rtlil_cc_2608_muxgate_28495
* NET  9672 = abc_30082_auto_rtlil_cc_2608_muxgate_28493
* NET  9673 = abc_30082_auto_rtlil_cc_2608_muxgate_28491
* NET  9674 = abc_30082_auto_rtlil_cc_2608_muxgate_28487
* NET  9675 = abc_30082_auto_rtlil_cc_2608_muxgate_28483
* NET  9676 = abc_30082_auto_rtlil_cc_2608_muxgate_28481
* NET  9677 = abc_30082_auto_rtlil_cc_2608_muxgate_28477
* NET  9678 = abc_30082_auto_rtlil_cc_2608_muxgate_28473
* NET  9679 = abc_30082_auto_rtlil_cc_2608_muxgate_28469
* NET  9680 = abc_30082_auto_rtlil_cc_2608_muxgate_28467
* NET  9681 = abc_30082_auto_rtlil_cc_2608_muxgate_28465
* NET  9682 = abc_30082_auto_rtlil_cc_2608_muxgate_28463
* NET  9683 = abc_30082_auto_rtlil_cc_2608_muxgate_28461
* NET  9684 = abc_30082_auto_rtlil_cc_2608_muxgate_28459
* NET  9685 = abc_30082_auto_rtlil_cc_2608_muxgate_28457
* NET  9686 = abc_30082_auto_rtlil_cc_2608_muxgate_28455
* NET  9687 = abc_30082_auto_rtlil_cc_2608_muxgate_28453
* NET  9688 = abc_30082_auto_rtlil_cc_2608_muxgate_28451
* NET  9689 = abc_30082_auto_rtlil_cc_2608_muxgate_28449
* NET  9690 = abc_30082_auto_rtlil_cc_2608_muxgate_28447
* NET  9691 = abc_30082_auto_rtlil_cc_2608_muxgate_28445
* NET  9692 = abc_30082_auto_rtlil_cc_2608_muxgate_28443
* NET  9693 = abc_30082_auto_rtlil_cc_2608_muxgate_28441
* NET  9694 = abc_30082_auto_rtlil_cc_2608_muxgate_28439
* NET  9695 = abc_30082_auto_rtlil_cc_2608_muxgate_28437
* NET  9696 = abc_30082_auto_rtlil_cc_2608_muxgate_28435
* NET  9697 = abc_30082_auto_rtlil_cc_2608_muxgate_28433
* NET  9698 = abc_30082_auto_rtlil_cc_2608_muxgate_28431
* NET  9699 = abc_30082_auto_rtlil_cc_2608_muxgate_28429
* NET  9700 = abc_30082_auto_rtlil_cc_2608_muxgate_28427
* NET  9701 = abc_30082_auto_rtlil_cc_2608_muxgate_28425
* NET  9702 = abc_30082_auto_rtlil_cc_2608_muxgate_28423
* NET  9703 = abc_30082_auto_rtlil_cc_2608_muxgate_28421
* NET  9704 = abc_30082_auto_rtlil_cc_2608_muxgate_28419
* NET  9705 = abc_30082_auto_rtlil_cc_2608_muxgate_28417
* NET  9706 = abc_30082_auto_rtlil_cc_2608_muxgate_28415
* NET  9707 = abc_30082_auto_rtlil_cc_2608_muxgate_28413
* NET  9708 = abc_30082_auto_rtlil_cc_2608_muxgate_28411
* NET  9709 = abc_30082_auto_rtlil_cc_2608_muxgate_28409
* NET  9710 = abc_30082_auto_rtlil_cc_2608_muxgate_28407
* NET  9711 = abc_30082_auto_rtlil_cc_2608_muxgate_28405
* NET  9712 = abc_30082_auto_rtlil_cc_2608_muxgate_28401
* NET  9713 = abc_30082_auto_rtlil_cc_2608_muxgate_28397
* NET  9714 = abc_30082_auto_rtlil_cc_2608_muxgate_28393
* NET  9715 = abc_30082_auto_rtlil_cc_2608_muxgate_28389
* NET  9716 = abc_30082_auto_rtlil_cc_2608_muxgate_28387
* NET  9717 = abc_30082_auto_rtlil_cc_2608_muxgate_28385
* NET  9718 = abc_30082_auto_rtlil_cc_2608_muxgate_28383
* NET  9719 = abc_30082_auto_rtlil_cc_2608_muxgate_28381
* NET  9720 = abc_30082_auto_rtlil_cc_2608_muxgate_28379
* NET  9721 = abc_30082_auto_rtlil_cc_2608_muxgate_28377
* NET  9722 = abc_30082_auto_rtlil_cc_2608_muxgate_28375
* NET  9723 = abc_30082_auto_rtlil_cc_2608_muxgate_28373
* NET  9724 = abc_30082_auto_rtlil_cc_2608_muxgate_28371
* NET  9725 = abc_30082_auto_rtlil_cc_2608_muxgate_28369
* NET  9726 = abc_30082_auto_rtlil_cc_2608_muxgate_28367
* NET  9727 = abc_30082_auto_rtlil_cc_2608_muxgate_28365
* NET  9728 = abc_30082_auto_rtlil_cc_2608_muxgate_28363
* NET  9729 = abc_30082_auto_rtlil_cc_2608_muxgate_28361
* NET  9730 = abc_30082_auto_rtlil_cc_2608_muxgate_28359
* NET  9731 = abc_30082_auto_rtlil_cc_2608_muxgate_28357
* NET  9732 = abc_30082_auto_rtlil_cc_2608_muxgate_28355
* NET  9733 = abc_30082_auto_rtlil_cc_2608_muxgate_28353
* NET  9734 = abc_30082_auto_rtlil_cc_2608_muxgate_28351
* NET  9735 = abc_30082_auto_rtlil_cc_2608_muxgate_28349
* NET  9736 = abc_30082_auto_rtlil_cc_2608_muxgate_28347
* NET  9737 = abc_30082_auto_rtlil_cc_2608_muxgate_28345
* NET  9738 = abc_30082_auto_rtlil_cc_2608_muxgate_28343
* NET  9739 = abc_30082_auto_rtlil_cc_2608_muxgate_28341
* NET  9740 = abc_30082_auto_rtlil_cc_2608_muxgate_28339
* NET  9741 = abc_30082_auto_rtlil_cc_2608_muxgate_28337
* NET  9742 = abc_30082_auto_rtlil_cc_2608_muxgate_28335
* NET  9743 = abc_30082_auto_rtlil_cc_2608_muxgate_28333
* NET  9744 = abc_30082_auto_rtlil_cc_2608_muxgate_28331
* NET  9745 = abc_30082_auto_rtlil_cc_2608_muxgate_28329
* NET  9746 = abc_30082_auto_rtlil_cc_2608_muxgate_28327
* NET  9747 = abc_30082_auto_rtlil_cc_2608_muxgate_28325
* NET  9748 = abc_30082_auto_rtlil_cc_2608_muxgate_28323
* NET  9749 = abc_30082_auto_rtlil_cc_2608_muxgate_28321
* NET  9750 = abc_30082_auto_rtlil_cc_2608_muxgate_28319
* NET  9751 = abc_30082_auto_rtlil_cc_2608_muxgate_28317
* NET  9752 = abc_30082_auto_rtlil_cc_2608_muxgate_28315
* NET  9753 = abc_30082_auto_rtlil_cc_2608_muxgate_28313
* NET  9754 = abc_30082_auto_rtlil_cc_2608_muxgate_28311
* NET  9755 = abc_30082_auto_rtlil_cc_2608_muxgate_28309
* NET  9756 = abc_30082_auto_rtlil_cc_2608_muxgate_28307
* NET  9757 = abc_30082_auto_rtlil_cc_2608_muxgate_28305
* NET  9758 = abc_30082_auto_rtlil_cc_2608_muxgate_28303
* NET  9759 = abc_30082_auto_rtlil_cc_2608_muxgate_28301
* NET  9760 = abc_30082_auto_rtlil_cc_2608_muxgate_28299
* NET  9761 = abc_30082_auto_rtlil_cc_2608_muxgate_28297
* NET  9762 = abc_30082_auto_rtlil_cc_2608_muxgate_28295
* NET  9763 = abc_30082_auto_rtlil_cc_2608_muxgate_28293
* NET  9764 = abc_30082_auto_rtlil_cc_2608_muxgate_28291
* NET  9765 = abc_30082_auto_rtlil_cc_2608_muxgate_28289
* NET  9766 = abc_30082_auto_rtlil_cc_2608_muxgate_28287
* NET  9767 = abc_30082_auto_rtlil_cc_2608_muxgate_28285
* NET  9768 = abc_30082_auto_rtlil_cc_2608_muxgate_28283
* NET  9769 = abc_30082_auto_rtlil_cc_2608_muxgate_28281
* NET  9770 = abc_30082_auto_rtlil_cc_2608_muxgate_28279
* NET  9771 = abc_30082_auto_rtlil_cc_2608_muxgate_28277
* NET  9772 = abc_30082_auto_rtlil_cc_2608_muxgate_28275
* NET  9773 = abc_30082_auto_rtlil_cc_2608_muxgate_28273
* NET  9774 = abc_30082_auto_rtlil_cc_2608_muxgate_28271
* NET  9775 = abc_30082_auto_rtlil_cc_2608_muxgate_28269
* NET  9776 = abc_30082_auto_rtlil_cc_2608_muxgate_28267
* NET  9777 = abc_30082_auto_rtlil_cc_2608_muxgate_28265
* NET  9778 = abc_30082_auto_rtlil_cc_2608_muxgate_28263
* NET  9779 = abc_30082_auto_rtlil_cc_2608_muxgate_28261
* NET  9780 = abc_30082_auto_rtlil_cc_2608_muxgate_28259
* NET  9781 = abc_30082_auto_rtlil_cc_2608_muxgate_28257
* NET  9782 = abc_30082_auto_rtlil_cc_2608_muxgate_28255
* NET  9783 = abc_30082_auto_rtlil_cc_2608_muxgate_28253
* NET  9784 = abc_30082_auto_rtlil_cc_2608_muxgate_28251
* NET  9785 = abc_30082_auto_rtlil_cc_2608_muxgate_28249
* NET  9786 = abc_30082_auto_rtlil_cc_2608_muxgate_28247
* NET  9787 = abc_30082_auto_rtlil_cc_2608_muxgate_28245
* NET  9788 = abc_30082_auto_rtlil_cc_2608_muxgate_28243
* NET  9789 = abc_30082_auto_rtlil_cc_2608_muxgate_28241
* NET  9790 = abc_30082_auto_rtlil_cc_2608_muxgate_28239
* NET  9791 = abc_30082_auto_rtlil_cc_2608_muxgate_28237
* NET  9792 = abc_30082_auto_rtlil_cc_2608_muxgate_28235
* NET  9793 = abc_30082_auto_rtlil_cc_2608_muxgate_28233
* NET  9794 = abc_30082_auto_rtlil_cc_2608_muxgate_28231
* NET  9795 = abc_30082_auto_rtlil_cc_2608_muxgate_28229
* NET  9796 = abc_30082_auto_rtlil_cc_2608_muxgate_28227
* NET  9797 = abc_30082_auto_rtlil_cc_2608_muxgate_28225
* NET  9798 = abc_30082_auto_rtlil_cc_2608_muxgate_28223
* NET  9799 = abc_30082_auto_rtlil_cc_2608_muxgate_28221
* NET  9800 = abc_30082_auto_rtlil_cc_2608_muxgate_28219
* NET  9801 = abc_30082_auto_rtlil_cc_2608_muxgate_28217
* NET  9802 = abc_30082_auto_rtlil_cc_2608_muxgate_28215
* NET  9803 = abc_30082_auto_rtlil_cc_2608_muxgate_28213
* NET  9804 = abc_30082_auto_rtlil_cc_2608_muxgate_28211
* NET  9805 = abc_30082_auto_rtlil_cc_2608_muxgate_28209
* NET  9806 = abc_30082_auto_rtlil_cc_2608_muxgate_28207
* NET  9807 = abc_30082_auto_rtlil_cc_2608_muxgate_28205
* NET  9808 = abc_30082_auto_rtlil_cc_2608_muxgate_28203
* NET  9809 = abc_30082_auto_rtlil_cc_2608_muxgate_28201
* NET  9810 = abc_30082_auto_rtlil_cc_2608_muxgate_28199
* NET  9811 = abc_30082_auto_rtlil_cc_2608_muxgate_28195
* NET  9812 = abc_30082_auto_rtlil_cc_2608_muxgate_28191
* NET  9813 = abc_30082_auto_rtlil_cc_2608_muxgate_28187
* NET  9814 = abc_30082_auto_rtlil_cc_2608_muxgate_28183
* NET  9815 = abc_30082_auto_rtlil_cc_2608_muxgate_28179
* NET  9816 = abc_30082_auto_rtlil_cc_2608_muxgate_28175
* NET  9817 = abc_30082_auto_rtlil_cc_2608_muxgate_28171
* NET  9818 = abc_30082_auto_rtlil_cc_2608_muxgate_28167
* NET  9819 = abc_30082_auto_rtlil_cc_2608_muxgate_28163
* NET  9820 = abc_30082_auto_rtlil_cc_2608_muxgate_28159
* NET  9821 = abc_30082_auto_rtlil_cc_2608_muxgate_28155
* NET  9822 = abc_30082_auto_rtlil_cc_2608_muxgate_28151
* NET  9823 = abc_30082_auto_rtlil_cc_2608_muxgate_28147
* NET  9824 = abc_30082_auto_rtlil_cc_2608_muxgate_28143
* NET  9825 = abc_30082_auto_rtlil_cc_2608_muxgate_28139
* NET  9826 = abc_30082_auto_rtlil_cc_2608_muxgate_28135
* NET  9827 = abc_30082_auto_rtlil_cc_2608_muxgate_28131
* NET  9828 = abc_30082_auto_rtlil_cc_2608_muxgate_28127
* NET  9829 = abc_30082_auto_rtlil_cc_2608_muxgate_28123
* NET  9830 = abc_30082_auto_rtlil_cc_2608_muxgate_28119
* NET  9831 = abc_30082_auto_rtlil_cc_2608_muxgate_28115
* NET  9832 = abc_30082_auto_rtlil_cc_2608_muxgate_28111
* NET  9833 = abc_30082_auto_rtlil_cc_2608_muxgate_28107
* NET  9834 = abc_30082_auto_rtlil_cc_2608_muxgate_28103
* NET  9835 = abc_30082_auto_rtlil_cc_2608_muxgate_28099
* NET  9836 = abc_30082_auto_rtlil_cc_2608_muxgate_28095
* NET  9837 = abc_30082_auto_rtlil_cc_2608_muxgate_28091
* NET  9838 = abc_30082_auto_rtlil_cc_2608_muxgate_28087
* NET  9839 = abc_30082_auto_rtlil_cc_2608_muxgate_28083
* NET  9840 = abc_30082_auto_rtlil_cc_2608_muxgate_28079
* NET  9841 = abc_30082_auto_rtlil_cc_2608_muxgate_28075
* NET  9842 = abc_30082_auto_rtlil_cc_2608_muxgate_28071
* NET  9843 = abc_30082_auto_rtlil_cc_2608_muxgate_28067
* NET  9844 = abc_30082_auto_rtlil_cc_2608_muxgate_28063
* NET  9845 = abc_30082_auto_rtlil_cc_2608_muxgate_28059
* NET  9846 = abc_30082_auto_rtlil_cc_2608_muxgate_28055
* NET  9847 = abc_30082_auto_rtlil_cc_2608_muxgate_28051
* NET  9848 = abc_30082_auto_rtlil_cc_2608_muxgate_28047
* NET  9849 = abc_30082_auto_rtlil_cc_2608_muxgate_28043
* NET  9850 = abc_30082_auto_rtlil_cc_2608_muxgate_28039
* NET  9851 = abc_30082_auto_rtlil_cc_2608_muxgate_28035
* NET  9852 = abc_30082_auto_rtlil_cc_2608_muxgate_28031
* NET  9853 = abc_30082_auto_rtlil_cc_2608_muxgate_28027
* NET  9854 = abc_30082_auto_rtlil_cc_2608_muxgate_28023
* NET  9855 = abc_30082_auto_rtlil_cc_2608_muxgate_28019
* NET  9856 = abc_30082_auto_rtlil_cc_2608_muxgate_28015
* NET  9857 = abc_30082_auto_rtlil_cc_2608_muxgate_28011
* NET  9858 = abc_30082_auto_rtlil_cc_2608_muxgate_28007
* NET  9859 = abc_30082_auto_rtlil_cc_2608_muxgate_28003
* NET  9860 = abc_30082_auto_rtlil_cc_2608_muxgate_27999
* NET  9861 = abc_30082_auto_rtlil_cc_2608_muxgate_27995
* NET  9862 = abc_30082_auto_rtlil_cc_2608_muxgate_27991
* NET  9863 = abc_30082_auto_rtlil_cc_2608_muxgate_27987
* NET  9864 = abc_30082_auto_rtlil_cc_2608_muxgate_27983
* NET  9865 = abc_30082_auto_rtlil_cc_2608_muxgate_27979
* NET  9866 = abc_30082_auto_rtlil_cc_2608_muxgate_27975
* NET  9867 = abc_30082_auto_rtlil_cc_2608_muxgate_27971
* NET  9868 = abc_30082_auto_rtlil_cc_2608_muxgate_27967
* NET  9869 = abc_30082_auto_rtlil_cc_2608_muxgate_27963
* NET  9870 = abc_30082_auto_rtlil_cc_2608_muxgate_27959
* NET  9871 = abc_30082_auto_rtlil_cc_2608_muxgate_27955
* NET  9872 = abc_30082_auto_rtlil_cc_2608_muxgate_27951
* NET  9873 = abc_30082_auto_rtlil_cc_2608_muxgate_27947
* NET  9874 = abc_30082_auto_rtlil_cc_2608_muxgate_27943
* NET  9875 = abc_30082_auto_rtlil_cc_2608_muxgate_27939
* NET  9876 = abc_30082_auto_rtlil_cc_2608_muxgate_27935
* NET  9877 = abc_30082_auto_rtlil_cc_2608_muxgate_27931
* NET  9878 = abc_30082_auto_rtlil_cc_2608_muxgate_27927
* NET  9879 = abc_30082_auto_rtlil_cc_2608_muxgate_27923
* NET  9880 = abc_30082_auto_rtlil_cc_2608_muxgate_27919
* NET  9881 = abc_30082_auto_rtlil_cc_2608_muxgate_27915
* NET  9882 = abc_30082_auto_rtlil_cc_2608_muxgate_27911
* NET  9883 = abc_30082_auto_rtlil_cc_2608_muxgate_27907
* NET  9884 = abc_30082_auto_rtlil_cc_2608_muxgate_27903
* NET  9885 = abc_30082_auto_rtlil_cc_2608_muxgate_27899
* NET  9886 = abc_30082_auto_rtlil_cc_2608_muxgate_27895
* NET  9887 = abc_30082_auto_rtlil_cc_2608_muxgate_27891
* NET  9888 = abc_30082_auto_rtlil_cc_2608_muxgate_27887
* NET  9889 = abc_30082_auto_rtlil_cc_2608_muxgate_27883
* NET  9890 = abc_30082_auto_rtlil_cc_2608_muxgate_27879
* NET  9891 = abc_30082_auto_rtlil_cc_2608_muxgate_27875
* NET  9892 = abc_30082_auto_rtlil_cc_2608_muxgate_27871
* NET  9893 = abc_30082_auto_rtlil_cc_2608_muxgate_27867
* NET  9894 = abc_30082_auto_rtlil_cc_2608_muxgate_27863
* NET  9895 = abc_30082_auto_rtlil_cc_2608_muxgate_27859
* NET  9896 = abc_30082_auto_rtlil_cc_2608_muxgate_27855
* NET  9897 = abc_30082_auto_rtlil_cc_2608_muxgate_27851
* NET  9898 = abc_30082_auto_rtlil_cc_2608_muxgate_27847
* NET  9899 = abc_30082_auto_rtlil_cc_2608_muxgate_27843
* NET  9900 = abc_30082_auto_rtlil_cc_2608_muxgate_27839
* NET  9901 = abc_30082_auto_rtlil_cc_2608_muxgate_27835
* NET  9902 = abc_30082_auto_rtlil_cc_2608_muxgate_27831
* NET  9903 = abc_30082_auto_rtlil_cc_2608_muxgate_27827
* NET  9904 = abc_30082_auto_rtlil_cc_2608_muxgate_27823
* NET  9905 = abc_30082_auto_rtlil_cc_2608_muxgate_27819
* NET  9906 = abc_30082_auto_rtlil_cc_2608_muxgate_27815
* NET  9907 = abc_30082_auto_rtlil_cc_2608_muxgate_27811
* NET  9908 = abc_30082_auto_rtlil_cc_2608_muxgate_27807
* NET  9909 = abc_30082_auto_rtlil_cc_2608_muxgate_27803
* NET  9910 = abc_30082_auto_rtlil_cc_2608_muxgate_27799
* NET  9911 = abc_30082_auto_rtlil_cc_2608_muxgate_27795
* NET  9912 = abc_30082_auto_rtlil_cc_2608_muxgate_27791
* NET  9913 = abc_30082_auto_rtlil_cc_2608_muxgate_27787
* NET  9914 = abc_30082_auto_rtlil_cc_2608_muxgate_27783
* NET  9915 = abc_30082_auto_rtlil_cc_2608_muxgate_27779
* NET  9916 = abc_30082_auto_rtlil_cc_2608_muxgate_27775
* NET  9917 = abc_30082_auto_rtlil_cc_2608_muxgate_27771
* NET  9918 = abc_30082_auto_rtlil_cc_2608_muxgate_27767
* NET  9919 = abc_30082_auto_rtlil_cc_2608_muxgate_27763
* NET  9920 = abc_30082_auto_rtlil_cc_2608_muxgate_27759
* NET  9921 = abc_30082_auto_rtlil_cc_2608_muxgate_27755
* NET  9922 = abc_30082_auto_rtlil_cc_2608_muxgate_27751
* NET  9923 = abc_30082_auto_rtlil_cc_2608_muxgate_27747
* NET  9924 = abc_30082_auto_rtlil_cc_2608_muxgate_27743
* NET  9925 = abc_30082_auto_rtlil_cc_2608_muxgate_27739
* NET  9926 = abc_30082_auto_rtlil_cc_2608_muxgate_27735
* NET  9927 = abc_30082_auto_rtlil_cc_2608_muxgate_27731
* NET  9928 = abc_30082_auto_rtlil_cc_2608_muxgate_27727
* NET  9929 = abc_30082_auto_rtlil_cc_2608_muxgate_27723
* NET  9930 = abc_30082_auto_rtlil_cc_2608_muxgate_27719
* NET  9931 = abc_30082_auto_rtlil_cc_2608_muxgate_27715
* NET  9932 = abc_30082_auto_rtlil_cc_2608_muxgate_27711
* NET  9933 = abc_30082_auto_rtlil_cc_2608_muxgate_27707
* NET  9934 = abc_30082_auto_rtlil_cc_2608_muxgate_27703
* NET  9935 = abc_30082_auto_rtlil_cc_2608_muxgate_27699
* NET  9936 = abc_30082_auto_rtlil_cc_2608_muxgate_27695
* NET  9937 = abc_30082_auto_rtlil_cc_2608_muxgate_27693
* NET  9938 = abc_30082_auto_rtlil_cc_2608_muxgate_27691
* NET  9939 = abc_30082_auto_rtlil_cc_2608_muxgate_27689
* NET  9940 = abc_30082_auto_rtlil_cc_2608_muxgate_27687
* NET  9941 = abc_30082_auto_rtlil_cc_2608_muxgate_27685
* NET  9942 = abc_30082_auto_rtlil_cc_2608_muxgate_27683
* NET  9943 = abc_30082_auto_rtlil_cc_2608_muxgate_27681
* NET  9944 = abc_30082_auto_rtlil_cc_2608_muxgate_27679
* NET  9945 = abc_30082_auto_rtlil_cc_2608_muxgate_27677
* NET  9946 = abc_30082_auto_rtlil_cc_2608_muxgate_27675
* NET  9947 = abc_30082_auto_rtlil_cc_2608_muxgate_27673
* NET  9948 = abc_30082_auto_rtlil_cc_2608_muxgate_27671
* NET  9949 = abc_30082_auto_rtlil_cc_2608_muxgate_27669
* NET  9950 = abc_30082_auto_rtlil_cc_2608_muxgate_27667
* NET  9951 = abc_30082_auto_rtlil_cc_2608_muxgate_27665
* NET  9952 = abc_30082_auto_rtlil_cc_2608_muxgate_27663
* NET  9953 = abc_30082_auto_rtlil_cc_2608_muxgate_27661
* NET  9954 = abc_30082_auto_rtlil_cc_2608_muxgate_27659
* NET  9955 = abc_30082_auto_rtlil_cc_2608_muxgate_27657
* NET  9956 = abc_30082_auto_rtlil_cc_2608_muxgate_27655
* NET  9957 = abc_30082_auto_rtlil_cc_2608_muxgate_27653
* NET  9958 = abc_30082_auto_rtlil_cc_2608_muxgate_27651
* NET  9959 = abc_30082_auto_rtlil_cc_2608_muxgate_27649
* NET  9960 = abc_30082_auto_rtlil_cc_2608_muxgate_27647
* NET  9961 = abc_30082_auto_rtlil_cc_2608_muxgate_27645
* NET  9962 = abc_30082_auto_rtlil_cc_2608_muxgate_27643
* NET  9963 = abc_30082_auto_rtlil_cc_2608_muxgate_27641
* NET  9964 = abc_30082_auto_rtlil_cc_2608_muxgate_27639
* NET  9965 = abc_30082_auto_rtlil_cc_2608_muxgate_27637
* NET  9966 = abc_30082_auto_rtlil_cc_2608_muxgate_27635
* NET  9967 = abc_30082_auto_rtlil_cc_2608_muxgate_27633
* NET  9968 = abc_30082_auto_rtlil_cc_2608_muxgate_27631
* NET  9969 = abc_30082_auto_rtlil_cc_2608_muxgate_27629
* NET  9970 = abc_30082_auto_rtlil_cc_2608_muxgate_27627
* NET  9971 = abc_30082_auto_rtlil_cc_2608_muxgate_27625
* NET  9972 = abc_30082_auto_rtlil_cc_2608_muxgate_27623
* NET  9973 = abc_30082_auto_rtlil_cc_2608_muxgate_27621
* NET  9974 = abc_30082_auto_rtlil_cc_2608_muxgate_27619
* NET  9975 = abc_30082_auto_rtlil_cc_2608_muxgate_27617
* NET  9976 = abc_30082_auto_rtlil_cc_2608_muxgate_27615
* NET  9977 = abc_30082_auto_rtlil_cc_2608_muxgate_27613
* NET  9978 = abc_30082_auto_rtlil_cc_2608_muxgate_27611
* NET  9979 = abc_30082_auto_rtlil_cc_2608_muxgate_27609
* NET  9980 = abc_30082_auto_rtlil_cc_2608_muxgate_27607
* NET  9981 = abc_30082_auto_rtlil_cc_2608_muxgate_27605
* NET  9982 = abc_30082_auto_rtlil_cc_2608_muxgate_27603
* NET  9983 = abc_30082_auto_rtlil_cc_2608_muxgate_27601
* NET  9984 = abc_30082_auto_rtlil_cc_2608_muxgate_27599
* NET  9985 = abc_30082_auto_rtlil_cc_2608_muxgate_27597
* NET  9986 = abc_30082_auto_rtlil_cc_2608_muxgate_27595
* NET  9987 = abc_30082_auto_rtlil_cc_2608_muxgate_27593
* NET  9988 = abc_30082_auto_rtlil_cc_2608_muxgate_27591
* NET  9989 = abc_30082_auto_rtlil_cc_2608_muxgate_27589
* NET  9990 = abc_30082_auto_rtlil_cc_2608_muxgate_27587
* NET  9991 = abc_30082_auto_rtlil_cc_2608_muxgate_27585
* NET  9992 = abc_30082_auto_rtlil_cc_2608_muxgate_27583
* NET  9993 = abc_30082_auto_rtlil_cc_2608_muxgate_27581
* NET  9994 = abc_30082_auto_rtlil_cc_2608_muxgate_27579
* NET  9995 = abc_30082_auto_rtlil_cc_2608_muxgate_27577
* NET  9996 = abc_30082_auto_rtlil_cc_2608_muxgate_27575
* NET  9997 = abc_30082_auto_rtlil_cc_2608_muxgate_27573
* NET  9998 = abc_30082_auto_rtlil_cc_2608_muxgate_27571
* NET  9999 = abc_30082_auto_rtlil_cc_2608_muxgate_27569
* NET 10000 = abc_30082_auto_rtlil_cc_2608_muxgate_27567
* NET 10001 = abc_30082_auto_rtlil_cc_2608_muxgate_27565
* NET 10002 = abc_30082_auto_rtlil_cc_2608_muxgate_27563
* NET 10003 = abc_30082_auto_rtlil_cc_2608_muxgate_27561
* NET 10004 = abc_30082_auto_rtlil_cc_2608_muxgate_27559
* NET 10005 = abc_30082_auto_rtlil_cc_2608_muxgate_27557
* NET 10006 = abc_30082_auto_rtlil_cc_2608_muxgate_27555
* NET 10007 = abc_30082_auto_rtlil_cc_2608_muxgate_27553
* NET 10008 = abc_30082_auto_rtlil_cc_2608_muxgate_27551
* NET 10009 = abc_30082_auto_rtlil_cc_2608_muxgate_27549
* NET 10010 = abc_30082_auto_rtlil_cc_2608_muxgate_27547
* NET 10011 = abc_30082_auto_rtlil_cc_2608_muxgate_27545
* NET 10012 = abc_30082_auto_rtlil_cc_2608_muxgate_27543
* NET 10013 = abc_30082_auto_rtlil_cc_2608_muxgate_27541
* NET 10014 = abc_30082_auto_rtlil_cc_2608_muxgate_27539
* NET 10015 = abc_30082_auto_rtlil_cc_2608_muxgate_27537
* NET 10016 = abc_30082_auto_rtlil_cc_2608_muxgate_27535
* NET 10017 = abc_30082_auto_rtlil_cc_2608_muxgate_27533
* NET 10018 = abc_30082_auto_rtlil_cc_2608_muxgate_27531
* NET 10019 = abc_30082_auto_rtlil_cc_2608_muxgate_27529
* NET 10020 = abc_30082_auto_rtlil_cc_2608_muxgate_27527
* NET 10021 = abc_30082_auto_rtlil_cc_2608_muxgate_27525
* NET 10022 = abc_30082_auto_rtlil_cc_2608_muxgate_27523
* NET 10023 = abc_30082_auto_rtlil_cc_2608_muxgate_27521
* NET 10024 = abc_30082_auto_rtlil_cc_2608_muxgate_27519
* NET 10025 = abc_30082_auto_rtlil_cc_2608_muxgate_27517
* NET 10026 = abc_30082_auto_rtlil_cc_2608_muxgate_27515
* NET 10027 = abc_30082_auto_rtlil_cc_2608_muxgate_27513
* NET 10028 = abc_30082_auto_rtlil_cc_2608_muxgate_27511
* NET 10029 = abc_30082_auto_rtlil_cc_2608_muxgate_27509
* NET 10030 = abc_30082_auto_rtlil_cc_2608_muxgate_27507
* NET 10031 = abc_30082_auto_rtlil_cc_2608_muxgate_27505
* NET 10032 = abc_30082_auto_rtlil_cc_2608_muxgate_27503
* NET 10033 = abc_30082_auto_rtlil_cc_2608_muxgate_27501
* NET 10034 = abc_30082_auto_rtlil_cc_2608_muxgate_27499
* NET 10035 = abc_30082_auto_rtlil_cc_2608_muxgate_27497
* NET 10036 = abc_30082_auto_rtlil_cc_2608_muxgate_27495
* NET 10037 = abc_30082_auto_rtlil_cc_2608_muxgate_27493
* NET 10038 = abc_30082_auto_rtlil_cc_2608_muxgate_27491
* NET 10039 = abc_30082_auto_rtlil_cc_2608_muxgate_27489
* NET 10040 = abc_30082_auto_rtlil_cc_2608_muxgate_27487
* NET 10041 = abc_30082_auto_rtlil_cc_2608_muxgate_27485
* NET 10042 = abc_30082_auto_rtlil_cc_2608_muxgate_27483
* NET 10043 = abc_30082_auto_rtlil_cc_2608_muxgate_27481
* NET 10044 = abc_30082_auto_rtlil_cc_2608_muxgate_27479
* NET 10045 = abc_30082_auto_rtlil_cc_2608_muxgate_27477
* NET 10046 = abc_30082_auto_rtlil_cc_2608_muxgate_27475
* NET 10047 = abc_30082_auto_rtlil_cc_2608_muxgate_27473
* NET 10048 = abc_30082_auto_rtlil_cc_2608_muxgate_27471
* NET 10049 = abc_30082_auto_rtlil_cc_2608_muxgate_27469
* NET 10050 = abc_30082_auto_rtlil_cc_2608_muxgate_27467
* NET 10051 = abc_30082_auto_rtlil_cc_2608_muxgate_27465
* NET 10052 = abc_30082_auto_rtlil_cc_2608_muxgate_27463
* NET 10053 = abc_30082_auto_rtlil_cc_2608_muxgate_27461
* NET 10054 = abc_30082_auto_rtlil_cc_2608_muxgate_27459
* NET 10055 = abc_30082_auto_rtlil_cc_2608_muxgate_27457
* NET 10056 = abc_30082_auto_rtlil_cc_2608_muxgate_27455
* NET 10057 = abc_30082_auto_rtlil_cc_2608_muxgate_27453
* NET 10058 = abc_30082_auto_rtlil_cc_2608_muxgate_27451
* NET 10059 = abc_30082_auto_rtlil_cc_2608_muxgate_27449
* NET 10060 = abc_30082_auto_rtlil_cc_2608_muxgate_27447
* NET 10061 = abc_30082_auto_rtlil_cc_2608_muxgate_27445
* NET 10062 = abc_30082_auto_rtlil_cc_2608_muxgate_27443
* NET 10063 = abc_30082_auto_rtlil_cc_2608_muxgate_27441
* NET 10064 = abc_30082_auto_rtlil_cc_2608_muxgate_27439
* NET 10065 = abc_30082_auto_rtlil_cc_2608_muxgate_27437
* NET 10066 = abc_30082_auto_rtlil_cc_2608_muxgate_27435
* NET 10067 = abc_30082_auto_rtlil_cc_2608_muxgate_27433
* NET 10068 = abc_30082_auto_rtlil_cc_2608_muxgate_27431
* NET 10069 = abc_30082_auto_rtlil_cc_2608_muxgate_27429
* NET 10070 = abc_30082_auto_rtlil_cc_2608_muxgate_27427
* NET 10071 = abc_30082_auto_rtlil_cc_2608_muxgate_27425
* NET 10072 = abc_30082_auto_rtlil_cc_2608_muxgate_27423
* NET 10073 = abc_30082_auto_rtlil_cc_2608_muxgate_27421
* NET 10074 = abc_30082_auto_rtlil_cc_2608_muxgate_27419
* NET 10075 = abc_30082_auto_rtlil_cc_2608_muxgate_27417
* NET 10076 = abc_30082_auto_rtlil_cc_2608_muxgate_27415
* NET 10077 = abc_30082_auto_rtlil_cc_2608_muxgate_27413
* NET 10078 = abc_30082_auto_rtlil_cc_2608_muxgate_27411
* NET 10079 = abc_30082_auto_rtlil_cc_2608_muxgate_27409
* NET 10080 = abc_30082_auto_rtlil_cc_2608_muxgate_27407
* NET 10081 = abc_30082_auto_rtlil_cc_2608_muxgate_27405
* NET 10082 = abc_30082_auto_rtlil_cc_2608_muxgate_27403
* NET 10083 = abc_30082_auto_rtlil_cc_2608_muxgate_27401
* NET 10084 = abc_30082_auto_rtlil_cc_2608_muxgate_27399
* NET 10085 = abc_30082_auto_rtlil_cc_2608_muxgate_27397
* NET 10086 = abc_30082_auto_rtlil_cc_2608_muxgate_27395
* NET 10087 = abc_30082_auto_rtlil_cc_2608_muxgate_27393
* NET 10088 = abc_30082_auto_rtlil_cc_2608_muxgate_27391
* NET 10089 = abc_30082_auto_rtlil_cc_2608_muxgate_27389
* NET 10090 = abc_30082_auto_rtlil_cc_2608_muxgate_27387
* NET 10091 = abc_30082_auto_rtlil_cc_2608_muxgate_27385
* NET 10092 = abc_30082_auto_rtlil_cc_2608_muxgate_27383
* NET 10093 = abc_30082_auto_rtlil_cc_2608_muxgate_27381
* NET 10094 = abc_30082_auto_rtlil_cc_2608_muxgate_27379
* NET 10095 = abc_30082_auto_rtlil_cc_2608_muxgate_27377
* NET 10096 = abc_30082_auto_rtlil_cc_2608_muxgate_27375
* NET 10097 = abc_30082_auto_rtlil_cc_2608_muxgate_27373
* NET 10098 = abc_30082_auto_rtlil_cc_2608_muxgate_27371
* NET 10099 = abc_30082_auto_rtlil_cc_2608_muxgate_27369
* NET 10100 = abc_30082_auto_rtlil_cc_2608_muxgate_27367
* NET 10101 = abc_30082_auto_rtlil_cc_2608_muxgate_27365
* NET 10102 = abc_30082_auto_rtlil_cc_2608_muxgate_27363
* NET 10103 = abc_30082_auto_rtlil_cc_2608_muxgate_27361
* NET 10104 = abc_30082_auto_rtlil_cc_2608_muxgate_27359
* NET 10105 = abc_30082_auto_rtlil_cc_2608_muxgate_27357
* NET 10106 = abc_30082_auto_rtlil_cc_2608_muxgate_27355
* NET 10107 = abc_30082_auto_rtlil_cc_2608_muxgate_27353
* NET 10108 = abc_30082_auto_rtlil_cc_2608_muxgate_27351
* NET 10109 = abc_30082_auto_rtlil_cc_2608_muxgate_27349
* NET 10110 = abc_30082_auto_rtlil_cc_2608_muxgate_27347
* NET 10111 = abc_30082_auto_rtlil_cc_2608_muxgate_27345
* NET 10112 = abc_30082_auto_rtlil_cc_2608_muxgate_27343
* NET 10113 = abc_30082_auto_rtlil_cc_2608_muxgate_27341
* NET 10114 = abc_30082_auto_rtlil_cc_2608_muxgate_27339
* NET 10115 = abc_30082_auto_rtlil_cc_2608_muxgate_27337
* NET 10116 = abc_30082_auto_rtlil_cc_2608_muxgate_27335
* NET 10117 = abc_30082_auto_rtlil_cc_2608_muxgate_27333
* NET 10118 = abc_30082_auto_rtlil_cc_2608_muxgate_27331
* NET 10119 = abc_30082_auto_rtlil_cc_2608_muxgate_27329
* NET 10120 = abc_30082_auto_rtlil_cc_2608_muxgate_27327
* NET 10121 = abc_30082_auto_rtlil_cc_2608_muxgate_27325
* NET 10122 = abc_30082_auto_rtlil_cc_2608_muxgate_27323
* NET 10123 = abc_30082_auto_rtlil_cc_2608_muxgate_27321
* NET 10124 = abc_30082_auto_rtlil_cc_2608_muxgate_27319
* NET 10125 = abc_30082_auto_rtlil_cc_2608_muxgate_27317
* NET 10126 = abc_30082_auto_rtlil_cc_2608_muxgate_27315
* NET 10127 = abc_30082_auto_rtlil_cc_2608_muxgate_27313
* NET 10128 = abc_30082_auto_rtlil_cc_2608_muxgate_27311
* NET 10129 = abc_30082_auto_rtlil_cc_2608_muxgate_27309
* NET 10130 = abc_30082_auto_rtlil_cc_2608_muxgate_27307
* NET 10131 = abc_30082_auto_rtlil_cc_2608_muxgate_27305
* NET 10132 = abc_30082_auto_rtlil_cc_2608_muxgate_27303
* NET 10133 = abc_30082_auto_rtlil_cc_2608_muxgate_27301
* NET 10134 = abc_30082_auto_rtlil_cc_2608_muxgate_27299
* NET 10135 = abc_30082_auto_rtlil_cc_2608_muxgate_27297
* NET 10136 = abc_30082_auto_rtlil_cc_2608_muxgate_27295
* NET 10137 = abc_30082_auto_rtlil_cc_2608_muxgate_27293
* NET 10138 = abc_30082_auto_rtlil_cc_2608_muxgate_27291
* NET 10139 = abc_30082_auto_rtlil_cc_2608_muxgate_27289
* NET 10140 = abc_30082_auto_rtlil_cc_2608_muxgate_27287
* NET 10141 = abc_30082_auto_rtlil_cc_2608_muxgate_27285
* NET 10142 = abc_30082_auto_rtlil_cc_2608_muxgate_27283
* NET 10143 = abc_30082_auto_rtlil_cc_2608_muxgate_27281
* NET 10144 = abc_30082_auto_rtlil_cc_2608_muxgate_27279
* NET 10145 = abc_30082_auto_rtlil_cc_2608_muxgate_27277
* NET 10146 = abc_30082_auto_rtlil_cc_2608_muxgate_27275
* NET 10147 = abc_30082_auto_rtlil_cc_2608_muxgate_27273
* NET 10148 = abc_30082_auto_rtlil_cc_2608_muxgate_27271
* NET 10149 = abc_30082_auto_rtlil_cc_2608_muxgate_27269
* NET 10150 = abc_30082_auto_rtlil_cc_2608_muxgate_27267
* NET 10151 = abc_30082_auto_rtlil_cc_2608_muxgate_27265
* NET 10152 = abc_30082_auto_rtlil_cc_2608_muxgate_27263
* NET 10153 = abc_30082_auto_rtlil_cc_2608_muxgate_27261
* NET 10154 = abc_30082_auto_rtlil_cc_2608_muxgate_27259
* NET 10155 = abc_30082_auto_rtlil_cc_2608_muxgate_27257
* NET 10156 = abc_30082_auto_rtlil_cc_2608_muxgate_27255
* NET 10157 = abc_30082_auto_rtlil_cc_2608_muxgate_27253
* NET 10158 = abc_30082_auto_rtlil_cc_2608_muxgate_27251
* NET 10159 = abc_30082_auto_rtlil_cc_2608_muxgate_27249
* NET 10160 = abc_30082_auto_rtlil_cc_2608_muxgate_27247
* NET 10161 = abc_30082_auto_rtlil_cc_2608_muxgate_27245
* NET 10162 = abc_30082_auto_rtlil_cc_2608_muxgate_27243
* NET 10163 = abc_30082_auto_rtlil_cc_2608_muxgate_27241
* NET 10164 = abc_30082_auto_rtlil_cc_2608_muxgate_27239
* NET 10165 = abc_30082_auto_rtlil_cc_2608_muxgate_27237
* NET 10166 = abc_30082_auto_rtlil_cc_2608_muxgate_27235
* NET 10167 = abc_30082_auto_rtlil_cc_2608_muxgate_27233
* NET 10168 = abc_30082_auto_rtlil_cc_2608_muxgate_27231
* NET 10169 = abc_30082_auto_rtlil_cc_2608_muxgate_27229
* NET 10170 = abc_30082_auto_rtlil_cc_2608_muxgate_27227
* NET 10171 = abc_30082_auto_rtlil_cc_2608_muxgate_27225
* NET 10172 = abc_30082_auto_rtlil_cc_2608_muxgate_27223
* NET 10173 = abc_30082_auto_rtlil_cc_2608_muxgate_27221
* NET 10174 = abc_30082_auto_rtlil_cc_2608_muxgate_27219
* NET 10175 = abc_30082_auto_rtlil_cc_2608_muxgate_27217
* NET 10176 = abc_30082_auto_rtlil_cc_2608_muxgate_27215
* NET 10177 = abc_30082_auto_rtlil_cc_2608_muxgate_27213
* NET 10178 = abc_30082_auto_rtlil_cc_2608_muxgate_27211
* NET 10179 = abc_30082_auto_rtlil_cc_2608_muxgate_27209
* NET 10180 = abc_30082_auto_rtlil_cc_2608_muxgate_27207
* NET 10181 = abc_30082_auto_rtlil_cc_2608_muxgate_27205
* NET 10182 = abc_30082_auto_rtlil_cc_2608_muxgate_27203
* NET 10183 = abc_30082_auto_rtlil_cc_2608_muxgate_27201
* NET 10184 = abc_30082_auto_rtlil_cc_2608_muxgate_27199
* NET 10185 = abc_30082_auto_rtlil_cc_2608_muxgate_27197
* NET 10186 = abc_30082_auto_rtlil_cc_2608_muxgate_27195
* NET 10187 = abc_30082_auto_rtlil_cc_2608_muxgate_27193
* NET 10188 = abc_30082_auto_rtlil_cc_2608_muxgate_27191
* NET 10189 = abc_30082_auto_rtlil_cc_2608_muxgate_27189
* NET 10190 = abc_30082_auto_rtlil_cc_2608_muxgate_27187
* NET 10191 = abc_30082_auto_rtlil_cc_2608_muxgate_27185
* NET 10192 = abc_30082_auto_rtlil_cc_2608_muxgate_27183
* NET 10193 = abc_30082_auto_rtlil_cc_2608_muxgate_27181
* NET 10194 = abc_30082_auto_rtlil_cc_2608_muxgate_27179
* NET 10195 = abc_30082_auto_rtlil_cc_2608_muxgate_27177
* NET 10196 = abc_30082_auto_rtlil_cc_2608_muxgate_27175
* NET 10197 = abc_30082_auto_rtlil_cc_2608_muxgate_27173
* NET 10198 = abc_30082_auto_rtlil_cc_2608_muxgate_27171
* NET 10199 = abc_30082_auto_rtlil_cc_2608_muxgate_27169
* NET 10200 = abc_30082_auto_rtlil_cc_2608_muxgate_27167
* NET 10201 = abc_30082_auto_rtlil_cc_2608_muxgate_27165
* NET 10202 = abc_30082_auto_rtlil_cc_2608_muxgate_27163
* NET 10203 = abc_30082_auto_rtlil_cc_2608_muxgate_27161
* NET 10204 = abc_30082_auto_rtlil_cc_2608_muxgate_27159
* NET 10205 = abc_30082_auto_rtlil_cc_2608_muxgate_27157
* NET 10206 = abc_30082_auto_rtlil_cc_2608_muxgate_27155
* NET 10207 = abc_30082_auto_rtlil_cc_2608_muxgate_27153
* NET 10208 = abc_30082_auto_rtlil_cc_2608_muxgate_27151
* NET 10209 = abc_30082_auto_rtlil_cc_2608_muxgate_27149
* NET 10210 = abc_30082_auto_rtlil_cc_2608_muxgate_27147
* NET 10211 = abc_30082_auto_rtlil_cc_2608_muxgate_27145
* NET 10212 = abc_30082_auto_rtlil_cc_2608_muxgate_27143
* NET 10213 = abc_30082_auto_rtlil_cc_2608_muxgate_27141
* NET 10214 = abc_30082_auto_rtlil_cc_2608_muxgate_27139
* NET 10215 = abc_30082_auto_rtlil_cc_2608_muxgate_27137
* NET 10216 = abc_30082_auto_rtlil_cc_2608_muxgate_27135
* NET 10217 = abc_30082_auto_rtlil_cc_2608_muxgate_27133
* NET 10218 = abc_30082_auto_rtlil_cc_2608_muxgate_27131
* NET 10219 = abc_30082_auto_rtlil_cc_2608_muxgate_27129
* NET 10220 = abc_30082_auto_rtlil_cc_2608_muxgate_27127
* NET 10221 = abc_30082_auto_rtlil_cc_2608_muxgate_27125
* NET 10222 = abc_30082_auto_rtlil_cc_2608_muxgate_27123
* NET 10223 = abc_30082_auto_rtlil_cc_2608_muxgate_27121
* NET 10224 = abc_30082_auto_rtlil_cc_2608_muxgate_27119
* NET 10225 = abc_30082_auto_rtlil_cc_2608_muxgate_27117
* NET 10226 = abc_30082_auto_rtlil_cc_2608_muxgate_27115
* NET 10227 = abc_30082_auto_rtlil_cc_2608_muxgate_27113
* NET 10228 = abc_30082_auto_rtlil_cc_2608_muxgate_27111
* NET 10229 = abc_30082_auto_rtlil_cc_2608_muxgate_27109
* NET 10230 = abc_30082_auto_rtlil_cc_2608_muxgate_27107
* NET 10231 = abc_30082_auto_rtlil_cc_2608_muxgate_27105
* NET 10232 = abc_30082_auto_rtlil_cc_2608_muxgate_27103
* NET 10233 = abc_30082_auto_rtlil_cc_2608_muxgate_27101
* NET 10234 = abc_30082_auto_rtlil_cc_2608_muxgate_27099
* NET 10235 = abc_30082_auto_rtlil_cc_2608_muxgate_27097
* NET 10236 = abc_30082_auto_rtlil_cc_2608_muxgate_27095
* NET 10237 = abc_30082_auto_rtlil_cc_2608_muxgate_27093
* NET 10238 = abc_30082_auto_rtlil_cc_2608_muxgate_27091
* NET 10239 = abc_30082_auto_rtlil_cc_2608_muxgate_27089
* NET 10240 = abc_30082_auto_rtlil_cc_2608_muxgate_27087
* NET 10241 = abc_30082_auto_rtlil_cc_2608_muxgate_27085
* NET 10242 = abc_30082_auto_rtlil_cc_2608_muxgate_27083
* NET 10243 = abc_30082_auto_rtlil_cc_2608_muxgate_27081
* NET 10244 = abc_30082_auto_rtlil_cc_2608_muxgate_27079
* NET 10245 = abc_30082_auto_rtlil_cc_2608_muxgate_27077
* NET 10246 = abc_30082_auto_rtlil_cc_2608_muxgate_27075
* NET 10247 = abc_30082_auto_rtlil_cc_2608_muxgate_27073
* NET 10248 = abc_30082_auto_rtlil_cc_2608_muxgate_27071
* NET 10249 = abc_30082_auto_rtlil_cc_2608_muxgate_27069
* NET 10250 = abc_30082_auto_rtlil_cc_2608_muxgate_27067
* NET 10251 = abc_30082_auto_rtlil_cc_2608_muxgate_27065
* NET 10252 = abc_30082_auto_rtlil_cc_2608_muxgate_27063
* NET 10253 = abc_30082_auto_rtlil_cc_2608_muxgate_27061
* NET 10254 = abc_30082_auto_rtlil_cc_2608_muxgate_27059
* NET 10255 = abc_30082_auto_rtlil_cc_2608_muxgate_27057
* NET 10256 = abc_30082_auto_rtlil_cc_2608_muxgate_27055
* NET 10257 = abc_30082_auto_rtlil_cc_2608_muxgate_27053
* NET 10258 = abc_30082_auto_rtlil_cc_2608_muxgate_27051
* NET 10259 = abc_30082_auto_rtlil_cc_2608_muxgate_27049
* NET 10260 = abc_30082_auto_rtlil_cc_2608_muxgate_27047
* NET 10261 = abc_30082_auto_rtlil_cc_2608_muxgate_27045
* NET 10262 = abc_30082_auto_rtlil_cc_2608_muxgate_27043
* NET 10263 = abc_30082_auto_rtlil_cc_2608_muxgate_27041
* NET 10264 = abc_30082_auto_rtlil_cc_2608_muxgate_27039
* NET 10265 = abc_30082_auto_rtlil_cc_2608_muxgate_27037
* NET 10266 = abc_30082_auto_rtlil_cc_2608_muxgate_27035
* NET 10267 = abc_30082_auto_rtlil_cc_2608_muxgate_27033
* NET 10268 = abc_30082_auto_rtlil_cc_2608_muxgate_27031
* NET 10269 = abc_30082_auto_rtlil_cc_2608_muxgate_27029
* NET 10270 = abc_30082_auto_rtlil_cc_2608_muxgate_27027
* NET 10271 = abc_30082_auto_rtlil_cc_2608_muxgate_27025
* NET 10272 = abc_30082_auto_rtlil_cc_2608_muxgate_27023
* NET 10273 = abc_30082_auto_rtlil_cc_2608_muxgate_27021
* NET 10274 = abc_30082_auto_rtlil_cc_2608_muxgate_27019
* NET 10275 = abc_30082_auto_rtlil_cc_2608_muxgate_27017
* NET 10276 = abc_30082_auto_rtlil_cc_2608_muxgate_27015
* NET 10277 = abc_30082_auto_rtlil_cc_2608_muxgate_27013
* NET 10278 = abc_30082_auto_rtlil_cc_2608_muxgate_27011
* NET 10279 = abc_30082_auto_rtlil_cc_2608_muxgate_27009
* NET 10280 = abc_30082_auto_rtlil_cc_2608_muxgate_27007
* NET 10281 = abc_30082_auto_rtlil_cc_2608_muxgate_27005
* NET 10282 = abc_30082_auto_rtlil_cc_2608_muxgate_27003
* NET 10283 = abc_30082_auto_rtlil_cc_2608_muxgate_27001
* NET 10284 = abc_30082_auto_rtlil_cc_2608_muxgate_26999
* NET 10285 = abc_30082_auto_rtlil_cc_2608_muxgate_26997
* NET 10286 = abc_30082_auto_rtlil_cc_2608_muxgate_26995
* NET 10287 = abc_30082_auto_rtlil_cc_2608_muxgate_26993
* NET 10288 = abc_30082_auto_rtlil_cc_2608_muxgate_26991
* NET 10289 = abc_30082_auto_rtlil_cc_2608_muxgate_26989
* NET 10290 = abc_30082_auto_rtlil_cc_2608_muxgate_26987
* NET 10291 = abc_30082_auto_rtlil_cc_2608_muxgate_26985
* NET 10292 = abc_30082_auto_rtlil_cc_2608_muxgate_26983
* NET 10293 = abc_30082_auto_rtlil_cc_2608_muxgate_26981
* NET 10294 = abc_30082_auto_rtlil_cc_2608_muxgate_26979
* NET 10295 = abc_30082_auto_rtlil_cc_2608_muxgate_26977
* NET 10296 = abc_30082_auto_rtlil_cc_2608_muxgate_26975
* NET 10297 = abc_30082_auto_rtlil_cc_2608_muxgate_26973
* NET 10298 = abc_30082_auto_rtlil_cc_2608_muxgate_26971
* NET 10299 = abc_30082_auto_rtlil_cc_2608_muxgate_26969
* NET 10300 = abc_30082_auto_rtlil_cc_2608_muxgate_26967
* NET 10301 = abc_30082_auto_rtlil_cc_2608_muxgate_26965
* NET 10302 = abc_30082_auto_rtlil_cc_2608_muxgate_26963
* NET 10303 = abc_30082_auto_rtlil_cc_2608_muxgate_26961
* NET 10304 = abc_30082_auto_rtlil_cc_2608_muxgate_26959
* NET 10305 = abc_30082_auto_rtlil_cc_2608_muxgate_26957
* NET 10306 = abc_30082_auto_rtlil_cc_2608_muxgate_26955
* NET 10307 = abc_30082_auto_rtlil_cc_2608_muxgate_26953
* NET 10308 = abc_30082_auto_rtlil_cc_2608_muxgate_26951
* NET 10309 = abc_30082_auto_rtlil_cc_2608_muxgate_26949
* NET 10310 = abc_30082_auto_rtlil_cc_2608_muxgate_26947
* NET 10311 = abc_30082_auto_rtlil_cc_2608_muxgate_26945
* NET 10312 = abc_30082_auto_rtlil_cc_2608_muxgate_26943
* NET 10313 = abc_30082_auto_rtlil_cc_2608_muxgate_26941
* NET 10314 = abc_30082_auto_rtlil_cc_2608_muxgate_26939
* NET 10315 = abc_30082_auto_rtlil_cc_2608_muxgate_26937
* NET 10316 = abc_30082_auto_rtlil_cc_2608_muxgate_26935
* NET 10317 = abc_30082_auto_rtlil_cc_2608_muxgate_26933
* NET 10318 = abc_30082_auto_rtlil_cc_2608_muxgate_26931
* NET 10319 = abc_30082_auto_rtlil_cc_2608_muxgate_26929
* NET 10320 = abc_30082_auto_rtlil_cc_2608_muxgate_26927
* NET 10321 = abc_30082_auto_rtlil_cc_2608_muxgate_26925
* NET 10322 = abc_30082_auto_rtlil_cc_2608_muxgate_26923
* NET 10323 = abc_30082_auto_rtlil_cc_2608_muxgate_26921
* NET 10324 = abc_30082_auto_rtlil_cc_2608_muxgate_26919
* NET 10325 = abc_30082_auto_rtlil_cc_2608_muxgate_26917
* NET 10326 = abc_30082_auto_rtlil_cc_2608_muxgate_26915
* NET 10327 = abc_30082_auto_rtlil_cc_2608_muxgate_26913
* NET 10328 = abc_30082_auto_rtlil_cc_2608_muxgate_26911
* NET 10329 = abc_30082_auto_rtlil_cc_2608_muxgate_26909
* NET 10330 = abc_30082_auto_rtlil_cc_2608_muxgate_26907
* NET 10331 = abc_30082_auto_rtlil_cc_2608_muxgate_26905
* NET 10332 = abc_30082_auto_rtlil_cc_2608_muxgate_26903
* NET 10333 = abc_30082_auto_rtlil_cc_2608_muxgate_26901
* NET 10334 = abc_30082_auto_rtlil_cc_2608_muxgate_26899
* NET 10335 = abc_30082_auto_rtlil_cc_2608_muxgate_26897
* NET 10336 = abc_30082_auto_rtlil_cc_2608_muxgate_26895
* NET 10337 = abc_30082_auto_rtlil_cc_2608_muxgate_26893
* NET 10338 = abc_30082_auto_rtlil_cc_2608_muxgate_26891
* NET 10339 = abc_30082_auto_rtlil_cc_2608_muxgate_26889
* NET 10340 = abc_30082_auto_rtlil_cc_2608_muxgate_26887
* NET 10341 = abc_30082_auto_rtlil_cc_2608_muxgate_26885
* NET 10342 = abc_30082_auto_rtlil_cc_2608_muxgate_26883
* NET 10343 = abc_30082_auto_rtlil_cc_2608_muxgate_26881
* NET 10344 = abc_30082_auto_rtlil_cc_2608_muxgate_26879
* NET 10345 = abc_30082_auto_rtlil_cc_2608_muxgate_26877
* NET 10346 = abc_30082_auto_rtlil_cc_2608_muxgate_26875
* NET 10347 = abc_30082_auto_rtlil_cc_2608_muxgate_26873
* NET 10348 = abc_30082_auto_rtlil_cc_2608_muxgate_26871
* NET 10349 = abc_30082_auto_rtlil_cc_2608_muxgate_26869
* NET 10350 = abc_30082_auto_rtlil_cc_2608_muxgate_26867
* NET 10351 = abc_30082_auto_rtlil_cc_2608_muxgate_26865
* NET 10352 = abc_30082_auto_rtlil_cc_2608_muxgate_26863
* NET 10353 = abc_30082_auto_rtlil_cc_2608_muxgate_26861
* NET 10354 = abc_30082_auto_rtlil_cc_2608_muxgate_26859
* NET 10355 = abc_30082_auto_rtlil_cc_2608_muxgate_26857
* NET 10356 = abc_30082_auto_rtlil_cc_2608_muxgate_26855
* NET 10357 = abc_30082_auto_rtlil_cc_2608_muxgate_26853
* NET 10358 = abc_30082_auto_rtlil_cc_2608_muxgate_26851
* NET 10359 = abc_30082_auto_rtlil_cc_2608_muxgate_26849
* NET 10360 = abc_30082_auto_rtlil_cc_2608_muxgate_26847
* NET 10361 = abc_30082_auto_rtlil_cc_2608_muxgate_26845
* NET 10362 = abc_30082_auto_rtlil_cc_2608_muxgate_26843
* NET 10363 = abc_30082_auto_rtlil_cc_2608_muxgate_26841
* NET 10364 = abc_30082_auto_rtlil_cc_2608_muxgate_26839
* NET 10365 = abc_30082_auto_rtlil_cc_2608_muxgate_26837
* NET 10366 = abc_30082_auto_rtlil_cc_2608_muxgate_26835
* NET 10367 = abc_30082_auto_rtlil_cc_2608_muxgate_26833
* NET 10368 = abc_30082_auto_rtlil_cc_2608_muxgate_26831
* NET 10369 = abc_30082_auto_rtlil_cc_2608_muxgate_26829
* NET 10370 = abc_30082_auto_rtlil_cc_2608_muxgate_26827
* NET 10371 = abc_30082_auto_rtlil_cc_2608_muxgate_26825
* NET 10372 = abc_30082_auto_rtlil_cc_2608_muxgate_26823
* NET 10373 = abc_30082_auto_rtlil_cc_2608_muxgate_26821
* NET 10374 = abc_30082_auto_rtlil_cc_2608_muxgate_26819
* NET 10375 = abc_30082_auto_rtlil_cc_2608_muxgate_26817
* NET 10376 = abc_30082_auto_rtlil_cc_2608_muxgate_26815
* NET 10377 = abc_30082_auto_rtlil_cc_2608_muxgate_26813
* NET 10378 = abc_30082_auto_rtlil_cc_2608_muxgate_26811
* NET 10379 = abc_30082_auto_rtlil_cc_2608_muxgate_26809
* NET 10380 = abc_30082_auto_rtlil_cc_2608_muxgate_26807
* NET 10381 = abc_30082_auto_rtlil_cc_2608_muxgate_26805
* NET 10382 = abc_30082_auto_rtlil_cc_2608_muxgate_26803
* NET 10383 = abc_30082_auto_rtlil_cc_2608_muxgate_26801
* NET 10384 = abc_30082_auto_rtlil_cc_2608_muxgate_26799
* NET 10385 = abc_30082_auto_rtlil_cc_2608_muxgate_26797
* NET 10386 = abc_30082_auto_rtlil_cc_2608_muxgate_26795
* NET 10387 = abc_30082_auto_rtlil_cc_2608_muxgate_26793
* NET 10388 = abc_30082_auto_rtlil_cc_2608_muxgate_26791
* NET 10389 = abc_30082_auto_rtlil_cc_2608_muxgate_26789
* NET 10390 = abc_30082_auto_rtlil_cc_2608_muxgate_26787
* NET 10391 = abc_30082_auto_rtlil_cc_2608_muxgate_26785
* NET 10392 = abc_30082_auto_rtlil_cc_2608_muxgate_26783
* NET 10393 = abc_30082_auto_rtlil_cc_2608_muxgate_26781
* NET 10394 = abc_30082_auto_rtlil_cc_2608_muxgate_26779
* NET 10395 = abc_30082_auto_rtlil_cc_2608_muxgate_26777
* NET 10396 = abc_30082_auto_rtlil_cc_2608_muxgate_26775
* NET 10397 = abc_30082_auto_rtlil_cc_2608_muxgate_26773
* NET 10398 = abc_30082_auto_rtlil_cc_2608_muxgate_26771
* NET 10399 = abc_30082_auto_rtlil_cc_2608_muxgate_26769
* NET 10400 = abc_30082_auto_rtlil_cc_2608_muxgate_26767
* NET 10401 = abc_30082_auto_rtlil_cc_2608_muxgate_26765
* NET 10402 = abc_30082_auto_rtlil_cc_2608_muxgate_26763
* NET 10403 = abc_30082_auto_rtlil_cc_2608_muxgate_26761
* NET 10404 = abc_30082_auto_rtlil_cc_2608_muxgate_26759
* NET 10405 = abc_30082_auto_rtlil_cc_2608_muxgate_26757
* NET 10406 = abc_30082_auto_rtlil_cc_2608_muxgate_26755
* NET 10407 = abc_30082_auto_rtlil_cc_2608_muxgate_26753
* NET 10408 = abc_30082_auto_rtlil_cc_2608_muxgate_26751
* NET 10409 = abc_30082_auto_rtlil_cc_2608_muxgate_26749
* NET 10410 = abc_30082_auto_rtlil_cc_2608_muxgate_26747
* NET 10411 = abc_30082_auto_rtlil_cc_2608_muxgate_26745
* NET 10412 = abc_30082_auto_rtlil_cc_2608_muxgate_26743
* NET 10413 = abc_30082_auto_rtlil_cc_2608_muxgate_26741
* NET 10414 = abc_30082_auto_rtlil_cc_2608_muxgate_26739
* NET 10415 = abc_30082_auto_rtlil_cc_2608_muxgate_26737
* NET 10416 = abc_30082_auto_rtlil_cc_2608_muxgate_26735
* NET 10417 = abc_30082_auto_rtlil_cc_2608_muxgate_26733
* NET 10418 = abc_30082_auto_rtlil_cc_2608_muxgate_26731
* NET 10419 = abc_30082_auto_rtlil_cc_2608_muxgate_26729
* NET 10420 = abc_30082_auto_rtlil_cc_2608_muxgate_26727
* NET 10421 = abc_30082_auto_rtlil_cc_2608_muxgate_26725
* NET 10422 = abc_30082_auto_rtlil_cc_2608_muxgate_26723
* NET 10423 = abc_30082_auto_rtlil_cc_2608_muxgate_26721
* NET 10424 = abc_30082_auto_rtlil_cc_2608_muxgate_26719
* NET 10425 = abc_30082_auto_rtlil_cc_2608_muxgate_26717
* NET 10426 = abc_30082_auto_rtlil_cc_2608_muxgate_26715
* NET 10427 = abc_30082_auto_rtlil_cc_2608_muxgate_26713
* NET 10428 = abc_30082_auto_rtlil_cc_2608_muxgate_26711
* NET 10429 = abc_30082_auto_rtlil_cc_2608_muxgate_26709
* NET 10430 = abc_30082_auto_rtlil_cc_2608_muxgate_26707
* NET 10431 = abc_30082_auto_rtlil_cc_2608_muxgate_26705
* NET 10432 = abc_30082_auto_rtlil_cc_2608_muxgate_26703
* NET 10433 = abc_30082_auto_rtlil_cc_2608_muxgate_26701
* NET 10434 = abc_30082_auto_rtlil_cc_2608_muxgate_26699
* NET 10435 = abc_30082_auto_rtlil_cc_2608_muxgate_26697
* NET 10436 = abc_30082_auto_rtlil_cc_2608_muxgate_26695
* NET 10437 = abc_30082_auto_rtlil_cc_2608_muxgate_26693
* NET 10438 = abc_30082_auto_rtlil_cc_2608_muxgate_26691
* NET 10439 = abc_30082_auto_rtlil_cc_2608_muxgate_26689
* NET 10440 = abc_30082_auto_rtlil_cc_2608_muxgate_26687
* NET 10441 = abc_30082_auto_rtlil_cc_2608_muxgate_26685
* NET 10442 = abc_30082_auto_rtlil_cc_2608_muxgate_26683
* NET 10443 = abc_30082_auto_rtlil_cc_2608_muxgate_26681
* NET 10444 = abc_30082_auto_rtlil_cc_2608_muxgate_26679
* NET 10445 = abc_30082_auto_rtlil_cc_2608_muxgate_26677
* NET 10446 = abc_30082_auto_rtlil_cc_2608_muxgate_26675
* NET 10447 = abc_30082_auto_rtlil_cc_2608_muxgate_26673
* NET 10448 = abc_20123_auto_rtlil_cc_2497_mux_4295[4]
* NET 10449 = abc_20123_auto_rtlil_cc_2497_mux_4295[3]
* NET 10450 = abc_20123_auto_rtlil_cc_2497_mux_4295[2]
* NET 10451 = abc_20123_auto_rtlil_cc_2497_mux_4295[1]
* NET 10452 = abc_20123_auto_rtlil_cc_2497_mux_4295[0]
* NET 10453 = abc_20123_auto_rtlil_cc_2497_mux_4292[4]
* NET 10454 = abc_20123_auto_rtlil_cc_2497_mux_4292[3]
* NET 10455 = abc_20123_auto_rtlil_cc_2497_mux_4292[2]
* NET 10456 = abc_20123_auto_rtlil_cc_2497_mux_4292[1]
* NET 10457 = abc_20123_auto_rtlil_cc_2497_mux_4292[0]
* NET 10458 = abc_20123_auto_fsm_map_cc_170_map_fsm_3816[2]
* NET 10459 = abc_20123_auto_fsm_map_cc_170_map_fsm_3816[1]
* NET 10460 = abc_20123_auto_fsm_map_cc_170_map_fsm_3816[0]
* NET 10461 = abc_20123_auto_fsm_map_cc_170_map_fsm_3615[6]
* NET 10462 = abc_20123_auto_fsm_map_cc_170_map_fsm_3615[5]
* NET 10463 = abc_20123_auto_fsm_map_cc_170_map_fsm_3615[4]
* NET 10464 = abc_20123_auto_fsm_map_cc_170_map_fsm_3615[3]
* NET 10465 = abc_20123_auto_fsm_map_cc_170_map_fsm_3615[2]
* NET 10466 = abc_20123_auto_fsm_map_cc_170_map_fsm_3615[1]
* NET 10467 = abc_20123_auto_fsm_map_cc_170_map_fsm_3615[0]

xfeed_409 1 0 tie
xfeed_408 1 0 decap_w0
xfeed_407 1 0 tie
xfeed_406 1 0 decap_w0
xfeed_405 1 0 decap_w0
xfeed_404 1 0 decap_w0
xfeed_403 1 0 decap_w0
xfeed_402 1 0 tie
xfeed_401 1 0 decap_w0
xfeed_400 1 0 tie
xspare_feed_359 1 0 tie
xspare_feed_358 1 0 decap_w0
xspare_feed_357 1 0 tie
xspare_feed_356 1 0 tie
xspare_feed_355 1 0 decap_w0
xspare_feed_354 1 0 tie
xspare_feed_353 1 0 tie
xspare_feed_352 1 0 decap_w0
xspare_feed_351 1 0 tie
xspare_feed_350 1 0 tie
xspare_buffer_44 1 0 2252 2245 buf_x4
xspare_buffer_42 1 0 2252 2246 buf_x4
xspare_buffer_41 1 0 2252 2247 buf_x4
xspare_buffer_40 1 0 2252 2248 buf_x4
xsubckt_471_nor4_x0 1 0 7866 640 633 638 629 nor4_x0
xsubckt_653_o2_x2 0 7688 1 7690 7692 o2_x2
xsubckt_1125_nand2_x0 1 0 7236 634 1956 nand2_x0
xsubckt_1128_a2_x2 0 7233 1 7234 7240 a2_x2
xsubckt_3257_oa22_x2 0 5108 1 5109 5148 5958 oa22_x2
xsubckt_3316_nand3_x0 1 0 5050 5051 5054 5949 nand3_x0
xsubckt_3494_nand3_x0 1 0 4875 4880 4884 771 nand3_x0
xsubckt_5082_nand2_x0 1 0 3801 3803 3805 nand2_x0
xsubckt_6233_mx2_x2 0 2785 1 860 1243 1211 mx2_x2
xsubckt_6235_mx2_x2 0 2783 1 8220 2784 2785 mx2_x2
xsubckt_8893_sff1_x4 1 2050 0 9532 342 sff1_x4
xsubckt_8815_sff1_x4 1 2066 0 9607 710 sff1_x4
xsubckt_8458_sff1_x4 1 2060 0 9899 1947 sff1_x4
xsubckt_8370_sff1_x4 1 2245 0 9987 1502 sff1_x4
xsubckt_7993_sff1_x4 1 2206 0 10364 1782 sff1_x4
xsubckt_7321_ao22_x2 0 9492 1 8526 8524 8523 ao22_x2
xsubckt_7051_a2_x2 0 8685 1 370 564 a2_x2
xsubckt_6628_mx2_x2 0 2401 1 8219 2402 2403 mx2_x2
xsubckt_6626_mx2_x2 0 2403 1 853 1359 1327 mx2_x2
xsubckt_6580_mx2_x2 0 2448 1 833 2449 2450 mx2_x2
xsubckt_6237_mx2_x2 0 2781 1 860 1659 1627 mx2_x2
xsubckt_1323_a2_x2 0 7042 1 445 226 a2_x2
xsubckt_1490_a3_x2 1 6873 0 6874 6875 6876 a3_x2
xsubckt_1496_nxr2_x1 6868 1 0 6870 222 nxr2_x1
xsubckt_1549_a3_x2 1 6818 0 6819 6820 6821 a3_x2
xsubckt_2095_nand2_x0 1 0 6351 6352 7854 nand2_x0
xcmpt_abc_30082_new_n5643_hfns_2 1 0 6009 6006 buf_x4
xcmpt_abc_30082_new_n5643_hfns_1 1 0 6006 6007 buf_x4
xcmpt_abc_30082_new_n5643_hfns_0 1 0 6006 6008 buf_x4
xspare_buffer_49 1 0 2252 2241 buf_x4
xspare_buffer_48 1 0 2252 2242 buf_x4
xspare_buffer_46 1 0 2252 2243 buf_x4
xspare_buffer_45 1 0 2252 2244 buf_x4
xsubckt_1812_a2_x2 0 6573 1 6574 230 a2_x2
xsubckt_1617_a2_x2 0 6755 1 6756 244 a2_x2
xsubckt_1383_a2_x2 0 6982 1 6983 6984 a2_x2
xsubckt_872_nand2_x0 1 0 7476 7477 1895 nand2_x0
xsubckt_2792_oa22_x2 0 5566 1 5625 5623 5622 oa22_x2
xsubckt_3140_nand2_x0 1 0 5223 6012 8106 nand2_x0
xsubckt_3455_a2_x2 0 4914 1 4915 4922 a2_x2
xsubckt_3630_a2_x2 0 4742 1 234 753 a2_x2
xsubckt_4189_a2_x2 0 4221 1 8007 555 a2_x2
xsubckt_5098_a2_x2 0 3786 1 3787 3790 a2_x2
xsubckt_5293_a2_x2 0 3605 1 3891 730 a2_x2
xsubckt_5507_a2_x2 0 9787 1 3425 54 a2_x2
xsubckt_5527_a2_x2 0 9781 1 3411 54 a2_x2
xsubckt_5687_ao22_x2 0 3287 1 503 7998 7995 ao22_x2
xsubckt_5700_mx2_x2 0 9735 1 3282 498 535 mx2_x2
xsubckt_5702_mx2_x2 0 9733 1 3282 496 533 mx2_x2
xsubckt_9266_sff1_x4 1 2145 0 9174 1426 sff1_x4
xsubckt_8889_sff1_x4 1 2070 0 9536 346 sff1_x4
xsubckt_8366_sff1_x4 1 2195 0 9991 1476 sff1_x4
xsubckt_7915_sff1_x4 1 2192 0 10437 1825 sff1_x4
xsubckt_7619_a2_x2 0 8462 1 4171 4195 a2_x2
xsubckt_7015_nor3_x0 1 0 8692 371 372 373 nor3_x0
xsubckt_6944_ao22_x2 0 8751 1 707 8277 625 ao22_x2
xsubckt_6586_mx2_x2 0 2442 1 859 1040 1008 mx2_x2
xsubckt_6584_mx2_x2 0 2444 1 8220 2445 2446 mx2_x2
xsubckt_6582_mx2_x2 0 2446 1 859 1872 1520 mx2_x2
xsubckt_6239_mx2_x2 0 2779 1 8220 2780 2781 mx2_x2
xsubckt_6195_mx2_x2 0 2822 1 859 1308 1276 mx2_x2
xsubckt_6193_mx2_x2 0 2824 1 826 2825 2832 mx2_x2
xsubckt_6191_mx2_x2 0 2826 1 833 2827 2828 mx2_x2
xsubckt_5704_mx2_x2 0 9731 1 3282 494 531 mx2_x2
xfeed_419 1 0 decap_w0
xfeed_418 1 0 tie
xfeed_417 1 0 decap_w0
xfeed_416 1 0 decap_w0
xfeed_415 1 0 tie
xfeed_414 1 0 decap_w0
xfeed_413 1 0 decap_w0
xfeed_412 1 0 decap_w0
xfeed_411 1 0 decap_w0
xfeed_410 1 0 tie
xspare_feed_369 1 0 tie
xspare_feed_368 1 0 tie
xspare_feed_367 1 0 decap_w0
xspare_feed_366 1 0 tie
xspare_feed_365 1 0 tie
xspare_feed_364 1 0 decap_w0
xspare_feed_363 1 0 tie
xspare_feed_362 1 0 tie
xspare_feed_361 1 0 decap_w0
xspare_feed_360 1 0 tie
xcmpt_abc_30082_new_n5256_hfns_3 1 0 6451 6447 buf_x4
xcmpt_abc_30082_new_n5256_hfns_2 1 0 6447 6448 buf_x4
xcmpt_abc_30082_new_n5256_hfns_1 1 0 6447 6449 buf_x4
xcmpt_abc_30082_new_n5256_hfns_0 1 0 6447 6450 buf_x4
xspare_buffer_50 1 0 2252 2240 buf_x4
xsubckt_1457_oa22_x2 0 6905 1 6917 6912 6913 oa22_x2
xsubckt_1215_xr2_x1 7150 0 1 200 232 xr2_x1
xsubckt_522_oa22_x2 0 10463 1 1905 7819 7817 oa22_x2
xsubckt_2875_nand2_x0 1 0 5484 5485 8023 nand2_x0
xsubckt_3136_nand3_x0 1 0 5227 5228 5231 5950 nand3_x0
xsubckt_3688_oa22_x2 0 4685 1 4743 4740 4742 oa22_x2
xsubckt_4520_mx3_x2 1 0 10053 4164 6294 1664 6197 6201 mx3_x2
xsubckt_4678_a2_x2 0 9927 1 4114 47 a2_x2
xsubckt_4787_ao22_x2 0 4031 1 4033 8333 1948 ao22_x2
xsubckt_4833_a2_x2 0 3996 1 3997 47 a2_x2
xsubckt_4911_mx3_x2 1 0 3940 6448 546 8369 8199 8200 mx3_x2
xsubckt_4945_oa22_x2 0 9859 1 7885 3915 3917 oa22_x2
xsubckt_5660_mx2_x2 0 3313 1 789 3314 3315 mx2_x2
xsubckt_5706_mx2_x2 0 9729 1 3283 492 529 mx2_x2
xsubckt_5708_mx2_x2 0 9727 1 3283 490 527 mx2_x2
xsubckt_6197_mx2_x2 0 2820 1 858 1244 1212 mx2_x2
xsubckt_6199_mx2_x2 0 2818 1 8221 2819 2820 mx2_x2
xsubckt_6588_mx2_x2 0 2440 1 8213 2441 2444 mx2_x2
xsubckt_6905_a2_x2 0 9654 1 8781 47 a2_x2
xsubckt_7317_ao22_x2 0 8526 1 8606 8686 380 ao22_x2
xsubckt_7989_sff1_x4 1 2203 0 10368 1787 sff1_x4
xsubckt_8200_sff1_x4 1 2106 0 10157 1260 sff1_x4
xsubckt_8723_sff1_x4 1 2179 0 2293 2261 sff1_x4
xsubckt_9100_sff1_x4 1 2212 0 9340 889 sff1_x4
xsubckt_1462_nand3_x0 1 0 6900 6903 445 8416 nand3_x0
xsubckt_1657_a2_x2 0 6718 1 6719 8416 a2_x2
xsubckt_1815_nand2_x0 1 0 6570 6572 6577 nand2_x0
xsubckt_1852_a2_x2 0 6535 1 6536 6940 a2_x2
xsubckt_1872_a2_x2 0 6517 1 6518 8416 a2_x2
xspare_buffer_58 1 0 2239 2233 buf_x4
xspare_buffer_57 1 0 2239 2234 buf_x4
xspare_buffer_56 1 0 2239 2235 buf_x4
xspare_buffer_54 1 0 2239 2236 buf_x4
xspare_buffer_53 1 0 2239 2237 buf_x4
xspare_buffer_52 1 0 2239 2238 buf_x4
xsubckt_9174_sff1_x4 1 2111 0 9266 1390 sff1_x4
xsubckt_8797_sff1_x4 1 2079 0 9625 722 sff1_x4
xsubckt_8274_sff1_x4 1 2251 0 10083 1310 sff1_x4
xsubckt_6985_a2_x2 0 8719 1 398 399 a2_x2
xsubckt_5666_mx2_x2 0 3307 1 809 1226 1194 mx2_x2
xsubckt_5664_mx2_x2 0 3309 1 784 3310 3313 mx2_x2
xsubckt_5662_mx2_x2 0 3311 1 809 1866 1514 mx2_x2
xsubckt_5595_ao22_x2 0 3363 1 3367 1997 46 ao22_x2
xsubckt_5265_nxr2_x1 3631 1 0 3898 732 nxr2_x1
xsubckt_4915_mx3_x2 1 0 3937 6448 546 8370 8197 8198 mx3_x2
xsubckt_4000_mx2_x2 0 4378 1 809 1870 1518 mx2_x2
xsubckt_3992_nxr2_x1 4386 1 0 228 747 nxr2_x1
xsubckt_1219_xr2_x1 7146 0 1 199 231 xr2_x1
xsubckt_1311_o2_x2 0 7054 1 441 222 o2_x2
xsubckt_1326_nxr2_x1 7039 1 0 445 226 nxr2_x1
xsubckt_1725_nand2_x0 1 0 6654 6948 7126 nand2_x0
xsubckt_1849_nxr2_x1 6538 1 0 6542 228 nxr2_x1
xfeed_429 1 0 decap_w0
xfeed_428 1 0 decap_w0
xfeed_427 1 0 tie
xfeed_426 1 0 decap_w0
xfeed_425 1 0 decap_w0
xfeed_424 1 0 decap_w0
xfeed_423 1 0 decap_w0
xfeed_422 1 0 decap_w0
xfeed_421 1 0 tie
xfeed_420 1 0 decap_w0
xspare_feed_379 1 0 decap_w0
xspare_feed_378 1 0 tie
xspare_feed_377 1 0 tie
xspare_feed_376 1 0 decap_w0
xspare_feed_375 1 0 tie
xspare_feed_374 1 0 tie
xspare_feed_373 1 0 decap_w0
xspare_feed_372 1 0 tie
xspare_feed_371 1 0 tie
xspare_feed_370 1 0 decap_w0
xsubckt_9082_sff1_x4 1 2096 0 9358 899 sff1_x4
xsubckt_8719_sff1_x4 1 2153 0 2319 2287 sff1_x4
xsubckt_8631_sff1_x4 1 2156 0 177 114 sff1_x4
xsubckt_5668_mx2_x2 0 3305 1 8036 3306 3307 mx2_x2
xsubckt_5147_nand4_x0 1 0 3741 3782 3921 3924 3927 nand4_x0
xsubckt_4919_mx3_x2 1 0 3934 6450 545 8371 8195 8196 mx3_x2
xsubckt_4482_mx3_x2 1 0 10088 4170 6295 1285 6226 6230 mx3_x2
xsubckt_4006_mx2_x2 0 4372 1 791 4373 4374 mx2_x2
xsubckt_4004_mx2_x2 0 4374 1 809 1710 1678 mx2_x2
xsubckt_4002_mx2_x2 0 4376 1 8036 4377 4378 mx2_x2
xsubckt_3740_nand2_x0 1 0 4633 6011 8088 nand2_x0
xsubckt_3309_nand2_x0 1 0 5057 5058 8024 nand2_x0
xsubckt_2909_ao22_x2 0 5451 1 5509 5505 5506 ao22_x2
xsubckt_2622_oa22_x2 0 5733 1 5750 5748 5747 oa22_x2
xsubckt_1365_oa22_x2 0 7000 1 7001 7002 7114 oa22_x2
xsubckt_1605_o2_x2 0 6766 1 6767 6768 o2_x2
xspare_buffer_69 1 0 2226 2224 buf_x4
xspare_buffer_68 1 0 2226 2225 buf_x4
xspare_buffer_66 1 0 2239 2227 buf_x4
xspare_buffer_65 1 0 2239 2228 buf_x4
xspare_buffer_64 1 0 2239 2229 buf_x4
xspare_buffer_62 1 0 2239 2230 buf_x4
xspare_buffer_61 1 0 2239 2231 buf_x4
xspare_buffer_60 1 0 2239 2232 buf_x4
xsubckt_9004_sff1_x4 1 2123 0 10451 792 sff1_x4
xsubckt_8182_sff1_x4 1 2222 0 10175 1722 sff1_x4
xsubckt_4484_mx3_x2 1 0 10086 4170 6295 1313 6205 6210 mx3_x2
xsubckt_4355_mx2_x2 0 10204 1 4191 6116 1462 mx2_x2
xsubckt_4353_mx2_x2 0 10206 1 4191 6134 1465 mx2_x2
xsubckt_4351_mx2_x2 0 10208 1 4191 6151 1467 mx2_x2
xsubckt_4008_mx2_x2 0 4370 1 799 910 878 mx2_x2
xsubckt_3736_nand3_x0 1 0 4637 4638 4641 5949 nand3_x0
xsubckt_3129_nand2_x0 1 0 5234 5235 8022 nand2_x0
xsubckt_2618_oa22_x2 0 5736 1 5960 5752 5737 oa22_x2
xsubckt_949_oa22_x2 0 7403 1 7614 7478 7404 oa22_x2
xsubckt_2399_o2_x2 0 5954 1 713 732 o2_x2
xfeed_439 1 0 tie
xfeed_438 1 0 decap_w0
xfeed_437 1 0 decap_w0
xfeed_436 1 0 tie
xfeed_435 1 0 decap_w0
xfeed_434 1 0 decap_w0
xfeed_433 1 0 decap_w0
xfeed_432 1 0 decap_w0
xfeed_431 1 0 tie
xfeed_430 1 0 decap_w0
xspare_feed_389 1 0 tie
xspare_feed_388 1 0 decap_w0
xspare_feed_387 1 0 tie
xspare_feed_386 1 0 tie
xspare_feed_385 1 0 decap_w0
xspare_feed_384 1 0 tie
xspare_feed_383 1 0 tie
xspare_feed_382 1 0 decap_w0
xspare_feed_381 1 0 tie
xspare_feed_380 1 0 tie
xsubckt_9078_sff1_x4 1 2083 0 10464 1910 sff1_x4
xsubckt_8627_sff1_x4 1 2159 0 181 118 sff1_x4
xsubckt_8104_sff1_x4 1 2103 0 10253 1228 sff1_x4
xsubckt_6999_nor2_x0 1 0 8705 392 390 nor2_x0
xsubckt_6034_oa22_x2 0 2979 1 49 1905 213 oa22_x2
xsubckt_5618_nxr2_x1 3347 1 0 3351 8086 nxr2_x1
xsubckt_4796_nxr2_x1 4024 1 0 4026 8336 nxr2_x1
xsubckt_4359_mx2_x2 0 10200 1 4191 6080 1458 mx2_x2
xsubckt_4357_mx2_x2 0 10202 1 4191 6098 1460 mx2_x2
xsubckt_3822_mx2_x2 0 4553 1 806 1873 1521 mx2_x2
xsubckt_3820_mx2_x2 0 4555 1 790 4556 4557 mx2_x2
xsubckt_3560_nand2_x0 1 0 4810 6012 8094 nand2_x0
xsubckt_3268_ao22_x2 0 5098 1 5158 5156 5153 ao22_x2
xsubckt_861_oa22_x2 0 7487 1 7506 7504 7505 oa22_x2
xsubckt_581_nand3_x0 1 0 7757 7758 7759 7761 nand3_x0
xspare_buffer_78 1 0 2226 2217 buf_x4
xspare_buffer_77 1 0 2226 2218 buf_x4
xspare_buffer_76 1 0 2226 2219 buf_x4
xspare_buffer_74 1 0 2226 2220 buf_x4
xspare_buffer_73 1 0 2226 2221 buf_x4
xspare_buffer_72 1 0 2226 2222 buf_x4
xspare_buffer_70 1 0 2226 2223 buf_x4
xsubckt_2410_nand2_x0 1 0 5940 6008 223 nand2_x0
xsubckt_1181_oa22_x2 0 7183 1 7184 7188 7793 oa22_x2
xsubckt_495_a3_x2 1 7841 0 7868 7913 52 a3_x2
xsubckt_403_nand3_x0 1 0 7942 53 92 504 nand3_x0
xsubckt_934_nand2_x0 1 0 7417 1995 637 nand2_x0
xsubckt_9435_sff1_x4 1 2138 0 9008 907 sff1_x4
xsubckt_8178_sff1_x4 1 2245 0 10179 1726 sff1_x4
xsubckt_8090_sff1_x4 1 2214 0 10267 1173 sff1_x4
xsubckt_7527_mx3_x2 1 0 9286 8477 6290 1381 6226 6230 mx3_x2
xsubckt_5134_oa22_x2 0 3753 1 3765 3763 3764 oa22_x2
xsubckt_3828_mx2_x2 0 4547 1 789 4548 4549 mx2_x2
xsubckt_3826_mx2_x2 0 4549 1 806 1713 1681 mx2_x2
xsubckt_3824_mx2_x2 0 4551 1 8029 4552 4553 mx2_x2
xsubckt_3780_mx2_x2 0 4594 1 8029 4595 4596 mx2_x2
xsubckt_3556_nand3_x0 1 0 4814 4815 4818 5950 nand3_x0
xsubckt_3380_nand2_x0 1 0 4987 6011 8098 nand2_x0
xsubckt_3044_mx2_x2 0 5318 1 8028 5319 5320 mx2_x2
xsubckt_3042_mx2_x2 0 5320 1 805 1887 1535 mx2_x2
xsubckt_3040_mx2_x2 0 5322 1 787 5323 5324 mx2_x2
xsubckt_1007_nand2_x0 1 0 7348 234 1897 nand2_x0
xfeed_449 1 0 decap_w0
xfeed_448 1 0 tie
xfeed_447 1 0 decap_w0
xfeed_446 1 0 decap_w0
xfeed_445 1 0 tie
xfeed_444 1 0 tie
xfeed_443 1 0 decap_w0
xfeed_442 1 0 decap_w0
xfeed_441 1 0 decap_w0
xfeed_440 1 0 decap_w0
xspare_feed_399 1 0 tie
xspare_feed_398 1 0 tie
xspare_feed_397 1 0 decap_w0
xspare_feed_396 1 0 tie
xspare_feed_395 1 0 tie
xspare_feed_394 1 0 decap_w0
xspare_feed_393 1 0 tie
xspare_feed_392 1 0 tie
xspare_feed_391 1 0 decap_w0
xspare_feed_390 1 0 tie
xsubckt_2120_mx2_x2 0 6327 1 830 6328 6331 mx2_x2
xsubckt_1573_nxr2_x1 6796 1 0 6799 247 nxr2_x1
xsubckt_240_inv_x0 1 0 2018 8136 inv_x0
xsubckt_563_a2_x2 0 7774 1 7775 1895 a2_x2
xsubckt_583_a2_x2 0 7755 1 7756 1895 a2_x2
xsubckt_3046_mx2_x2 0 5316 1 804 1727 1695 mx2_x2
xsubckt_3048_mx2_x2 0 5314 1 788 5315 5316 mx2_x2
xsubckt_3376_nand3_x0 1 0 4991 4992 4995 5949 nand3_x0
xsubckt_3782_mx2_x2 0 4592 1 804 1234 1202 mx2_x2
xsubckt_3784_mx2_x2 0 4590 1 8030 4591 4592 mx2_x2
xsubckt_3857_oa22_x2 0 4518 1 4519 4558 5957 oa22_x2
xsubckt_4879_nand2_x0 1 0 3963 3965 8353 nand2_x0
xsubckt_5526_nxr2_x1 3411 1 0 3414 8076 nxr2_x1
xsubckt_6793_nor3_x0 1 0 8862 1899 1894 1906 nor3_x0
xsubckt_6806_nand2_x0 1 0 8852 8853 5997 nand2_x0
xsubckt_7245_nand3_x0 1 0 8583 8584 8604 8609 nand3_x0
xsubckt_7350_mx2_x2 0 9485 1 8500 6278 1602 mx2_x2
xsubckt_7529_mx3_x2 1 0 9284 8477 6287 1409 6206 6209 mx3_x2
xsubckt_7741_mx2_x2 0 9085 1 8444 6143 986 mx2_x2
xsubckt_7743_mx2_x2 0 9083 1 8444 6125 984 mx2_x2
xsubckt_8012_sff1_x4 1 2193 0 10345 1126 sff1_x4
xsubckt_8535_sff1_x4 1 2176 0 9822 145 sff1_x4
xsubckt_8970_sff1_x4 1 2112 0 9455 1578 sff1_x4
xcmpt_latched_rd_bit2_hfns_2 1 0 554 549 buf_x4
xcmpt_latched_rd_bit2_hfns_1 1 0 549 550 buf_x4
xcmpt_latched_rd_bit2_hfns_0 1 0 549 551 buf_x4
xspare_buffer_89 1 0 2213 2208 buf_x4
xspare_buffer_88 1 0 2213 2209 buf_x4
xspare_buffer_86 1 0 2213 2210 buf_x4
xspare_buffer_85 1 0 2213 2211 buf_x4
xspare_buffer_84 1 0 2213 2212 buf_x4
xspare_buffer_82 1 0 2226 2214 buf_x4
xspare_buffer_81 1 0 2226 2215 buf_x4
xspare_buffer_80 1 0 2226 2216 buf_x4
xsubckt_2228_a4_x2 0 6174 1 6203 89 88 87 a4_x2
xsubckt_2208_a4_x2 0 6203 1 6232 62 91 90 a4_x2
xsubckt_2126_mx2_x2 0 6321 1 835 6322 6323 mx2_x2
xsubckt_2124_mx2_x2 0 6323 1 838 1161 1065 mx2_x2
xsubckt_2122_mx2_x2 0 6325 1 838 1033 1001 mx2_x2
xsubckt_1965_nand2_x0 1 0 6452 7809 193 nand2_x0
xsubckt_1280_a4_x2 0 7085 1 7086 7090 7095 7099 a4_x2
xsubckt_1260_a4_x2 0 7105 1 7106 7110 7115 7119 a4_x2
xsubckt_463_o3_x2 0 320 1 644 662 652 o3_x2
xsubckt_423_o3_x2 0 7921 1 504 505 503 o3_x2
xsubckt_246_inv_x0 1 0 223 8130 inv_x0
xsubckt_244_inv_x0 1 0 2007 8132 inv_x0
xsubckt_242_inv_x0 1 0 226 8134 inv_x0
xsubckt_664_nand2_x0 1 0 7677 7991 1996 nand2_x0
xsubckt_2513_mx2_x2 0 5839 1 6012 226 217 mx2_x2
xsubckt_2860_mx2_x2 0 5499 1 810 964 932 mx2_x2
xsubckt_3399_mx2_x2 0 4969 1 810 1049 1017 mx2_x2
xsubckt_3729_nand2_x0 1 0 4644 4645 8020 nand2_x0
xsubckt_3786_mx2_x2 0 4588 1 810 1362 1330 mx2_x2
xsubckt_3788_mx2_x2 0 4586 1 8030 4587 4588 mx2_x2
xsubckt_5023_a3_x2 1 3856 0 50 144 8398 a3_x2
xsubckt_5042_oa22_x2 0 3838 1 3855 3946 7881 oa22_x2
xsubckt_5241_ao22_x2 0 3653 1 3654 3660 703 ao22_x2
xsubckt_7352_mx2_x2 0 9483 1 8500 6265 1580 mx2_x2
xsubckt_7354_mx2_x2 0 9481 1 8500 6251 1576 mx2_x2
xsubckt_7745_mx2_x2 0 9081 1 8444 6107 981 mx2_x2
xsubckt_7747_mx2_x2 0 9079 1 8444 6088 979 mx2_x2
xsubckt_8008_sff1_x4 1 2103 0 10349 1132 sff1_x4
xsubckt_8086_sff1_x4 1 2242 0 10271 1178 sff1_x4
xsubckt_8443_sff1_x4 1 2047 0 9914 1963 sff1_x4
xsubckt_8966_sff1_x4 1 2132 0 9459 1583 sff1_x4
xsubckt_9343_sff1_x4 1 2126 0 9100 983 sff1_x4
xfeed_459 1 0 tie
xfeed_458 1 0 decap_w0
xfeed_457 1 0 decap_w0
xfeed_456 1 0 tie
xfeed_455 1 0 decap_w0
xfeed_454 1 0 decap_w0
xfeed_453 1 0 decap_w0
xfeed_452 1 0 decap_w0
xfeed_451 1 0 decap_w0
xfeed_450 1 0 tie
xsubckt_2128_mx2_x2 0 6319 1 827 6320 6327 mx2_x2
xsubckt_2082_mx2_x2 0 6364 1 864 972 940 mx2_x2
xsubckt_2080_mx2_x2 0 6366 1 835 6367 6368 mx2_x2
xsubckt_1875_nand2_x0 1 0 6514 6515 225 nand2_x0
xsubckt_1481_nxr2_x1 6882 1 0 6885 8062 nxr2_x1
xsubckt_531_o2_x2 0 7807 1 330 328 o2_x2
xsubckt_248_inv_x0 1 0 417 8128 inv_x0
xsubckt_2471_mx2_x2 0 5881 1 807 1783 1751 mx2_x2
xsubckt_2473_mx2_x2 0 5879 1 8023 5880 5883 mx2_x2
xsubckt_2519_mx2_x2 0 10413 1 5994 5834 237 mx2_x2
xsubckt_2757_nand2_x0 1 0 5600 5601 781 nand2_x0
xsubckt_2862_mx2_x2 0 5497 1 790 5498 5499 mx2_x2
xsubckt_2864_mx2_x2 0 5495 1 807 1860 1508 mx2_x2
xsubckt_2866_mx2_x2 0 5493 1 8032 5494 5495 mx2_x2
xsubckt_3196_nand3_x0 1 0 5168 5169 5172 5950 nand3_x0
xsubckt_3549_nand2_x0 1 0 4821 4822 8025 nand2_x0
xsubckt_4154_a3_x2 1 4227 0 551 8005 553 a3_x2
xsubckt_4575_a4_x2 0 4154 1 4196 6306 6312 551 a4_x2
xsubckt_5473_oa22_x2 0 3447 1 2039 3453 2038 oa22_x2
xsubckt_5996_oa22_x2 0 3015 1 3191 3018 3016 oa22_x2
xsubckt_6842_a4_x2 0 8825 1 8827 8244 702 577 a4_x2
xsubckt_7749_mx2_x2 0 9077 1 8444 6071 977 mx2_x2
xsubckt_8800_sff1_x4 1 2079 0 9622 734 sff1_x4
xsubckt_9339_sff1_x4 1 2053 0 10459 330 sff1_x4
xspare_buffer_98 1 0 2213 2201 buf_x4
xspare_buffer_97 1 0 2213 2202 buf_x4
xspare_buffer_96 1 0 2213 2203 buf_x4
xspare_buffer_94 1 0 2213 2204 buf_x4
xspare_buffer_93 1 0 2213 2205 buf_x4
xspare_buffer_92 1 0 2213 2206 buf_x4
xspare_buffer_90 1 0 2213 2207 buf_x4
xsubckt_2404_a2_x2 0 5946 1 5950 5960 a2_x2
xsubckt_2342_oa22_x2 0 6028 1 6029 6030 6031 oa22_x2
xsubckt_2130_a2_x2 0 6317 1 6318 6427 a2_x2
xsubckt_2088_mx2_x2 0 6358 1 830 6359 6362 mx2_x2
xsubckt_2086_mx2_x2 0 6360 1 841 1868 1516 mx2_x2
xsubckt_2084_mx2_x2 0 6362 1 836 6363 6364 mx2_x2
xsubckt_1607_nand2_x0 1 0 6764 6943 7089 nand2_x0
xsubckt_484_nand2_x0 1 0 7850 8420 1903 nand2_x0
xsubckt_437_ao22_x2 0 7901 1 1912 7905 46 ao22_x2
xsubckt_591_o2_x2 0 7747 1 7748 7749 o2_x2
xsubckt_673_oa22_x2 0 7669 1 7692 7690 7691 oa22_x2
xsubckt_2475_mx2_x2 0 5877 1 810 1879 1527 mx2_x2
xsubckt_2477_mx2_x2 0 5875 1 813 1047 1015 mx2_x2
xsubckt_2479_mx2_x2 0 5873 1 8032 5874 5875 mx2_x2
xsubckt_2667_nand2_x0 1 0 5688 6007 8113 nand2_x0
xsubckt_2868_mx2_x2 0 5491 1 813 1700 1668 mx2_x2
xsubckt_3980_nand2_x0 1 0 4397 6011 8080 nand2_x0
xsubckt_4790_a4_x2 0 4029 1 1951 1950 1949 1948 a4_x2
xsubckt_5151_a2_x2 0 3737 1 3921 712 a2_x2
xsubckt_6041_mx2_x2 0 2972 1 8215 2973 2976 mx2_x2
xsubckt_6043_mx2_x2 0 2970 1 842 1184 1088 mx2_x2
xsubckt_6045_mx2_x2 0 2968 1 842 992 960 mx2_x2
xsubckt_6432_mx2_x2 0 2592 1 842 1844 1812 mx2_x2
xsubckt_6434_mx2_x2 0 2590 1 842 1716 1684 mx2_x2
xsubckt_6436_mx2_x2 0 2588 1 836 2589 2590 mx2_x2
xsubckt_7238_nand2_x0 1 0 8588 7976 383 nand2_x0
xsubckt_7328_nand2_x0 1 0 8517 727 653 nand2_x0
xsubckt_8351_sff1_x4 1 2203 0 10006 1328 sff1_x4
xsubckt_8439_sff1_x4 1 2047 0 9918 1968 sff1_x4
xsubckt_8874_sff1_x4 1 2070 0 9551 332 sff1_x4
xsubckt_9251_sff1_x4 1 2194 0 9189 1412 sff1_x4
xfeed_469 1 0 decap_w0
xfeed_468 1 0 tie
xfeed_467 1 0 tie
xfeed_466 1 0 decap_w0
xfeed_465 1 0 decap_w0
xfeed_464 1 0 tie
xfeed_463 1 0 decap_w0
xfeed_462 1 0 tie
xfeed_461 1 0 tie
xfeed_460 1 0 decap_w0
xcmpt_abc_30082_new_n5453_hfns_2 1 0 6279 6276 buf_x4
xcmpt_abc_30082_new_n5453_hfns_1 1 0 6276 6277 buf_x4
xcmpt_abc_30082_new_n5453_hfns_0 1 0 6276 6278 buf_x4
xsubckt_1946_mx2_x2 0 457 1 7807 205 445 mx2_x2
xsubckt_1944_mx2_x2 0 459 1 7807 207 467 mx2_x2
xsubckt_1695_nand2_x0 1 0 6682 6947 7116 nand2_x0
xsubckt_1517_nand2_x0 1 0 6848 7060 7972 nand2_x0
xsubckt_1427_nand2_x0 1 0 6933 6948 7034 nand2_x0
xsubckt_1261_a2_x2 0 7104 1 7105 7124 a2_x2
xsubckt_2740_nand2_x0 1 0 5617 6012 8123 nand2_x0
xsubckt_3369_nand2_x0 1 0 4998 4999 8022 nand2_x0
xsubckt_3802_a2_x2 0 4572 1 4573 4575 a2_x2
xsubckt_3976_nand3_x0 1 0 4401 4402 4405 5949 nand3_x0
xsubckt_5397_a3_x2 1 3509 0 44 134 8397 a3_x2
xsubckt_5640_a2_x2 0 9746 1 3333 44 a2_x2
xsubckt_5901_mx2_x2 0 3108 1 843 966 934 mx2_x2
xsubckt_5903_mx2_x2 0 3106 1 834 3107 3108 mx2_x2
xsubckt_6047_mx2_x2 0 2966 1 834 2967 2968 mx2_x2
xsubckt_6049_mx2_x2 0 2964 1 828 2965 2972 mx2_x2
xsubckt_6438_mx2_x2 0 2586 1 841 1876 1524 mx2_x2
xsubckt_6781_mx2_x2 0 8873 1 841 1418 1386 mx2_x2
xsubckt_6783_mx2_x2 0 8871 1 8212 8872 8875 mx2_x2
xsubckt_6785_mx2_x2 0 8869 1 8207 8870 8885 mx2_x2
xsubckt_6803_a2_x2 0 9676 1 8855 44 a2_x2
xsubckt_7134_nand4_x0 1 0 8644 7997 8300 44 503 nand4_x0
xsubckt_7302_ao22_x2 0 8538 1 8606 8686 377 ao22_x2
xsubckt_7517_a2_x2 0 8477 1 4182 4195 a2_x2
xsubckt_7974_sff1_x4 1 2126 0 10383 1794 sff1_x4
xsubckt_9247_sff1_x4 1 2251 0 9193 1416 sff1_x4
xsubckt_1948_mx2_x2 0 454 1 7807 203 441 mx2_x2
xsubckt_1575_a2_x2 0 6794 1 6796 6803 a2_x2
xsubckt_1337_nand2_x0 1 0 7028 7029 7030 nand2_x0
xsubckt_669_oa22_x2 0 7672 1 7673 7677 7793 oa22_x2
xsubckt_3189_nand2_x0 1 0 5175 5176 8021 nand2_x0
xsubckt_3796_nand3_x0 1 0 4578 4579 4582 5950 nand3_x0
xsubckt_3862_a2_x2 0 4513 1 4514 4516 a2_x2
xsubckt_4046_oa22_x2 0 4333 1 4389 4387 4388 oa22_x2
xsubckt_5250_nxr2_x1 3645 1 0 3901 713 nxr2_x1
xsubckt_5861_mx2_x2 0 3147 1 8211 3148 3151 mx2_x2
xsubckt_5905_mx2_x2 0 3104 1 827 3105 3112 mx2_x2
xsubckt_5907_mx2_x2 0 3102 1 854 1286 1254 mx2_x2
xsubckt_5909_mx2_x2 0 3100 1 844 1222 1190 mx2_x2
xsubckt_6396_mx2_x2 0 2627 1 844 1845 1813 mx2_x2
xsubckt_6398_mx2_x2 0 2625 1 844 1717 1685 mx2_x2
xsubckt_6863_a2_x2 0 9665 1 8809 43 a2_x2
xsubckt_8347_sff1_x4 1 2238 0 10010 1332 sff1_x4
xsubckt_8782_sff1_x4 1 2073 0 9640 617 sff1_x4
xfeed_479 1 0 tie
xfeed_478 1 0 decap_w0
xfeed_477 1 0 tie
xfeed_476 1 0 decap_w0
xfeed_475 1 0 decap_w0
xfeed_474 1 0 tie
xfeed_473 1 0 decap_w0
xfeed_472 1 0 decap_w0
xfeed_471 1 0 decap_w0
xfeed_470 1 0 decap_w0
xspare_feed_509 1 0 tie
xspare_feed_508 1 0 decap_w0
xspare_feed_507 1 0 tie
xspare_feed_506 1 0 tie
xspare_feed_505 1 0 decap_w0
xspare_feed_504 1 0 tie
xspare_feed_503 1 0 tie
xspare_feed_502 1 0 decap_w0
xspare_feed_501 1 0 tie
xspare_feed_500 1 0 tie
xsubckt_9155_sff1_x4 1 2194 0 9285 1380 sff1_x4
xsubckt_8704_sff1_x4 1 2092 0 9686 200 sff1_x4
xsubckt_7018_nor2_x0 1 0 9632 8690 8305 nor2_x0
xsubckt_5867_mx2_x2 0 3141 1 833 3142 3143 mx2_x2
xsubckt_5865_mx2_x2 0 3143 1 865 967 935 mx2_x2
xsubckt_5863_mx2_x2 0 3145 1 865 1159 1063 mx2_x2
xsubckt_5377_oa22_x2 0 3527 1 3877 3880 8268 oa22_x2
xsubckt_4201_mx2_x2 0 10346 1 4215 6245 1127 mx2_x2
xsubckt_3868_ao22_x2 0 4508 1 4568 4566 4563 ao22_x2
xsubckt_2560_nand2_x0 1 0 5793 5794 5800 nand2_x0
xsubckt_577_oa22_x2 0 7761 1 7806 7939 8236 oa22_x2
xsubckt_422_nor2_x0 1 0 7922 504 505 nor2_x0
xsubckt_1500_nand2_x0 1 0 6864 6948 7053 nand2_x0
xsubckt_8778_sff1_x4 1 2070 0 9644 625 sff1_x4
xsubckt_8690_sff1_x4 1 2166 0 9700 214 sff1_x4
xsubckt_8255_sff1_x4 1 2129 0 10102 1680 sff1_x4
xsubckt_7206_ao22_x2 0 8611 1 1899 8614 8612 ao22_x2
xsubckt_7007_oa22_x2 0 9634 1 8703 8699 8702 oa22_x2
xsubckt_5869_mx2_x2 0 3139 1 826 3140 3147 mx2_x2
xsubckt_4869_nxr2_x1 3970 1 0 3971 8351 nxr2_x1
xsubckt_4207_mx2_x2 0 10340 1 4215 6188 1151 mx2_x2
xsubckt_3969_nand2_x0 1 0 4408 4409 8020 nand2_x0
xsubckt_3810_o2_x2 0 4565 1 231 750 o2_x2
xsubckt_2968_ao22_x2 0 5393 1 5451 5446 5448 ao22_x2
xsubckt_1094_o2_x2 0 7266 1 748 73 o2_x2
xsubckt_1067_nand2_x0 1 0 7291 1988 637 nand2_x0
xsubckt_411_oa22_x2 0 7934 1 54 7937 7943 oa22_x2
xsubckt_496_nor2_x0 1 0 7840 567 573 nor2_x0
xsubckt_1543_o2_x2 0 6824 1 6825 6830 o2_x2
xfeed_489 1 0 decap_w0
xfeed_488 1 0 tie
xfeed_487 1 0 decap_w0
xfeed_486 1 0 decap_w0
xfeed_485 1 0 decap_w0
xfeed_484 1 0 decap_w0
xfeed_483 1 0 decap_w0
xfeed_482 1 0 tie
xfeed_481 1 0 decap_w0
xfeed_480 1 0 decap_w0
xspare_feed_519 1 0 tie
xspare_feed_518 1 0 tie
xspare_feed_517 1 0 decap_w0
xspare_feed_516 1 0 tie
xspare_feed_515 1 0 tie
xspare_feed_514 1 0 decap_w0
xspare_feed_513 1 0 tie
xspare_feed_512 1 0 tie
xspare_feed_511 1 0 decap_w0
xspare_feed_510 1 0 tie
xsubckt_9063_sff1_x4 1 2139 0 9367 1363 sff1_x4
xsubckt_8686_sff1_x4 1 2166 0 9704 440 sff1_x4
xsubckt_8612_sff1_x4 1 2086 0 9745 224 sff1_x4
xsubckt_5453_nand3_x0 1 0 3461 3465 1996 2007 nand3_x0
xsubckt_4209_mx2_x2 0 10338 1 4214 6169 1149 mx2_x2
xsubckt_4163_mx2_x2 0 10378 1 4223 6245 1767 mx2_x2
xsubckt_4161_mx2_x2 0 10380 1 4223 6258 1769 mx2_x2
xsubckt_2466_nand3_x0 1 0 5886 569 8289 81 nand3_x0
xsubckt_1022_ao22_x2 0 7334 1 7336 7339 1903 ao22_x2
xsubckt_9420_sff1_x4 1 2206 0 9023 924 sff1_x4
xsubckt_9059_sff1_x4 1 2223 0 9371 1368 sff1_x4
xsubckt_8608_sff1_x4 1 2044 0 9749 1984 sff1_x4
xsubckt_8520_sff1_x4 1 2159 0 9837 130 sff1_x4
xsubckt_8163_sff1_x4 1 2119 0 10194 1451 sff1_x4
xsubckt_6538_oa22_x2 0 2489 1 54 1905 199 oa22_x2
xsubckt_5406_ao22_x2 0 3500 1 3527 3503 3501 ao22_x2
xsubckt_4558_mx2_x2 0 10017 1 4157 6161 1340 mx2_x2
xsubckt_4556_mx2_x2 0 10019 1 4157 6179 1342 mx2_x2
xsubckt_4169_mx2_x2 0 10372 1 4224 6189 1791 mx2_x2
xsubckt_3789_nand2_x0 1 0 4585 4586 8025 nand2_x0
xsubckt_1140_nand2_x0 1 0 7222 227 1898 nand2_x0
xsubckt_0_inv_x0 1 0 1902 8422 inv_x0
xsubckt_2_inv_x0 1 0 577 8420 inv_x0
xsubckt_4_inv_x0 1 0 664 8418 inv_x0
xsubckt_1289_nxr2_x1 7076 1 0 214 247 nxr2_x1
xsubckt_1937_nand2_x0 1 0 462 6464 6465 nand2_x0
xsubckt_2286_nand3_x0 1 0 6100 6101 6103 6294 nand3_x0
xfeed_499 1 0 decap_w0
xfeed_498 1 0 tie
xfeed_497 1 0 decap_w0
xfeed_496 1 0 tie
xfeed_495 1 0 tie
xfeed_494 1 0 decap_w0
xfeed_493 1 0 decap_w0
xfeed_492 1 0 decap_w0
xfeed_491 1 0 tie
xfeed_490 1 0 tie
xspare_feed_529 1 0 decap_w0
xspare_feed_528 1 0 tie
xspare_feed_527 1 0 tie
xspare_feed_526 1 0 decap_w0
xspare_feed_525 1 0 tie
xspare_feed_524 1 0 tie
xspare_feed_523 1 0 decap_w0
xspare_feed_522 1 0 tie
xspare_feed_521 1 0 tie
xspare_feed_520 1 0 decap_w0
xsubckt_9494_sff1_x4 1 2110 0 8949 1841 sff1_x4
xsubckt_9416_sff1_x4 1 2189 0 9027 928 sff1_x4
xsubckt_8594_sff1_x4 1 2047 0 9763 2000 sff1_x4
xsubckt_8159_sff1_x4 1 2129 0 10198 1456 sff1_x4
xsubckt_8071_sff1_x4 1 2126 0 10286 1175 sff1_x4
xsubckt_7200_mx2_x2 0 8616 1 562 3227 712 mx2_x2
xsubckt_7188_ao22_x2 0 8623 1 1902 1912 47 ao22_x2
xsubckt_5183_nand3_x0 1 0 3707 3708 3709 652 nand3_x0
xsubckt_3243_mx2_x2 0 5122 1 814 1148 1116 mx2_x2
xsubckt_6_inv_x0 1 0 659 8413 inv_x0
xsubckt_8_inv_x0 1 0 557 8411 inv_x0
xsubckt_393_a3_x2 1 7952 0 7953 7956 7959 a3_x2
xsubckt_461_a2_x2 0 7871 1 7872 7873 a2_x2
xsubckt_1611_oa22_x2 0 6761 1 6775 6769 6770 oa22_x2
xsubckt_1646_nxr2_x1 6728 1 0 6731 242 nxr2_x1
xsubckt_1757_nand2_x0 1 0 6624 6947 7135 nand2_x0
xsubckt_8951_sff1_x4 1 2247 0 9474 1599 sff1_x4
xsubckt_8516_sff1_x4 1 2153 0 9841 68 sff1_x4
xsubckt_7298_nand2_x0 1 0 8541 736 652 nand2_x0
xsubckt_6800_mx3_x2 1 0 8857 1902 577 7853 6952 649 mx3_x2
xsubckt_5314_ao22_x2 0 3586 1 3597 3885 8294 ao22_x2
xsubckt_4297_nand4_x0 1 0 4200 4220 6306 6312 551 nand4_x0
xsubckt_3638_mx2_x2 0 4734 1 814 980 948 mx2_x2
xsubckt_3592_mx2_x2 0 4779 1 8036 4780 4781 mx2_x2
xsubckt_3590_mx2_x2 0 4781 1 814 917 885 mx2_x2
xsubckt_3247_mx2_x2 0 5118 1 814 1308 1276 mx2_x2
xsubckt_2459_nand2_x0 1 0 5892 6012 8285 nand2_x0
xsubckt_715_a2_x2 0 7628 1 7629 7630 a2_x2
xsubckt_481_a2_x2 0 7853 1 701 653 a2_x2
xsubckt_1197_nxr2_x1 7168 1 0 195 227 nxr2_x1
xsubckt_1667_nand2_x0 1 0 6708 7112 7972 nand2_x0
xsubckt_1685_oa22_x2 0 6692 1 6712 6702 6693 oa22_x2
xspare_feed_539 1 0 tie
xspare_feed_538 1 0 decap_w0
xspare_feed_537 1 0 tie
xspare_feed_536 1 0 tie
xspare_feed_535 1 0 decap_w0
xspare_feed_534 1 0 tie
xspare_feed_533 1 0 tie
xspare_feed_532 1 0 decap_w0
xspare_feed_531 1 0 tie
xspare_feed_530 1 0 tie
xsubckt_9324_sff1_x4 1 2232 0 9116 1017 sff1_x4
xsubckt_8067_sff1_x4 1 2119 0 10290 1739 sff1_x4
xsubckt_7555_mx2_x2 0 9260 1 8469 6273 1207 mx2_x2
xsubckt_7553_mx2_x2 0 9262 1 8469 6283 1219 mx2_x2
xsubckt_7164_mx2_x2 0 9531 1 8643 446 341 mx2_x2
xsubckt_7162_mx2_x2 0 9533 1 8643 448 343 mx2_x2
xsubckt_7160_mx2_x2 0 9535 1 8642 450 345 mx2_x2
xsubckt_3598_mx2_x2 0 4773 1 815 1653 1621 mx2_x2
xsubckt_3596_mx2_x2 0 4775 1 8036 4776 4777 mx2_x2
xsubckt_3594_mx2_x2 0 4777 1 816 1493 1461 mx2_x2
xsubckt_3453_xr2_x1 4916 0 1 238 757 xr2_x1
xsubckt_3315_oa22_x2 0 5051 1 5052 5053 8016 oa22_x2
xsubckt_2712_mx2_x2 0 5644 1 816 1287 1255 mx2_x2
xsubckt_361_o3_x2 0 7987 1 627 626 614 o3_x2
xsubckt_1309_nand2_x0 1 0 7056 7057 7061 nand2_x0
xsubckt_1487_nand2_x0 1 0 6876 6947 7049 nand2_x0
xsubckt_1577_nand2_x0 1 0 6792 6947 7077 nand2_x0
xsubckt_2257_ao22_x2 0 6137 1 83 6147 6295 ao22_x2
xsubckt_2323_mx2_x2 0 6051 1 545 103 2267 mx2_x2
xsubckt_9398_sff1_x4 1 2116 0 9045 945 sff1_x4
xsubckt_8947_sff1_x4 1 2232 0 9478 1573 sff1_x4
xsubckt_8424_sff1_x4 1 2057 0 9933 1965 sff1_x4
xsubckt_7559_mx2_x2 0 9256 1 8470 6245 1191 mx2_x2
xsubckt_7557_mx2_x2 0 9258 1 8470 6258 1193 mx2_x2
xsubckt_7166_mx2_x2 0 9529 1 8643 443 338 mx2_x2
xsubckt_6631_mx2_x2 0 2398 1 8222 2399 2400 mx2_x2
xsubckt_5215_a3_x2 1 3678 0 55 148 8398 a3_x2
xsubckt_4727_a4_x2 0 4076 1 4078 4091 4143 1964 a4_x2
xsubckt_3389_oa22_x2 0 4979 1 5039 5037 5036 oa22_x2
xsubckt_1070_oa22_x2 0 7288 1 7289 7293 7793 oa22_x2
xsubckt_1031_a3_x2 1 7325 0 7326 7327 7328 a3_x2
xsubckt_1650_nand2_x0 1 0 6724 6948 7100 nand2_x0
xsubckt_1740_nand2_x0 1 0 6640 6948 7130 nand2_x0
xsubckt_2234_a3_x2 1 6166 0 6167 541 8409 a3_x2
xsubckt_2281_mx2_x2 0 6105 1 547 109 2273 mx2_x2
xspare_feed_549 1 0 tie
xspare_feed_548 1 0 tie
xspare_feed_547 1 0 decap_w0
xspare_feed_546 1 0 tie
xspare_feed_545 1 0 tie
xspare_feed_544 1 0 decap_w0
xspare_feed_543 1 0 tie
xspare_feed_542 1 0 tie
xspare_feed_541 1 0 decap_w0
xspare_feed_540 1 0 tie
xsubckt_9232_sff1_x4 1 2212 0 9208 1076 sff1_x4
xsubckt_8498_sff1_x4 1 2159 0 9859 88 sff1_x4
xsubckt_6819_a4_x2 0 8845 1 9420 8847 9422 9421 a4_x2
xsubckt_6796_nor2_x0 1 0 9678 8860 8305 nor2_x0
xsubckt_6637_mx2_x2 0 2392 1 850 1423 1391 mx2_x2
xsubckt_6635_mx2_x2 0 2394 1 8223 2395 2396 mx2_x2
xsubckt_6633_mx2_x2 0 2396 1 850 1647 1615 mx2_x2
xsubckt_6244_mx2_x2 0 2774 1 828 2775 2782 mx2_x2
xsubckt_6242_mx2_x2 0 2776 1 8223 2777 2778 mx2_x2
xsubckt_6240_mx2_x2 0 2778 1 850 1499 1467 mx2_x2
xsubckt_6030_ao22_x2 0 2982 1 574 569 766 ao22_x2
xsubckt_5724_a3_x2 1 3278 0 3279 6001 50 a3_x2
xsubckt_5489_nxr2_x1 3436 1 0 3439 8099 nxr2_x1
xsubckt_5454_oa22_x2 0 3460 1 2007 3465 1996 oa22_x2
xsubckt_5086_nand2_x0 1 0 9835 3798 3809 nand2_x0
xsubckt_3211_a2_x2 0 5154 1 242 761 a2_x2
xsubckt_1129_nand2_x0 1 0 7232 7233 7241 nand2_x0
xsubckt_743_o2_x2 0 7599 1 737 62 o2_x2
xsubckt_8855_sff1_x4 1 2110 0 9570 1518 sff1_x4
xsubckt_8332_sff1_x4 1 2198 0 10025 1318 sff1_x4
xsubckt_7955_sff1_x4 1 2163 0 10402 244 sff1_x4
xsubckt_6639_mx2_x2 0 2390 1 8212 2391 2394 mx2_x2
xsubckt_6593_mx2_x2 0 2435 1 849 1232 1200 mx2_x2
xsubckt_6591_mx2_x2 0 2437 1 848 1296 1264 mx2_x2
xsubckt_5744_a3_x2 1 3260 0 8287 52 8421 a3_x2
xsubckt_5711_mx2_x2 0 9724 1 3282 486 523 mx2_x2
xsubckt_5549_a3_x2 1 9774 0 3396 3397 52 a3_x2
xsubckt_5343_a2_x2 0 3559 1 3569 3580 a2_x2
xsubckt_4835_a3_x2 1 3994 0 3998 4002 1936 a3_x2
xsubckt_876_nand2_x0 1 0 7472 630 1935 nand2_x0
xsubckt_1470_nand2_x0 1 0 6892 6947 7040 nand2_x0
xsubckt_1580_a3_x2 1 6789 0 6790 6791 6792 a3_x2
xsubckt_2289_mx2_x2 0 6095 1 546 108 2272 mx2_x2
xfeed_609 1 0 tie
xfeed_608 1 0 tie
xfeed_607 1 0 decap_w0
xfeed_606 1 0 tie
xfeed_605 1 0 tie
xfeed_604 1 0 decap_w0
xfeed_603 1 0 decap_w0
xfeed_602 1 0 tie
xfeed_601 1 0 decap_w0
xfeed_600 1 0 tie
xspare_feed_559 1 0 decap_w0
xspare_feed_558 1 0 tie
xspare_feed_557 1 0 tie
xspare_feed_556 1 0 decap_w0
xspare_feed_555 1 0 tie
xspare_feed_554 1 0 tie
xspare_feed_553 1 0 decap_w0
xspare_feed_552 1 0 tie
xspare_feed_551 1 0 tie
xspare_feed_550 1 0 decap_w0
xsubckt_9228_sff1_x4 1 2232 0 9212 1081 sff1_x4
xsubckt_9140_sff1_x4 1 2204 0 9300 1104 sff1_x4
xsubckt_8763_sff1_x4 1 2070 0 9659 647 sff1_x4
xsubckt_8328_sff1_x4 1 2106 0 10029 1324 sff1_x4
xsubckt_7070_oa22_x2 0 8671 1 8763 8679 8749 oa22_x2
xsubckt_6906_ao22_x2 0 8780 1 707 8278 621 ao22_x2
xsubckt_6599_mx2_x2 0 2429 1 8226 2430 2431 mx2_x2
xsubckt_6597_mx2_x2 0 2431 1 853 1648 1616 mx2_x2
xsubckt_6595_mx2_x2 0 2433 1 8226 2434 2435 mx2_x2
xsubckt_5717_mx2_x2 0 9718 1 3283 480 517 mx2_x2
xsubckt_5715_mx2_x2 0 9720 1 3283 482 519 mx2_x2
xsubckt_5713_mx2_x2 0 9722 1 3283 484 521 mx2_x2
xsubckt_4985_oa22_x2 0 9849 1 7884 3885 3887 oa22_x2
xsubckt_4895_a3_x2 1 3952 0 51 92 8398 a3_x2
xsubckt_4749_ao22_x2 0 9910 1 4060 4061 51 ao22_x2
xsubckt_4728_a2_x2 0 4075 1 4077 8320 a2_x2
xsubckt_2879_nand2_x0 1 0 5480 5481 783 nand2_x0
xsubckt_696_nand2_x0 1 0 159 7647 7664 nand2_x0
xsubckt_1290_nand2_x0 1 0 7075 7076 7080 nand2_x0
xsubckt_1909_nand2_x0 1 0 6486 467 330 nand2_x0
xsubckt_2231_oa22_x2 0 6171 1 6172 6173 6175 oa22_x2
xsubckt_2348_nand3_x0 1 0 6020 6021 6022 6288 nand3_x0
xsubckt_9136_sff1_x4 1 2229 0 9304 1108 sff1_x4
xsubckt_8240_sff1_x4 1 2189 0 10117 1696 sff1_x4
xsubckt_6892_ao22_x2 0 8790 1 707 8277 627 ao22_x2
xsubckt_5719_mx2_x2 0 9716 1 3283 477 514 mx2_x2
xsubckt_5673_mx2_x2 0 3300 1 817 1578 1546 mx2_x2
xsubckt_5671_mx2_x2 0 3302 1 788 3303 3304 mx2_x2
xsubckt_5358_oa22_x2 0 3544 1 3545 3546 3560 oa22_x2
xsubckt_5155_nand3_x0 1 0 3733 3734 3735 653 nand3_x0
xsubckt_4768_a2_x2 0 9905 1 4046 50 a2_x2
xsubckt_4400_mx2_x2 0 10161 1 4186 6017 1706 mx2_x2
xsubckt_3569_nor2_x0 1 0 4802 235 754 nor2_x0
xsubckt_10_inv_x0 1 0 545 8406 inv_x0
xsubckt_12_inv_x0 1 0 505 8404 inv_x0
xsubckt_14_inv_x0 1 0 506 8402 inv_x0
xsubckt_1226_xr2_x1 7139 0 1 201 233 xr2_x1
xsubckt_1729_nand2_x0 1 0 2307 6651 6655 nand2_x0
xsubckt_1819_nand2_x0 1 0 6566 7157 7971 nand2_x0
xsubckt_1854_oa22_x2 0 6534 1 6546 6538 6540 oa22_x2
xsubckt_1889_nxr2_x1 6501 1 0 6502 6505 nxr2_x1
xfeed_619 1 0 decap_w0
xfeed_618 1 0 decap_w0
xfeed_617 1 0 decap_w0
xfeed_616 1 0 decap_w0
xfeed_615 1 0 decap_w0
xfeed_614 1 0 decap_w0
xfeed_613 1 0 decap_w0
xfeed_612 1 0 decap_w0
xfeed_611 1 0 decap_w0
xfeed_610 1 0 tie
xspare_feed_569 1 0 tie
xspare_feed_568 1 0 decap_w0
xspare_feed_567 1 0 tie
xspare_feed_566 1 0 tie
xspare_feed_565 1 0 decap_w0
xspare_feed_564 1 0 tie
xspare_feed_563 1 0 tie
xspare_feed_562 1 0 decap_w0
xspare_feed_561 1 0 tie
xspare_feed_560 1 0 tie
xsubckt_8759_sff1_x4 1 2073 0 9663 649 sff1_x4
xsubckt_8671_sff1_x4 1 2182 0 9718 517 sff1_x4
xsubckt_8236_sff1_x4 1 2169 0 10121 1670 sff1_x4
xsubckt_6319_o2_x2 0 2701 1 2702 7931 o2_x2
xsubckt_5679_mx2_x2 0 3294 1 8020 3295 3298 mx2_x2
xsubckt_5677_mx2_x2 0 3296 1 796 1418 1386 mx2_x2
xsubckt_5675_mx2_x2 0 3298 1 788 3299 3300 mx2_x2
xsubckt_5418_nand2_x0 1 0 3489 3507 3864 nand2_x0
xsubckt_4657_ao22_x2 0 9932 1 4130 4131 42 ao22_x2
xsubckt_4406_mx2_x2 0 10159 1 4179 6278 1282 mx2_x2
xsubckt_4013_mx2_x2 0 4365 1 795 1422 1390 mx2_x2
xsubckt_16_inv_x0 1 0 1912 8400 inv_x0
xsubckt_18_inv_x0 1 0 134 8393 inv_x0
xsubckt_2146_nor2_x0 1 0 6312 556 555 nor2_x0
xsubckt_9044_sff1_x4 1 2126 0 9386 1353 sff1_x4
xsubckt_6888_ao22_x2 0 8792 1 707 8279 647 ao22_x2
xsubckt_5328_nand2_x0 1 0 9818 3573 3590 nand2_x0
xsubckt_4762_nxr2_x1 4050 1 0 4052 8328 nxr2_x1
xsubckt_4408_mx2_x2 0 10157 1 4178 6265 1260 mx2_x2
xsubckt_4362_mx2_x2 0 10197 1 4190 6054 1455 mx2_x2
xsubckt_4360_mx2_x2 0 10199 1 4190 6071 1457 mx2_x2
xsubckt_4017_mx2_x2 0 4361 1 795 1582 1550 mx2_x2
xsubckt_1286_o2_x2 0 7079 1 214 247 o2_x2
xsubckt_1719_nxr2_x1 6660 1 0 6662 204 nxr2_x1
xsubckt_1762_oa22_x2 0 6620 1 6635 6628 6629 oa22_x2
xsubckt_1797_nxr2_x1 6587 1 0 6590 231 nxr2_x1
xsubckt_1802_nand2_x0 1 0 6582 6948 7146 nand2_x0
xfeed_629 1 0 decap_w0
xfeed_628 1 0 decap_w0
xfeed_627 1 0 decap_w0
xfeed_626 1 0 tie
xfeed_625 1 0 decap_w0
xfeed_624 1 0 decap_w0
xfeed_623 1 0 decap_w0
xfeed_622 1 0 decap_w0
xfeed_621 1 0 decap_w0
xfeed_620 1 0 tie
xspare_feed_579 1 0 tie
xspare_feed_578 1 0 tie
xspare_feed_577 1 0 decap_w0
xspare_feed_576 1 0 tie
xspare_feed_575 1 0 tie
xspare_feed_574 1 0 decap_w0
xspare_feed_573 1 0 tie
xspare_feed_572 1 0 tie
xspare_feed_571 1 0 decap_w0
xspare_feed_570 1 0 tie
xsubckt_9401_sff1_x4 1 2116 0 9042 942 sff1_x4
xsubckt_8667_sff1_x4 1 2182 0 9722 521 sff1_x4
xsubckt_8144_sff1_x4 1 2195 0 10213 1472 sff1_x4
xsubckt_7343_nand2_x0 1 0 8505 711 652 nand2_x0
xsubckt_7076_nand4_x0 1 0 8667 6306 6309 556 8008 nand4_x0
xsubckt_5959_o2_x2 0 3051 1 3052 7931 o2_x2
xsubckt_5570_nxr2_x1 3381 1 0 3385 8112 nxr2_x1
xsubckt_4366_mx2_x2 0 10193 1 4191 6017 1450 mx2_x2
xsubckt_4364_mx2_x2 0 10195 1 4191 6035 1453 mx2_x2
xsubckt_4042_ao22_x2 0 4336 1 4385 4384 4337 ao22_x2
xsubckt_3989_oa22_x2 0 4389 1 4449 4447 4446 oa22_x2
xsubckt_359_nor3_x0 1 0 7992 634 638 630 nor3_x0
xsubckt_1603_nor2_x0 1 0 6768 6769 6775 nor2_x0
xsubckt_1712_nand2_x0 1 0 6666 7121 7972 nand2_x0
xsubckt_1890_nand2_x0 1 0 6500 6948 7178 nand2_x0
xsubckt_9475_sff1_x4 1 2132 0 8968 1831 sff1_x4
xsubckt_8501_sff1_x4 1 2159 0 9856 85 sff1_x4
xsubckt_7530_mx3_x2 1 0 9283 8477 6289 1408 6197 6201 mx3_x2
xsubckt_7401_mx2_x2 0 9436 1 8495 6135 1561 mx2_x2
xsubckt_4873_nand3_x0 1 0 3967 3971 1925 1924 nand3_x0
xsubckt_3835_mx2_x2 0 4540 1 794 1425 1393 mx2_x2
xsubckt_3831_mx2_x2 0 4544 1 794 1841 1809 mx2_x2
xsubckt_3206_nand2_x0 1 0 5159 5994 242 nand2_x0
xsubckt_3051_mx2_x2 0 5311 1 794 1855 1823 mx2_x2
xsubckt_1532_nand2_x0 1 0 6834 6948 7062 nand2_x0
xsubckt_1622_nand2_x0 1 0 6750 6942 7093 nand2_x0
xfeed_639 1 0 tie
xfeed_638 1 0 decap_w0
xfeed_637 1 0 decap_w0
xfeed_636 1 0 decap_w0
xfeed_635 1 0 decap_w0
xfeed_634 1 0 tie
xfeed_633 1 0 tie
xfeed_632 1 0 tie
xfeed_631 1 0 decap_w0
xfeed_630 1 0 tie
xspare_feed_589 1 0 decap_w0
xspare_feed_588 1 0 tie
xspare_feed_587 1 0 tie
xspare_feed_586 1 0 decap_w0
xspare_feed_585 1 0 tie
xspare_feed_584 1 0 tie
xspare_feed_583 1 0 decap_w0
xspare_feed_582 1 0 tie
xspare_feed_581 1 0 tie
xspare_feed_580 1 0 decap_w0
xsubckt_8575_sff1_x4 1 2050 0 9782 2021 sff1_x4
xsubckt_8052_sff1_x4 1 2209 0 10305 1756 sff1_x4
xsubckt_7750_mx2_x2 0 9076 1 8444 6062 976 mx2_x2
xsubckt_7407_mx2_x2 0 9430 1 8494 6080 1554 mx2_x2
xsubckt_7405_mx2_x2 0 9432 1 8495 6098 1556 mx2_x2
xsubckt_7403_mx2_x2 0 9434 1 8495 6115 1558 mx2_x2
xsubckt_7003_ao22_x2 0 8702 1 707 8277 637 ao22_x2
xsubckt_5818_ao22_x2 0 3192 1 6428 6430 7840 ao22_x2
xsubckt_5311_nand2_x0 1 0 3589 3885 8277 nand2_x0
xsubckt_5221_nand2_x0 1 0 3672 3907 8262 nand2_x0
xsubckt_3839_mx2_x2 0 4536 1 794 1585 1553 mx2_x2
xsubckt_3055_mx2_x2 0 5307 1 794 1439 1407 mx2_x2
xsubckt_879_a3_x2 1 7469 0 7470 7471 7472 a3_x2
xsubckt_848_nand2_x0 1 0 7499 7810 425 nand2_x0
xsubckt_573_ao22_x2 0 7764 1 767 92 1903 ao22_x2
xcmpt_abc_30082_new_n7693_hfns_2 1 0 4180 4177 buf_x4
xcmpt_abc_30082_new_n7693_hfns_1 1 0 4177 4178 buf_x4
xcmpt_abc_30082_new_n7693_hfns_0 1 0 4177 4179 buf_x4
xsubckt_9383_sff1_x4 1 2235 0 9060 961 sff1_x4
xsubckt_8932_sff1_x4 1 2079 0 9493 739 sff1_x4
xsubckt_8048_sff1_x4 1 2189 0 10309 1760 sff1_x4
xsubckt_7754_mx2_x2 0 9072 1 8444 6026 971 mx2_x2
xsubckt_7752_mx2_x2 0 9074 1 8443 6043 974 mx2_x2
xsubckt_7496_mx3_x2 1 0 9315 8482 6291 1120 6196 6200 mx3_x2
xsubckt_7494_mx3_x2 1 0 9317 8482 6291 1092 6215 6219 mx3_x2
xsubckt_7492_mx3_x2 1 0 9319 8482 6291 1094 6236 6240 mx3_x2
xsubckt_7409_mx2_x2 0 9428 1 8495 6062 1552 mx2_x2
xsubckt_7363_mx2_x2 0 9472 1 8500 6170 1597 mx2_x2
xsubckt_7361_mx2_x2 0 9474 1 8500 6189 1599 mx2_x2
xsubckt_6862_oa22_x2 0 8809 1 8826 8811 8812 oa22_x2
xsubckt_5962_oa22_x2 0 3049 1 44 1905 191 oa22_x2
xsubckt_5400_nxr2_x1 3506 1 0 3516 3868 nxr2_x1
xsubckt_3059_mx2_x2 0 5303 1 793 1599 1567 mx2_x2
xsubckt_3026_nand2_x0 1 0 10404 5336 5394 nand2_x0
xsubckt_2524_mx2_x2 0 5829 1 793 1836 1804 mx2_x2
xsubckt_2522_mx2_x2 0 5831 1 799 1772 1740 mx2_x2
xsubckt_738_nor2_x0 1 0 7603 7604 7610 nor2_x0
xsubckt_251_inv_x0 1 0 1985 8125 inv_x0
xsubckt_253_inv_x0 1 0 221 8123 inv_x0
xfeed_646 1 0 tie
xfeed_645 1 0 tie
xfeed_644 1 0 tie
xfeed_643 1 0 tie
xfeed_642 1 0 decap_w0
xfeed_641 1 0 decap_w0
xfeed_640 1 0 decap_w0
xspare_feed_599 1 0 tie
xspare_feed_598 1 0 decap_w0
xspare_feed_597 1 0 tie
xspare_feed_596 1 0 tie
xspare_feed_595 1 0 decap_w0
xspare_feed_594 1 0 tie
xspare_feed_593 1 0 tie
xspare_feed_592 1 0 decap_w0
xspare_feed_591 1 0 tie
xspare_feed_590 1 0 tie
xsubckt_9379_sff1_x4 1 2142 0 9064 935 sff1_x4
xsubckt_9305_sff1_x4 1 2136 0 9135 1034 sff1_x4
xsubckt_8928_sff1_x4 1 2089 0 9497 765 sff1_x4
xsubckt_8840_sff1_x4 1 2245 0 9585 1534 sff1_x4
xsubckt_8483_sff1_x4 1 2050 0 9874 1919 sff1_x4
xsubckt_8405_sff1_x4 1 2205 0 9952 1627 sff1_x4
xsubckt_7758_mx2_x2 0 9070 1 8438 6282 963 mx2_x2
xsubckt_7586_nand4_x0 1 0 8466 6306 6309 556 555 nand4_x0
xsubckt_7369_mx2_x2 0 9466 1 8499 6115 1590 mx2_x2
xsubckt_7367_mx2_x2 0 9468 1 8499 6134 1593 mx2_x2
xsubckt_7365_mx2_x2 0 9470 1 8499 6151 1595 mx2_x2
xsubckt_5078_oa22_x2 0 3805 1 3817 3815 3816 oa22_x2
xsubckt_5039_nxr2_x1 3841 1 0 3842 3845 nxr2_x1
xsubckt_4840_a4_x2 0 3991 1 3992 4003 4016 4028 a4_x2
xsubckt_4800_a4_x2 0 4021 1 4023 4028 4142 1945 a4_x2
xsubckt_2919_mx2_x2 0 5441 1 798 993 961 mx2_x2
xsubckt_2873_mx2_x2 0 5486 1 798 1828 1796 mx2_x2
xsubckt_2673_ao22_x2 0 5683 1 5734 5730 5731 ao22_x2
xsubckt_2528_mx2_x2 0 5825 1 798 972 940 mx2_x2
xsubckt_2526_mx2_x2 0 5827 1 787 5828 5829 mx2_x2
xsubckt_2480_mx2_x2 0 5872 1 8021 5873 5876 mx2_x2
xsubckt_1139_oa22_x2 0 7223 1 7614 7478 7224 oa22_x2
xsubckt_1051_oa22_x2 0 7306 1 7307 7311 7793 oa22_x2
xsubckt_569_ao22_x2 0 7768 1 7769 7773 7795 ao22_x2
xsubckt_255_inv_x0 1 0 1980 8121 inv_x0
xsubckt_257_inv_x0 1 0 415 8119 inv_x0
xsubckt_259_inv_x0 1 0 2006 8117 inv_x0
xsubckt_406_o2_x2 0 7939 1 249 217 o2_x2
xsubckt_1338_ao22_x2 0 7027 1 7028 7031 7047 ao22_x2
xsubckt_1348_nand3_x0 1 0 7017 7067 192 8115 nand3_x0
xsubckt_2135_mx2_x2 0 9402 1 7918 418 386 mx2_x2
xsubckt_2137_mx2_x2 0 9401 1 7918 417 385 mx2_x2
xfeed_649 1 0 tie
xfeed_648 1 0 decap_w0
xfeed_647 1 0 tie
xsubckt_2303_nand3_x0 1 0 6077 6078 541 8409 nand3_x0
xsubckt_2139_mx2_x2 0 9400 1 7918 416 384 mx2_x2
xsubckt_1415_nor2_x0 1 0 6950 612 613 nor2_x0
xsubckt_1088_a3_x2 1 7271 0 7272 7273 7274 a3_x2
xsubckt_2482_mx2_x2 0 5870 1 796 1367 1335 mx2_x2
xsubckt_2484_mx2_x2 0 5868 1 796 1143 1111 mx2_x2
xsubckt_2486_mx2_x2 0 5866 1 788 5867 5868 mx2_x2
xsubckt_2877_mx2_x2 0 5482 1 796 1412 1380 mx2_x2
xsubckt_3204_oa22_x2 0 5160 1 5161 5208 5995 oa22_x2
xsubckt_3806_nand2_x0 1 0 4569 5995 231 nand2_x0
xsubckt_5026_a2_x2 0 3853 1 3854 3855 a2_x2
xsubckt_5399_a4_x2 0 3507 1 3540 3867 3870 3873 a4_x2
xsubckt_6050_mx2_x2 0 2963 1 860 1376 1344 mx2_x2
xsubckt_6052_mx2_x2 0 2961 1 8220 2962 2963 mx2_x2
xsubckt_6441_mx2_x2 0 2583 1 860 980 948 mx2_x2
xsubckt_6443_mx2_x2 0 2581 1 833 2582 2583 mx2_x2
xsubckt_6534_ao22_x2 0 2492 1 574 567 751 ao22_x2
xsubckt_6836_mx2_x2 0 9670 1 6441 8834 653 mx2_x2
xsubckt_6932_a4_x2 0 8760 1 395 8259 393 579 a4_x2
xsubckt_7940_sff1_x4 1 2066 0 10454 829 sff1_x4
xsubckt_9291_sff1_x4 1 2242 0 9149 1050 sff1_x4
xsubckt_9213_sff1_x4 1 2103 0 9227 1068 sff1_x4
xsubckt_8479_sff1_x4 1 2044 0 9878 1924 sff1_x4
xfeed_650 1 0 tie
xcmpt_abc_30082_new_n10773_hfns_2 1 0 8481 8478 buf_x4
xcmpt_abc_30082_new_n10773_hfns_1 1 0 8478 8479 buf_x4
xcmpt_abc_30082_new_n10773_hfns_0 1 0 8478 8480 buf_x4
xsubckt_2304_oa22_x2 0 6076 1 6093 76 75 oa22_x2
xsubckt_2099_mx2_x2 0 6348 1 858 1289 1257 mx2_x2
xsubckt_1952_nand2_x0 1 0 451 6459 6489 nand2_x0
xsubckt_1699_nand2_x0 1 0 2310 6679 6683 nand2_x0
xsubckt_635_oa22_x2 0 7705 1 7801 7804 8131 oa22_x2
xsubckt_924_xr2_x1 7427 0 1 758 83 xr2_x1
xsubckt_2488_mx2_x2 0 5864 1 820 1591 1559 mx2_x2
xsubckt_2503_ao22_x2 0 5849 1 5943 5896 5898 ao22_x2
xsubckt_2681_a3_x2 1 5675 0 5676 5677 7905 a3_x2
xsubckt_3443_a2_x2 0 4925 1 4926 4931 a2_x2
xsubckt_3626_nand2_x0 1 0 10394 4746 4805 nand2_x0
xsubckt_5066_a2_x2 0 3816 1 3939 726 a2_x2
xsubckt_5307_mx3_x2 1 0 3592 703 651 3889 3593 3596 mx3_x2
xsubckt_5515_a2_x2 0 3419 1 3421 2023 a2_x2
xsubckt_5910_mx2_x2 0 3099 1 859 1126 1094 mx2_x2
xsubckt_6054_mx2_x2 0 2959 1 859 1152 1120 mx2_x2
xsubckt_6056_mx2_x2 0 2957 1 8215 2958 2961 mx2_x2
xsubckt_6058_mx2_x2 0 2955 1 859 1600 1568 mx2_x2
xsubckt_6249_a2_x2 0 9694 1 2770 2804 a2_x2
xsubckt_6445_mx2_x2 0 2579 1 826 2580 2587 mx2_x2
xsubckt_6447_mx2_x2 0 2577 1 859 1300 1268 mx2_x2
xsubckt_6449_mx2_x2 0 2575 1 859 1236 1204 mx2_x2
xsubckt_6845_a3_x2 1 8823 0 395 8259 8261 a3_x2
xsubckt_8313_sff1_x4 1 2215 0 10044 1654 sff1_x4
xsubckt_8391_sff1_x4 1 2098 0 9966 1623 sff1_x4
xsubckt_8836_sff1_x4 1 2192 0 9589 1508 sff1_x4
xsubckt_9287_sff1_x4 1 2245 0 9153 1054 sff1_x4
xcmpt_abc_30082_new_n5466_hfns_2 1 0 6260 6257 buf_x4
xcmpt_abc_30082_new_n5466_hfns_1 1 0 6257 6258 buf_x4
xcmpt_abc_30082_new_n5466_hfns_0 1 0 6257 6259 buf_x4
xsubckt_1874_nxr2_x1 6515 1 0 6517 194 nxr2_x1
xsubckt_1645_a2_x2 0 6729 1 6730 242 a2_x2
xsubckt_1391_a2_x2 0 6974 1 6975 6976 a2_x2
xsubckt_414_nor4_x0 1 0 7928 7937 7943 8287 8305 nor4_x0
xsubckt_4793_a3_x2 1 4026 0 4028 4142 1947 a3_x2
xsubckt_4841_a2_x2 0 3990 1 3991 4142 a2_x2
xsubckt_4861_a2_x2 0 9882 1 3976 46 a2_x2
xsubckt_5641_nand2_x0 1 0 3332 6014 7818 nand2_x0
xsubckt_5912_mx2_x2 0 3097 1 8214 3098 3101 mx2_x2
xsubckt_5914_mx2_x2 0 3095 1 864 1574 1542 mx2_x2
xsubckt_5916_mx2_x2 0 3093 1 864 1478 1446 mx2_x2
xsubckt_6885_a3_x2 1 8794 0 8258 394 8261 a3_x2
xsubckt_6913_a2_x2 0 9652 1 8775 47 a2_x2
xsubckt_6965_ao22_x2 0 8735 1 707 8279 619 ao22_x2
xsubckt_7198_a2_x2 0 8617 1 8422 717 a2_x2
xsubckt_7936_sff1_x4 1 2136 0 10416 1802 sff1_x4
xsubckt_8387_sff1_x4 1 2119 0 9970 1483 sff1_x4
xsubckt_9121_sff1_x4 1 2193 0 9319 1094 sff1_x4
xsubckt_9209_sff1_x4 1 2119 0 9231 1194 sff1_x4
xsubckt_2411_ao22_x2 0 5939 1 6389 5940 5941 ao22_x2
xsubckt_1772_nand2_x0 1 0 6610 7140 7972 nand2_x0
xsubckt_1677_ao22_x2 0 6699 1 6715 6712 6701 ao22_x2
xsubckt_1504_nand2_x0 1 0 2293 6861 6865 nand2_x0
xsubckt_1477_o4_x2 0 6886 1 456 445 467 468 o4_x2
xsubckt_886_xr2_x1 7463 0 1 760 85 xr2_x1
xsubckt_1038_xr2_x1 7319 0 1 751 76 xr2_x1
xsubckt_1154_ao22_x2 0 7209 1 7211 7213 1903 ao22_x2
xsubckt_3446_nand2_x0 1 0 4923 5994 238 nand2_x0
xsubckt_4881_a2_x2 0 9876 1 3962 3963 a2_x2
xsubckt_5870_mx2_x2 0 3138 1 862 1351 1319 mx2_x2
xsubckt_5872_mx2_x2 0 3136 1 8222 3137 3138 mx2_x2
xsubckt_5874_mx2_x2 0 3134 1 862 1127 1095 mx2_x2
xsubckt_5889_a2_x2 0 9704 1 3120 3154 a2_x2
xsubckt_5918_mx2_x2 0 3091 1 8222 3092 3093 mx2_x2
xsubckt_7250_ao22_x2 0 8580 1 662 644 388 ao22_x2
xsubckt_8221_sff1_x4 1 2145 0 10136 1266 sff1_x4
xsubckt_8309_sff1_x4 1 2205 0 10048 1659 sff1_x4
xsubckt_8744_sff1_x4 1 2150 0 2301 2269 sff1_x4
xsubckt_9195_sff1_x4 1 2248 0 9245 1210 sff1_x4
xcmpt_cpuregs_rdreg_1_q_0_hfns_19 1 0 802 810 buf_x4
xcmpt_cpuregs_rdreg_1_q_0_hfns_18 1 0 802 811 buf_x4
xcmpt_cpuregs_rdreg_1_q_0_hfns_17 1 0 802 812 buf_x4
xcmpt_cpuregs_rdreg_1_q_0_hfns_16 1 0 802 813 buf_x4
xcmpt_cpuregs_rdreg_1_q_0_hfns_15 1 0 802 814 buf_x4
xcmpt_cpuregs_rdreg_1_q_0_hfns_14 1 0 802 815 buf_x4
xcmpt_cpuregs_rdreg_1_q_0_hfns_13 1 0 802 816 buf_x4
xcmpt_cpuregs_rdreg_1_q_0_hfns_12 1 0 802 817 buf_x4
xcmpt_cpuregs_rdreg_1_q_0_hfns_11 1 0 802 818 buf_x4
xcmpt_cpuregs_rdreg_1_q_0_hfns_10 1 0 802 819 buf_x4
xsubckt_1782_nxr2_x1 6601 1 0 6604 232 nxr2_x1
xsubckt_1754_nor2_x0 1 0 6627 6628 6635 nor2_x0
xsubckt_1704_nxr2_x1 6674 1 0 6675 8042 nxr2_x1
xsubckt_1592_nand2_x0 1 0 6778 6942 7083 nand2_x0
xsubckt_1418_o2_x2 0 6944 1 663 664 o2_x2
xsubckt_539_oa22_x2 0 7800 1 7801 7804 8141 oa22_x2
xsubckt_2678_nxr2_x1 5678 1 0 221 740 nxr2_x1
xsubckt_2903_nand3_x0 1 0 5456 5457 5633 7856 nand3_x0
xsubckt_3266_nand2_x0 1 0 10400 5100 5159 nand2_x0
xsubckt_3985_nor2_x0 1 0 4392 4393 5995 nor2_x0
xsubckt_4148_nand2_x0 1 0 4232 6011 8073 nand2_x0
xsubckt_4210_mx2_x2 0 10337 1 4214 6162 1148 mx2_x2
xsubckt_4212_mx2_x2 0 10335 1 4214 6143 1146 mx2_x2
xsubckt_4214_mx2_x2 0 10333 1 4214 6124 1144 mx2_x2
xsubckt_4343_mx3_x2 1 0 10216 4193 6295 1445 6226 6230 mx3_x2
xsubckt_4345_mx3_x2 1 0 10214 4193 6295 1473 6206 6210 mx3_x2
xsubckt_4601_mx2_x2 0 9976 1 4151 6081 1490 mx2_x2
xsubckt_4603_mx2_x2 0 9974 1 4152 6061 1488 mx2_x2
xsubckt_4605_mx2_x2 0 9972 1 4152 6044 1486 mx2_x2
xsubckt_5547_nand3_x0 1 0 3397 3401 2012 2013 nand3_x0
xsubckt_5876_mx2_x2 0 3132 1 8215 3133 3136 mx2_x2
xsubckt_5878_mx2_x2 0 3130 1 861 1575 1543 mx2_x2
xsubckt_8295_sff1_x4 1 2098 0 10062 1655 sff1_x4
xsubckt_9117_sff1_x4 1 2103 0 9323 1100 sff1_x4
xspare_feed_709 1 0 decap_w0
xspare_feed_708 1 0 tie
xspare_feed_707 1 0 tie
xspare_feed_706 1 0 decap_w0
xspare_feed_705 1 0 tie
xspare_feed_704 1 0 tie
xspare_feed_703 1 0 decap_w0
xspare_feed_702 1 0 tie
xspare_feed_701 1 0 tie
xspare_feed_700 1 0 decap_w0
xsubckt_1255_nxr2_x1 7110 1 0 208 241 nxr2_x1
xsubckt_3016_oa22_x2 0 5345 1 5346 5347 8017 oa22_x2
xsubckt_3745_o2_x2 0 4628 1 4629 5994 o2_x2
xsubckt_4170_mx2_x2 0 10371 1 4224 6179 1790 mx2_x2
xsubckt_4216_mx2_x2 0 10331 1 4215 6108 1141 mx2_x2
xsubckt_4218_mx2_x2 0 10329 1 4215 6089 1139 mx2_x2
xsubckt_4561_mx2_x2 0 10014 1 4157 6135 1337 mx2_x2
xsubckt_4607_mx2_x2 0 9970 1 4152 6027 1483 mx2_x2
xsubckt_4952_mx2_x2 0 3909 1 6445 6167 149 mx2_x2
xsubckt_5170_nor2_x0 1 0 3719 3720 7881 nor2_x0
xsubckt_5208_nxr2_x1 3684 1 0 3910 716 nxr2_x1
xsubckt_5247_oa22_x2 0 3648 1 3659 3657 3658 oa22_x2
xsubckt_6950_nor2_x0 1 0 8746 8764 8793 nor2_x0
xsubckt_6998_nor3_x0 1 0 8706 391 389 388 nor3_x0
xsubckt_8217_sff1_x4 1 2214 0 10140 1270 sff1_x4
xsubckt_8652_sff1_x4 1 2185 0 9737 507 sff1_x4
xcmpt_cpuregs_rdreg_1_q_0_hfns_26 1 0 800 802 buf_x4
xcmpt_cpuregs_rdreg_1_q_0_hfns_25 1 0 801 803 buf_x4
xcmpt_cpuregs_rdreg_1_q_0_hfns_24 1 0 801 804 buf_x4
xcmpt_cpuregs_rdreg_1_q_0_hfns_23 1 0 801 805 buf_x4
xcmpt_cpuregs_rdreg_1_q_0_hfns_22 1 0 801 806 buf_x4
xcmpt_cpuregs_rdreg_1_q_0_hfns_21 1 0 801 807 buf_x4
xcmpt_cpuregs_rdreg_1_q_0_hfns_20 1 0 801 808 buf_x4
xcmpt_abc_30082_new_n3628_hfns_4 1 0 8027 8032 buf_x4
xcmpt_abc_30082_new_n3628_hfns_3 1 0 8027 8033 buf_x4
xcmpt_abc_30082_new_n3628_hfns_2 1 0 8027 8034 buf_x4
xcmpt_abc_30082_new_n3628_hfns_1 1 0 8027 8035 buf_x4
xcmpt_abc_30082_new_n3628_hfns_0 1 0 8027 8036 buf_x4
xsubckt_450_nand3_x0 1 0 7888 7889 7901 7908 nand3_x0
xsubckt_1144_nand2_x0 1 0 7218 634 1955 nand2_x0
xsubckt_3086_nand2_x0 1 0 5277 5994 244 nand2_x0
xsubckt_4172_mx2_x2 0 10369 1 4223 6162 1788 mx2_x2
xsubckt_4174_mx2_x2 0 10367 1 4223 6143 1786 mx2_x2
xsubckt_4176_mx2_x2 0 10365 1 4223 6124 1784 mx2_x2
xsubckt_4563_mx2_x2 0 10012 1 4157 6116 1334 mx2_x2
xsubckt_4565_mx2_x2 0 10010 1 4157 6097 1332 mx2_x2
xsubckt_4567_mx2_x2 0 10008 1 4157 6081 1330 mx2_x2
xsubckt_4956_mx2_x2 0 3906 1 6445 6159 148 mx2_x2
xsubckt_5166_nor2_x0 1 0 3723 3724 3727 nor2_x0
xsubckt_5194_nxr2_x1 3697 1 0 3913 733 nxr2_x1
xsubckt_5639_nxr2_x1 3333 1 0 3335 8069 nxr2_x1
xsubckt_5682_oa22_x2 0 3291 1 5950 3292 3323 oa22_x2
xsubckt_8125_sff1_x4 1 2145 0 10232 1234 sff1_x4
xsubckt_8648_sff1_x4 1 2194 0 9741 511 sff1_x4
xsubckt_9025_sff1_x4 1 2083 0 9405 390 sff1_x4
xsubckt_9460_sff1_x4 1 2136 0 8983 1875 sff1_x4
xspare_feed_719 1 0 tie
xspare_feed_718 1 0 decap_w0
xspare_feed_717 1 0 tie
xspare_feed_716 1 0 tie
xspare_feed_715 1 0 decap_w0
xspare_feed_714 1 0 tie
xspare_feed_713 1 0 tie
xspare_feed_712 1 0 decap_w0
xspare_feed_711 1 0 tie
xspare_feed_710 1 0 tie
xcmpt_cpuregs_rdreg_1_q_0_hfns_28 1 0 822 800 buf_x4
xcmpt_cpuregs_rdreg_1_q_0_hfns_27 1 0 800 801 buf_x4
xcmpt_abc_30082_new_n7932_hfns_3 1 0 4144 4140 buf_x4
xcmpt_abc_30082_new_n7932_hfns_2 1 0 4140 4141 buf_x4
xcmpt_abc_30082_new_n7932_hfns_1 1 0 4140 4142 buf_x4
xcmpt_abc_30082_new_n7932_hfns_0 1 0 4140 4143 buf_x4
xcmpt_abc_30082_new_n3628_hfns_9 1 0 8037 8027 buf_x4
xcmpt_abc_30082_new_n3628_hfns_8 1 0 8027 8028 buf_x4
xcmpt_abc_30082_new_n3628_hfns_7 1 0 8027 8029 buf_x4
xcmpt_abc_30082_new_n3628_hfns_6 1 0 8027 8030 buf_x4
xcmpt_abc_30082_new_n3628_hfns_5 1 0 8027 8031 buf_x4
xsubckt_891_nand2_x0 1 0 7458 7459 1895 nand2_x0
xsubckt_1054_nand2_x0 1 0 170 7304 7316 nand2_x0
xsubckt_3643_mx2_x2 0 4729 1 805 1172 1076 mx2_x2
xsubckt_4178_mx2_x2 0 10363 1 4224 6108 1781 mx2_x2
xsubckt_4569_mx2_x2 0 10006 1 4157 6062 1328 mx2_x2
xsubckt_5551_nxr2_x1 3394 1 0 3398 8133 nxr2_x1
xsubckt_7600_mx2_x2 0 9217 1 8465 6179 1086 mx2_x2
xsubckt_7731_mx3_x2 1 0 9095 8446 6287 966 6236 6240 mx3_x2
xsubckt_7733_mx3_x2 1 0 9093 8446 6287 964 6216 6220 mx3_x2
xsubckt_8199_sff1_x4 1 2132 0 10158 1271 sff1_x4
xsubckt_8560_sff1_x4 1 2047 0 9797 2037 sff1_x4
xsubckt_9099_sff1_x4 1 2222 0 9341 890 sff1_x4
xsubckt_9456_sff1_x4 1 2222 0 8987 1880 sff1_x4
xsubckt_1924_nand2_x0 1 0 6474 442 330 nand2_x0
xsubckt_396_a2_x2 0 7949 1 7950 7951 a2_x2
xsubckt_101_inv_x0 1 0 1932 8310 inv_x0
xsubckt_103_inv_x0 1 0 1965 8308 inv_x0
xsubckt_105_inv_x0 1 0 365 8306 inv_x0
xsubckt_571_a2_x2 0 7766 1 767 92 a2_x2
xsubckt_790_oa22_x2 0 7554 1 7555 7614 8284 oa22_x2
xsubckt_3647_mx2_x2 0 4725 1 804 1780 1748 mx2_x2
xsubckt_3804_oa22_x2 0 4570 1 4571 4618 5995 oa22_x2
xsubckt_3866_nand2_x0 1 0 10390 4510 4569 nand2_x0
xsubckt_4037_nand3_x0 1 0 4341 4342 4515 6392 nand3_x0
xsubckt_5097_nand3_x0 1 0 3787 3788 3791 7845 nand3_x0
xsubckt_7062_ao22_x2 0 8677 1 8258 394 579 ao22_x2
xsubckt_7602_mx2_x2 0 9215 1 8465 6161 1084 mx2_x2
xsubckt_7604_mx2_x2 0 9213 1 8464 6142 1082 mx2_x2
xsubckt_7606_mx2_x2 0 9211 1 8464 6125 1080 mx2_x2
xsubckt_7735_mx3_x2 1 0 9091 8446 6288 992 6197 6201 mx3_x2
xsubckt_8033_sff1_x4 1 2139 0 10324 1134 sff1_x4
xsubckt_8556_sff1_x4 1 2060 0 9801 1979 sff1_x4
xsubckt_8991_sff1_x4 1 2215 0 9434 1558 sff1_x4
xspare_feed_720 1 0 tie
xsubckt_2330_mx2_x2 0 10419 1 6300 6044 1806 mx2_x2
xsubckt_1834_nand2_x0 1 0 6552 6553 6560 nand2_x0
xsubckt_533_nand2_x0 1 0 435 7806 7939 nand2_x0
xsubckt_107_inv_x0 1 0 367 8304 inv_x0
xsubckt_109_inv_x0 1 0 112 8302 inv_x0
xsubckt_885_a2_x2 0 7464 1 760 85 a2_x2
xsubckt_3686_nand2_x0 1 0 4687 5995 233 nand2_x0
xsubckt_3996_mx2_x2 0 4382 1 810 974 942 mx2_x2
xsubckt_3998_mx2_x2 0 4380 1 788 4381 4382 mx2_x2
xsubckt_5260_nand3_x0 1 0 3636 3663 3897 3900 nand3_x0
xsubckt_5346_nand4_x0 1 0 3556 3559 3594 3604 3606 nand4_x0
xsubckt_6320_oa22_x2 0 2700 1 3191 2703 2701 oa22_x2
xsubckt_7075_a4_x2 0 8668 1 6306 6309 556 8008 a4_x2
xsubckt_7113_nor3_x0 1 0 8661 622 621 577 nor3_x0
xsubckt_7219_mx2_x2 0 9516 1 8832 8601 744 mx2_x2
xsubckt_7608_mx2_x2 0 9209 1 8465 6107 1077 mx2_x2
xsubckt_8913_sff1_x4 1 2089 0 9512 749 sff1_x4
xsubckt_9364_sff1_x4 1 2142 0 9079 979 sff1_x4
xsubckt_2338_mx2_x2 0 6032 1 546 100 2264 mx2_x2
xsubckt_1555_oa22_x2 0 6813 1 6830 6825 6826 oa22_x2
xsubckt_443_nand2_x0 1 0 7895 7896 7898 nand2_x0
xsubckt_1032_oa22_x2 0 7324 1 7325 7329 7793 oa22_x2
xsubckt_6394_oa22_x2 0 2629 1 42 1905 203 oa22_x2
xsubckt_7566_mx2_x2 0 9249 1 8470 6179 1214 mx2_x2
xsubckt_7568_mx2_x2 0 9247 1 8469 6161 1212 mx2_x2
xsubckt_7697_mx3_x2 1 0 9127 8451 6288 998 6236 6240 mx3_x2
xsubckt_7699_mx3_x2 1 0 9125 8451 6288 996 6216 6220 mx3_x2
xsubckt_8029_sff1_x4 1 2145 0 10328 1138 sff1_x4
xsubckt_8464_sff1_x4 1 2057 0 9893 1940 sff1_x4
xsubckt_8987_sff1_x4 1 2203 0 9438 1563 sff1_x4
xsubckt_1654_nand2_x0 1 0 2313 6721 6725 nand2_x0
xsubckt_1630_a3_x2 1 6743 0 6754 6769 6775 a3_x2
xsubckt_439_nand3_x0 1 0 7899 1894 40 8404 nand3_x0
xsubckt_1014_a2_x2 0 7341 1 7342 7348 a2_x2
xsubckt_2683_mx2_x2 0 5673 1 807 967 935 mx2_x2
xsubckt_2685_mx2_x2 0 5671 1 790 5672 5673 mx2_x2
xsubckt_2687_mx2_x2 0 5669 1 807 1863 1511 mx2_x2
xsubckt_4857_a4_x2 0 3978 1 3980 3991 4142 1929 a4_x2
xsubckt_5540_a3_x2 1 9777 0 3402 3403 40 a3_x2
xsubckt_5726_a4_x2 0 3276 1 3277 7821 7834 7866 a4_x2
xsubckt_6251_mx2_x2 0 2768 1 864 922 890 mx2_x2
xsubckt_6640_mx2_x2 0 2389 1 828 2390 2397 mx2_x2
xsubckt_8821_sff1_x4 1 2083 0 9602 575 sff1_x4
xsubckt_8909_sff1_x4 1 2073 0 9516 744 sff1_x4
xsubckt_9272_sff1_x4 1 2119 0 9168 1419 sff1_x4
xcmpt_resetn_hfns_0 1 0 48 55 buf_x4
xsubckt_2452_a2_x2 0 5899 1 767 216 a2_x2
xsubckt_2296_mx2_x2 0 6086 1 545 107 2271 mx2_x2
xsubckt_2266_nand2_x0 1 0 6126 6127 6131 nand2_x0
xsubckt_2189_a3_x2 1 6242 0 6256 65 64 a3_x2
xsubckt_1523_a2_x2 0 6843 1 6844 8415 a2_x2
xsubckt_1328_a2_x2 0 7037 1 467 8286 a2_x2
xsubckt_698_o2_x2 0 7645 1 739 64 o2_x2
xsubckt_2689_mx2_x2 0 5667 1 8032 5668 5669 mx2_x2
xsubckt_2720_oa22_x2 0 5636 1 5637 5638 8017 oa22_x2
xsubckt_3401_nand2_x0 1 0 4967 4968 784 nand2_x0
xsubckt_5258_a2_x2 0 3638 1 3897 8278 a2_x2
xsubckt_5413_a2_x2 0 3493 1 3494 701 a2_x2
xsubckt_5615_ao22_x2 0 3349 1 3353 1990 40 ao22_x2
xsubckt_6066_ao22_x2 0 2947 1 574 566 765 ao22_x2
xsubckt_6253_mx2_x2 0 2766 1 8226 2767 2768 mx2_x2
xsubckt_6255_mx2_x2 0 2764 1 843 1786 1754 mx2_x2
xsubckt_6257_mx2_x2 0 2762 1 8214 2763 2766 mx2_x2
xsubckt_6648_mx2_x2 0 2382 1 843 1838 1806 mx2_x2
xsubckt_7056_a2_x2 0 8681 1 8682 8683 a2_x2
xsubckt_7251_a2_x2 0 8579 1 732 653 a2_x2
xsubckt_7921_sff1_x4 1 2203 0 10431 1819 sff1_x4
xsubckt_7995_sff1_x4 1 2209 0 10362 1780 sff1_x4
xsubckt_8372_sff1_x4 1 2206 0 9985 1500 sff1_x4
xsubckt_8817_sff1_x4 1 2083 0 9605 768 sff1_x4
xsubckt_8895_sff1_x4 1 2050 0 9530 339 sff1_x4
xcmpt_cpuregs_rdreg_0_q_0_hfns_19 1 0 847 855 buf_x4
xcmpt_cpuregs_rdreg_0_q_0_hfns_18 1 0 847 856 buf_x4
xcmpt_cpuregs_rdreg_0_q_0_hfns_17 1 0 847 857 buf_x4
xcmpt_cpuregs_rdreg_0_q_0_hfns_16 1 0 847 858 buf_x4
xcmpt_cpuregs_rdreg_0_q_0_hfns_15 1 0 847 859 buf_x4
xcmpt_cpuregs_rdreg_0_q_0_hfns_14 1 0 847 860 buf_x4
xcmpt_cpuregs_rdreg_0_q_0_hfns_13 1 0 847 861 buf_x4
xcmpt_cpuregs_rdreg_0_q_0_hfns_12 1 0 847 862 buf_x4
xcmpt_cpuregs_rdreg_0_q_0_hfns_11 1 0 847 863 buf_x4
xcmpt_cpuregs_rdreg_0_q_0_hfns_10 1 0 847 864 buf_x4
xcmpt_abc_30082_new_n10978_hfns_2 1 0 8450 8447 buf_x4
xcmpt_abc_30082_new_n10978_hfns_1 1 0 8447 8448 buf_x4
xcmpt_abc_30082_new_n10978_hfns_0 1 0 8447 8449 buf_x4
xcmpt_resetn_hfns_9 1 0 48 40 buf_x4
xcmpt_resetn_hfns_8 1 0 48 41 buf_x4
xcmpt_resetn_hfns_7 1 0 48 42 buf_x4
xcmpt_resetn_hfns_6 1 0 48 43 buf_x4
xcmpt_resetn_hfns_5 1 0 48 44 buf_x4
xcmpt_resetn_hfns_4 1 0 48 45 buf_x4
xcmpt_resetn_hfns_3 1 0 48 46 buf_x4
xcmpt_resetn_hfns_2 1 0 48 47 buf_x4
xcmpt_resetn_hfns_1 1 0 48 54 buf_x4
xsubckt_1789_a3_x2 1 6594 0 6595 6596 6597 a3_x2
xsubckt_1388_a2_x2 0 6977 1 193 8068 a2_x2
xsubckt_1368_a2_x2 0 6997 1 6998 6999 a2_x2
xsubckt_1332_nxr2_x1 7033 1 0 467 216 nxr2_x1
xsubckt_1116_nand2_x0 1 0 7245 7247 7249 nand2_x0
xsubckt_2783_nand3_x0 1 0 5574 5575 5576 775 nand3_x0
xsubckt_5720_mx2_x2 0 9715 1 3282 476 513 mx2_x2
xsubckt_6259_mx2_x2 0 2760 1 840 1178 1082 mx2_x2
xsubckt_7917_sff1_x4 1 2222 0 10435 1823 sff1_x4
xsubckt_8368_sff1_x4 1 2195 0 9989 1504 sff1_x4
xsubckt_9180_sff1_x4 1 2132 0 9260 1207 sff1_x4
xsubckt_9268_sff1_x4 1 2129 0 9172 1424 sff1_x4
xsubckt_1894_oa22_x2 0 2295 1 6940 6501 6497 oa22_x2
xsubckt_1235_xr2_x1 7130 0 1 203 235 xr2_x1
xsubckt_381_nor4_x0 1 0 7964 617 619 664 655 nor4_x0
xsubckt_21_inv_x0 1 0 137 8390 inv_x0
xsubckt_953_nand2_x0 1 0 7399 1994 638 nand2_x0
xsubckt_1026_nand2_x0 1 0 7330 233 1898 nand2_x0
xsubckt_3221_nand2_x0 1 0 5144 5145 780 nand2_x0
xsubckt_3695_a2_x2 0 4678 1 4679 4686 a2_x2
xsubckt_3870_a2_x2 0 4506 1 230 749 a2_x2
xsubckt_4043_o2_x2 0 4335 1 4336 5995 o2_x2
xsubckt_4789_ao22_x2 0 9900 1 4030 4031 44 ao22_x2
xsubckt_4838_a2_x2 0 9888 1 3993 44 a2_x2
xsubckt_4878_a2_x2 0 9877 1 3964 44 a2_x2
xsubckt_4931_mx3_x2 1 0 3925 6449 547 8374 8189 8190 mx3_x2
xsubckt_5073_nand2_x0 1 0 9836 3810 3822 nand2_x0
xsubckt_5680_mx2_x2 0 3293 1 776 3294 3301 mx2_x2
xsubckt_8202_sff1_x4 1 2251 0 10155 1256 sff1_x4
xsubckt_8280_sff1_x4 1 2223 0 10077 1304 sff1_x4
xsubckt_8725_sff1_x4 1 2189 0 2291 2259 sff1_x4
xsubckt_9102_sff1_x4 1 2206 0 9338 886 sff1_x4
xcmpt_cpuregs_rdreg_0_q_0_hfns_28 1 0 867 845 buf_x4
xcmpt_cpuregs_rdreg_0_q_0_hfns_27 1 0 845 846 buf_x4
xcmpt_cpuregs_rdreg_0_q_0_hfns_26 1 0 845 847 buf_x4
xcmpt_cpuregs_rdreg_0_q_0_hfns_25 1 0 846 848 buf_x4
xcmpt_cpuregs_rdreg_0_q_0_hfns_24 1 0 846 849 buf_x4
xcmpt_cpuregs_rdreg_0_q_0_hfns_23 1 0 846 850 buf_x4
xcmpt_cpuregs_rdreg_0_q_0_hfns_22 1 0 846 851 buf_x4
xcmpt_cpuregs_rdreg_0_q_0_hfns_21 1 0 846 852 buf_x4
xcmpt_cpuregs_rdreg_0_q_0_hfns_20 1 0 846 853 buf_x4
xsubckt_1897_a2_x2 0 6495 1 7804 7807 a2_x2
xsubckt_1240_nxr2_x1 7125 1 0 204 236 nxr2_x1
xsubckt_1239_xr2_x1 7126 0 1 204 236 xr2_x1
xsubckt_1191_xr2_x1 7174 0 1 194 225 xr2_x1
xsubckt_25_inv_x0 1 0 141 8386 inv_x0
xsubckt_23_inv_x0 1 0 139 8388 inv_x0
xsubckt_773_nand2_x0 1 0 7570 634 1975 nand2_x0
xsubckt_797_ao22_x2 0 7547 1 7548 7552 7795 ao22_x2
xsubckt_3041_nand2_x0 1 0 5321 5322 780 nand2_x0
xsubckt_3217_nand3_x0 1 0 5148 568 8289 86 nand3_x0
xsubckt_4020_mx2_x2 0 4358 1 812 1230 1198 mx2_x2
xsubckt_4411_mx2_x2 0 10154 1 4178 6245 1255 mx2_x2
xsubckt_4935_mx3_x2 1 0 3922 6448 546 8375 8187 8188 mx3_x2
xsubckt_5322_nand3_x0 1 0 3578 3579 3582 3584 nand3_x0
xsubckt_6175_o2_x2 0 2841 1 2842 7930 o2_x2
xsubckt_6854_ao22_x2 0 8816 1 707 8279 660 ao22_x2
xsubckt_6983_nor3_x0 1 0 8721 385 384 383 nor3_x0
xsubckt_8276_sff1_x4 1 2206 0 10081 1308 sff1_x4
xsubckt_8799_sff1_x4 1 2079 0 9623 735 sff1_x4
xsubckt_9176_sff1_x4 1 2119 0 9264 1387 sff1_x4
xsubckt_377_nor4_x0 1 0 7968 641 623 620 642 nor4_x0
xsubckt_29_inv_x0 1 0 146 8382 inv_x0
xsubckt_27_inv_x0 1 0 143 8384 inv_x0
xsubckt_2734_o2_x2 0 5623 1 220 739 o2_x2
xsubckt_3037_nand3_x0 1 0 5325 568 8290 89 nand3_x0
xsubckt_3075_oa22_x2 0 5287 1 5288 5289 8017 oa22_x2
xsubckt_4022_mx2_x2 0 4356 1 8033 4357 4358 mx2_x2
xsubckt_4024_mx2_x2 0 4354 1 812 1358 1326 mx2_x2
xsubckt_4026_mx2_x2 0 4352 1 8034 4353 4354 mx2_x2
xsubckt_4417_mx2_x2 0 10148 1 4179 6189 1279 mx2_x2
xsubckt_4419_mx2_x2 0 10146 1 4179 6170 1277 mx2_x2
xsubckt_4939_mx3_x2 1 0 3919 6450 546 8376 8185 8186 mx3_x2
xsubckt_8110_sff1_x4 1 2195 0 10247 1220 sff1_x4
xsubckt_8633_sff1_x4 1 2156 0 174 111 sff1_x4
xsubckt_9010_sff1_x4 1 2053 0 9420 387 sff1_x4
xsubckt_1702_nand4_x0 1 0 6676 6720 8039 8040 8041 nand4_x0
xsubckt_1671_nxr2_x1 6705 1 0 6706 8040 nxr2_x1
xsubckt_1236_nxr2_x1 7129 1 0 203 235 nxr2_x1
xsubckt_415_nand2_x0 1 0 7927 1913 54 nand2_x0
xsubckt_593_nand2_x0 1 0 7745 2013 637 nand2_x0
xsubckt_2508_nand2_x0 1 0 5844 237 756 nand2_x0
xsubckt_2686_nand2_x0 1 0 5670 5671 783 nand2_x0
xsubckt_2794_o2_x2 0 5564 1 219 738 o2_x2
xsubckt_3100_mx2_x2 0 5263 1 788 5264 5265 mx2_x2
xsubckt_3102_mx2_x2 0 5261 1 812 1886 1534 mx2_x2
xsubckt_3432_oa22_x2 0 4936 1 4937 4938 775 oa22_x2
xsubckt_3821_nand2_x0 1 0 4554 4555 783 nand2_x0
xsubckt_4371_mx2_x2 0 10190 1 4185 6272 1719 mx2_x2
xsubckt_4373_mx2_x2 0 10188 1 4186 6259 1705 mx2_x2
xsubckt_4375_mx2_x2 0 10186 1 4186 6244 1703 mx2_x2
xsubckt_4899_mx3_x2 1 0 3949 6449 545 8366 8301 8302 mx3_x2
xsubckt_8184_sff1_x4 1 2224 0 10173 1720 sff1_x4
xsubckt_9006_sff1_x4 1 2086 0 10449 777 sff1_x4
xsubckt_9084_sff1_x4 1 2097 0 9356 887 sff1_x4
xsubckt_9441_sff1_x4 1 2098 0 9002 1865 sff1_x4
xsubckt_1626_nand2_x0 1 0 6747 6948 7096 nand2_x0
xsubckt_1536_nand2_x0 1 0 2291 6831 6835 nand2_x0
xsubckt_1522_nand4_x0 1 0 6844 6887 8062 8063 8064 nand4_x0
xsubckt_2731_ao22_x2 0 5626 1 5683 5678 5680 ao22_x2
xsubckt_3104_mx2_x2 0 5259 1 8035 5260 5261 mx2_x2
xsubckt_3106_mx2_x2 0 5257 1 813 1726 1694 mx2_x2
xsubckt_3108_mx2_x2 0 5255 1 788 5256 5257 mx2_x2
xsubckt_3817_nand3_x0 1 0 4558 569 8289 75 nand3_x0
xsubckt_3840_mx2_x2 0 4535 1 8034 4536 4537 mx2_x2
xsubckt_3842_mx2_x2 0 4533 1 812 1233 1201 mx2_x2
xsubckt_3995_nand3_x0 1 0 4383 569 8289 72 nand3_x0
xsubckt_8106_sff1_x4 1 2251 0 10251 1224 sff1_x4
xsubckt_8541_sff1_x4 1 2156 0 9816 138 sff1_x4
xsubckt_8629_sff1_x4 1 2159 0 179 116 sff1_x4
xsubckt_304_inv_x0 1 0 1982 8072 inv_x0
xsubckt_302_inv_x0 1 0 1983 8074 inv_x0
xsubckt_300_inv_x0 1 0 2020 8076 inv_x0
xsubckt_752_nand3_x0 1 0 7590 7591 7592 7593 nand3_x0
xsubckt_3020_nand3_x0 1 0 5341 5342 5515 6392 nand3_x0
xsubckt_3060_mx2_x2 0 5302 1 8035 5303 5304 mx2_x2
xsubckt_3062_mx2_x2 0 5300 1 814 1247 1215 mx2_x2
xsubckt_3064_mx2_x2 0 5298 1 8035 5299 5300 mx2_x2
xsubckt_3641_nand2_x0 1 0 4731 4732 782 nand2_x0
xsubckt_3844_mx2_x2 0 4531 1 8035 4532 4533 mx2_x2
xsubckt_3846_mx2_x2 0 4529 1 813 1361 1329 mx2_x2
xsubckt_3848_mx2_x2 0 4527 1 8035 4528 4529 mx2_x2
xsubckt_7410_mx2_x2 0 9427 1 8494 6053 1551 mx2_x2
xsubckt_7412_mx2_x2 0 9425 1 8494 6035 1549 mx2_x2
xsubckt_7414_mx2_x2 0 9423 1 8494 6018 1546 mx2_x2
xsubckt_7801_mx2_x2 0 9029 1 8434 6213 900 mx2_x2
xsubckt_7805_mx2_x2 0 9025 1 8434 6179 926 mx2_x2
xsubckt_8092_sff1_x4 1 2136 0 10265 1171 sff1_x4
xsubckt_9437_sff1_x4 1 2123 0 9006 1891 sff1_x4
xcmpt_cpuregs_rdreg_0_q_1_hfns_5 1 0 837 831 buf_x4
xcmpt_cpuregs_rdreg_0_q_1_hfns_4 1 0 831 832 buf_x4
xcmpt_cpuregs_rdreg_0_q_1_hfns_3 1 0 831 833 buf_x4
xcmpt_cpuregs_rdreg_0_q_1_hfns_2 1 0 831 834 buf_x4
xcmpt_cpuregs_rdreg_0_q_1_hfns_1 1 0 831 835 buf_x4
xcmpt_cpuregs_rdreg_0_q_1_hfns_0 1 0 831 836 buf_x4
xcmpt_cpuregs_rdreg_0_q_3_hfns_4 1 0 829 824 buf_x4
xcmpt_cpuregs_rdreg_0_q_3_hfns_3 1 0 824 825 buf_x4
xcmpt_cpuregs_rdreg_0_q_3_hfns_2 1 0 824 826 buf_x4
xcmpt_cpuregs_rdreg_0_q_3_hfns_1 1 0 824 827 buf_x4
xcmpt_cpuregs_rdreg_0_q_3_hfns_0 1 0 824 828 buf_x4
xsubckt_2140_mx2_x2 0 10455 1 6441 9400 710 mx2_x2
xsubckt_1400_a4_x2 0 6965 1 6966 7033 7039 7043 a4_x2
xsubckt_308_inv_x0 1 0 224 8068 inv_x0
xsubckt_306_inv_x0 1 0 225 8070 inv_x0
xsubckt_260_inv_x0 1 0 1979 8116 inv_x0
xsubckt_778_nor2_x0 1 0 7565 7566 7572 nor2_x0
xsubckt_783_a2_x2 0 7561 1 765 90 a2_x2
xsubckt_2531_mx2_x2 0 5822 1 815 1164 1068 mx2_x2
xsubckt_2920_mx2_x2 0 5440 1 814 1057 1025 mx2_x2
xsubckt_3066_mx2_x2 0 5296 1 814 1375 1343 mx2_x2
xsubckt_3068_mx2_x2 0 5294 1 8036 5295 5296 mx2_x2
xsubckt_3336_oa22_x2 0 5031 1 5034 5039 7907 oa22_x2
xsubckt_3459_mx2_x2 0 4910 1 814 1048 1016 mx2_x2
xsubckt_3461_nand2_x0 1 0 4908 4909 782 nand2_x0
xsubckt_3637_nand3_x0 1 0 4735 568 8290 78 nand3_x0
xsubckt_7023_mx2_x2 0 9629 1 6440 9397 726 mx2_x2
xsubckt_7025_mx2_x2 0 9628 1 6440 9396 725 mx2_x2
xsubckt_7027_mx2_x2 0 9627 1 6440 9395 724 mx2_x2
xsubckt_7330_nand2_x0 1 0 8515 8516 8518 nand2_x0
xsubckt_7370_mx2_x2 0 9465 1 8500 6107 1589 mx2_x2
xsubckt_7418_mx2_x2 0 9389 1 8490 6277 1378 mx2_x2
xsubckt_7761_mx2_x2 0 9067 1 8439 6265 940 mx2_x2
xsubckt_7807_mx2_x2 0 9023 1 8433 6162 924 mx2_x2
xsubckt_7809_mx2_x2 0 9021 1 8433 6143 922 mx2_x2
xsubckt_8014_sff1_x4 1 2195 0 10343 1124 sff1_x4
xsubckt_8537_sff1_x4 1 2176 0 9820 142 sff1_x4
xsubckt_8972_sff1_x4 1 2109 0 9453 1570 sff1_x4
xsubckt_2278_ao22_x2 0 6110 1 79 6120 6287 ao22_x2
xsubckt_2194_a4_x2 0 6232 1 6256 65 64 63 a4_x2
xsubckt_2144_mx2_x2 0 10453 1 6441 9398 727 mx2_x2
xsubckt_2142_mx2_x2 0 10454 1 6441 9399 709 mx2_x2
xsubckt_2058_nand2_x0 1 0 6387 6388 7854 nand2_x0
xsubckt_1176_nand2_x0 1 0 7188 7990 2016 nand2_x0
xsubckt_266_inv_x0 1 0 247 8110 inv_x0
xsubckt_264_inv_x0 1 0 2004 8112 inv_x0
xsubckt_262_inv_x0 1 0 1978 8114 inv_x0
xsubckt_2533_mx2_x2 0 5820 1 791 5821 5822 mx2_x2
xsubckt_2535_mx2_x2 0 5818 1 775 5819 5826 mx2_x2
xsubckt_2537_mx2_x2 0 5816 1 817 1132 1100 mx2_x2
xsubckt_2880_mx2_x2 0 5479 1 817 1636 1604 mx2_x2
xsubckt_2924_mx2_x2 0 5436 1 817 1185 1089 mx2_x2
xsubckt_2928_mx2_x2 0 5432 1 816 1793 1761 mx2_x2
xsubckt_3272_xr2_x1 5094 0 1 241 760 xr2_x1
xsubckt_3457_nand3_x0 1 0 4912 567 8290 82 nand3_x0
xsubckt_4144_oa22_x2 0 4236 1 4237 4238 8016 oa22_x2
xsubckt_5567_oa22_x2 0 3383 1 2006 3389 2005 oa22_x2
xsubckt_5924_oa22_x2 0 3085 1 3191 3088 3086 oa22_x2
xsubckt_6101_mx2_x2 0 2913 1 8207 2914 2929 mx2_x2
xsubckt_7029_mx2_x2 0 9626 1 6441 9394 723 mx2_x2
xsubckt_7372_mx2_x2 0 9463 1 8499 6089 1587 mx2_x2
xsubckt_7374_mx2_x2 0 9461 1 8499 6071 1585 mx2_x2
xsubckt_7376_mx2_x2 0 9459 1 8500 6053 1583 mx2_x2
xsubckt_7763_mx2_x2 0 9065 1 8438 6252 936 mx2_x2
xsubckt_8088_sff1_x4 1 2222 0 10269 1176 sff1_x4
xsubckt_8445_sff1_x4 1 2044 0 9912 1961 sff1_x4
xsubckt_8968_sff1_x4 1 2111 0 9457 1581 sff1_x4
xsubckt_9345_sff1_x4 1 2106 0 9098 969 sff1_x4
xsubckt_2355_nor2_x0 1 0 6005 624 625 nor2_x0
xsubckt_2307_nand3_x0 1 0 6073 6074 6076 6290 nand3_x0
xsubckt_2242_a3_x2 1 6156 0 6174 86 85 a3_x2
xsubckt_1483_nxr2_x1 6880 1 0 6882 223 nxr2_x1
xsubckt_268_inv_x0 1 0 2002 8108 inv_x0
xsubckt_835_nand2_x0 1 0 7511 2001 637 nand2_x0
xsubckt_1013_oa22_x2 0 7342 1 7343 7347 7793 oa22_x2
xsubckt_1086_nand2_x0 1 0 7273 1987 637 nand2_x0
xsubckt_2491_mx2_x2 0 5861 1 818 1495 1463 mx2_x2
xsubckt_2493_mx2_x2 0 5859 1 8029 5860 5861 mx2_x2
xsubckt_2539_mx2_x2 0 5814 1 818 1292 1260 mx2_x2
xsubckt_2882_mx2_x2 0 5477 1 8029 5478 5479 mx2_x2
xsubckt_2884_mx2_x2 0 5475 1 818 1220 1188 mx2_x2
xsubckt_2886_mx2_x2 0 5473 1 8029 5474 5475 mx2_x2
xsubckt_3024_a2_x2 0 5337 1 5338 5343 a2_x2
xsubckt_3281_nand2_x0 1 0 5085 5086 780 nand2_x0
xsubckt_4073_nand2_x0 1 0 4306 4307 780 nand2_x0
xsubckt_4766_nand4_x0 1 0 4047 4049 4054 4065 4142 nand4_x0
xsubckt_5436_nxr2_x1 3472 1 0 3862 729 nxr2_x1
xsubckt_5472_nand3_x0 1 0 3448 3453 2038 2039 nand3_x0
xsubckt_5998_oa22_x2 0 3014 1 49 1905 214 oa22_x2
xsubckt_6107_mx2_x2 0 2908 1 849 926 894 mx2_x2
xsubckt_6450_mx2_x2 0 2574 1 849 1140 1108 mx2_x2
xsubckt_7236_nand3_x0 1 0 8589 8590 8604 8609 nand3_x0
xsubckt_7378_mx2_x2 0 9457 1 8500 6035 1581 mx2_x2
xsubckt_7980_sff1_x4 1 2172 0 10377 1766 sff1_x4
xsubckt_8802_sff1_x4 1 2089 0 9620 732 sff1_x4
xsubckt_8880_sff1_x4 1 2050 0 9545 356 sff1_x4
xcmpt_abc_30082_new_n5513_hfns_2 1 0 6180 6177 buf_x4
xcmpt_abc_30082_new_n5513_hfns_1 1 0 6177 6178 buf_x4
xcmpt_abc_30082_new_n5513_hfns_0 1 0 6177 6179 buf_x4
xsubckt_1956_nand2_x0 1 0 449 6457 6481 nand2_x0
xsubckt_1896_inv_x0 1 0 6496 434 inv_x0
xsubckt_745_nand2_x0 1 0 7597 7598 7601 nand2_x0
xsubckt_2888_mx2_x2 0 5471 1 818 1348 1316 mx2_x2
xsubckt_3277_nand3_x0 1 0 5089 567 8290 85 nand3_x0
xsubckt_4227_a2_x2 0 4212 1 556 8008 a2_x2
xsubckt_4648_a3_x2 1 9935 0 4136 4137 52 a3_x2
xsubckt_5605_a2_x2 0 9757 1 3357 52 a2_x2
xsubckt_6061_mx2_x2 0 2952 1 853 1440 1408 mx2_x2
xsubckt_6063_mx2_x2 0 2950 1 8211 2951 2954 mx2_x2
xsubckt_6065_mx2_x2 0 2948 1 8207 2949 2964 mx2_x2
xsubckt_6109_mx2_x2 0 2906 1 8226 2907 2908 mx2_x2
xsubckt_6452_mx2_x2 0 2572 1 8211 2573 2576 mx2_x2
xsubckt_6454_mx2_x2 0 2570 1 853 1588 1556 mx2_x2
xsubckt_6456_mx2_x2 0 2568 1 853 1492 1460 mx2_x2
xsubckt_6867_a4_x2 0 8805 1 8806 8245 701 577 a4_x2
xsubckt_6931_ao22_x2 0 8761 1 706 8279 616 ao22_x2
xsubckt_7183_oa22_x2 0 8627 1 52 8300 8143 oa22_x2
xsubckt_8353_sff1_x4 1 2136 0 10004 1326 sff1_x4
xsubckt_8876_sff1_x4 1 2070 0 9549 360 sff1_x4
xsubckt_9253_sff1_x4 1 2198 0 9187 1440 sff1_x4
xcmpt_abc_30082_new_n5471_hfns_2 1 0 6253 6250 buf_x4
xcmpt_abc_30082_new_n5471_hfns_1 1 0 6250 6251 buf_x4
xcmpt_abc_30082_new_n5471_hfns_0 1 0 6250 6252 buf_x4
xsubckt_1930_a2_x2 0 6469 1 6470 6471 a2_x2
xsubckt_1910_a2_x2 0 6485 1 6486 6487 a2_x2
xsubckt_1444_oa22_x2 0 6917 1 6928 6920 6921 oa22_x2
xsubckt_565_nand2_x0 1 0 7772 2014 637 nand2_x0
xsubckt_3097_nand3_x0 1 0 5266 567 8290 88 nand3_x0
xsubckt_3675_oa22_x2 0 4697 1 4698 4699 8016 oa22_x2
xsubckt_4716_a2_x2 0 4085 1 1969 1968 a2_x2
xsubckt_4863_a3_x2 1 3974 0 3978 1928 1927 a3_x2
xsubckt_5383_oa22_x2 0 3521 1 3523 3525 8295 oa22_x2
xsubckt_5597_a3_x2 1 3362 0 3367 1995 1997 a3_x2
xsubckt_5735_nand2_x0 1 0 3267 3268 3269 nand2_x0
xsubckt_5921_mx2_x2 0 3088 1 8206 3089 3104 mx2_x2
xsubckt_6458_mx2_x2 0 2566 1 8224 2567 2568 mx2_x2
xsubckt_7483_a2_x2 0 8482 1 4182 4219 a2_x2
xsubckt_7976_sff1_x4 1 2096 0 10381 1772 sff1_x4
xsubckt_8710_sff1_x4 1 2123 0 9680 194 sff1_x4
xsubckt_9249_sff1_x4 1 2193 0 9191 1414 sff1_x4
xcmpt_abc_30082_new_n5479_hfns_2 1 0 6241 6238 buf_x4
xcmpt_abc_30082_new_n5479_hfns_1 1 0 6238 6239 buf_x4
xcmpt_abc_30082_new_n5479_hfns_0 1 0 6238 6240 buf_x4
xsubckt_2252_oa22_x2 0 6144 1 6145 6146 6148 oa22_x2
xsubckt_1313_nxr2_x1 7052 1 0 441 222 nxr2_x1
xsubckt_4142_nand3_x0 1 0 4238 4258 4262 8011 nand3_x0
xsubckt_4756_a2_x2 0 9908 1 4055 42 a2_x2
xsubckt_4801_nxr2_x1 4020 1 0 4022 8337 nxr2_x1
xsubckt_4849_nand3_x0 1 0 3984 3986 3991 4142 nand3_x0
xsubckt_5141_mx2_x2 0 3746 1 8276 3747 3925 mx2_x2
xsubckt_5645_nand2_x0 1 0 3328 3329 3330 nand2_x0
xsubckt_5740_oa22_x2 0 9713 1 6437 3278 3263 oa22_x2
xsubckt_5881_mx2_x2 0 3127 1 857 1415 1383 mx2_x2
xsubckt_5927_mx2_x2 0 3083 1 850 901 869 mx2_x2
xsubckt_5929_mx2_x2 0 3081 1 8224 3082 3083 mx2_x2
xsubckt_6848_a2_x2 0 9668 1 8821 50 a2_x2
xsubckt_7229_nand2_x0 1 0 8594 7976 380 nand2_x0
xsubckt_8261_sff1_x4 1 2103 0 10096 1315 sff1_x4
xsubckt_8349_sff1_x4 1 2145 0 10008 1330 sff1_x4
xsubckt_8784_sff1_x4 1 2070 0 9638 642 sff1_x4
xsubckt_9161_sff1_x4 1 2206 0 9279 1404 sff1_x4
xsubckt_1234_o2_x2 0 7131 1 203 235 o2_x2
xsubckt_1214_o2_x2 0 7151 1 200 232 o2_x2
xsubckt_362_nor4_x0 1 0 7986 652 649 646 643 nor4_x0
xsubckt_1039_o2_x2 0 7318 1 7319 7321 o2_x2
xsubckt_4221_mx2_x2 0 10326 1 4215 6062 1136 mx2_x2
xsubckt_4612_mx2_x2 0 9967 1 4146 6278 1634 mx2_x2
xsubckt_5124_o2_x2 0 3762 1 3763 3765 o2_x2
xsubckt_5379_oa22_x2 0 3525 1 3547 3537 3526 oa22_x2
xsubckt_5883_mx2_x2 0 3125 1 8213 3126 3129 mx2_x2
xsubckt_5885_mx2_x2 0 3123 1 8207 3124 3139 mx2_x2
xsubckt_6390_ao22_x2 0 2632 1 574 569 755 ao22_x2
xsubckt_8706_sff1_x4 1 2092 0 9684 198 sff1_x4
xsubckt_9157_sff1_x4 1 2195 0 9283 1408 sff1_x4
xsubckt_2298_nand2_x0 1 0 6084 6093 76 nand2_x0
xsubckt_2727_nand3_x0 1 0 5629 5630 5631 7856 nand3_x0
xsubckt_4223_mx2_x2 0 10324 1 4214 6043 1134 mx2_x2
xsubckt_4225_mx2_x2 0 10322 1 4214 6026 1131 mx2_x2
xsubckt_4614_mx2_x2 0 9965 1 4147 6265 1612 mx2_x2
xsubckt_4616_mx2_x2 0 9963 1 4147 6252 1608 mx2_x2
xsubckt_5160_nxr2_x1 3729 1 0 3742 3919 nxr2_x1
xsubckt_7286_ao22_x2 0 8551 1 662 644 395 ao22_x2
xsubckt_8257_sff1_x4 1 2108 0 10100 1678 sff1_x4
xsubckt_8692_sff1_x4 1 2172 0 9698 212 sff1_x4
xcmpt_abc_30082_new_n3631_hfns_3 1 0 8014 8010 buf_x4
xcmpt_abc_30082_new_n3631_hfns_2 1 0 8010 8011 buf_x4
xcmpt_abc_30082_new_n3631_hfns_1 1 0 8010 8012 buf_x4
xcmpt_abc_30082_new_n3631_hfns_0 1 0 8010 8013 buf_x4
xsubckt_1676_nor3_x0 1 0 6700 6701 6712 6715 nor3_x0
xsubckt_1588_o2_x2 0 6782 1 6783 6788 o2_x2
xsubckt_1098_ao22_x2 0 7262 1 7264 7267 1902 ao22_x2
xsubckt_1148_nand2_x0 1 0 7214 7215 7223 nand2_x0
xsubckt_3697_nand3_x0 1 0 4676 568 8290 77 nand3_x0
xsubckt_3936_oa22_x2 0 4441 1 4444 4449 7907 oa22_x2
xsubckt_4181_mx2_x2 0 10360 1 4224 6080 1778 mx2_x2
xsubckt_4183_mx2_x2 0 10358 1 4224 6062 1776 mx2_x2
xsubckt_4570_mx2_x2 0 10005 1 4157 6054 1327 mx2_x2
xsubckt_4572_mx2_x2 0 10003 1 4157 6035 1325 mx2_x2
xsubckt_4574_mx2_x2 0 10001 1 4157 6017 1322 mx2_x2
xsubckt_4705_nxr2_x1 4093 1 0 4096 8316 nxr2_x1
xsubckt_8614_sff1_x4 1 2089 0 186 123 sff1_x4
xsubckt_8688_sff1_x4 1 2172 0 9702 192 sff1_x4
xsubckt_9065_sff1_x4 1 2138 0 9365 1361 sff1_x4
xcmpt_latched_store_hfns_2 1 0 542 539 buf_x4
xcmpt_latched_store_hfns_1 1 0 539 540 buf_x4
xcmpt_latched_store_hfns_0 1 0 539 541 buf_x4
xsubckt_364_nand3_x0 1 0 7984 7986 7988 7990 nand3_x0
xsubckt_807_nand2_x0 1 0 7538 7707 327 nand2_x0
xsubckt_2800_nand3_x0 1 0 5558 567 8290 63 nand3_x0
xsubckt_3303_mx2_x2 0 5063 1 794 1147 1115 mx2_x2
xsubckt_3307_mx2_x2 0 5059 1 794 1307 1275 mx2_x2
xsubckt_3650_mx2_x2 0 4722 1 794 916 884 mx2_x2
xsubckt_4045_nand2_x0 1 0 4334 5994 227 nand2_x0
xsubckt_4185_mx2_x2 0 10356 1 4224 6044 1774 mx2_x2
xsubckt_4187_mx2_x2 0 10354 1 4224 6027 1771 mx2_x2
xsubckt_4578_mx2_x2 0 9999 1 4152 6278 1506 mx2_x2
xsubckt_5121_oa22_x2 0 3765 1 3779 3777 3778 oa22_x2
xsubckt_5591_nxr2_x1 3366 1 0 3370 8100 nxr2_x1
xsubckt_8165_sff1_x4 1 2097 0 10192 1731 sff1_x4
xsubckt_8522_sff1_x4 1 2159 0 9835 128 sff1_x4
xsubckt_9422_sff1_x4 1 2224 0 9021 922 sff1_x4
xcmpt_abc_30082_new_n7552_hfns_2 1 0 4205 4202 buf_x4
xcmpt_abc_30082_new_n7552_hfns_1 1 0 4202 4203 buf_x4
xcmpt_abc_30082_new_n7552_hfns_0 1 0 4202 4204 buf_x4
xsubckt_1560_nxr2_x1 6808 1 0 6811 191 nxr2_x1
xsubckt_520_ao22_x2 0 7818 1 7859 7862 1898 ao22_x2
xsubckt_426_a2_x2 0 7915 1 7921 7996 a2_x2
xsubckt_110_inv_x0 1 0 2276 8301 inv_x0
xsubckt_112_inv_x0 1 0 630 8299 inv_x0
xsubckt_661_a2_x2 0 7680 1 7681 1895 a2_x2
xsubckt_895_nand2_x0 1 0 7454 630 1934 nand2_x0
xsubckt_3652_mx2_x2 0 4720 1 8032 4721 4722 mx2_x2
xsubckt_3654_mx2_x2 0 4718 1 793 1492 1460 mx2_x2
xsubckt_3656_mx2_x2 0 4716 1 8032 4717 4718 mx2_x2
xsubckt_5354_nand3_x0 1 0 3548 3549 3553 3556 nand3_x0
xsubckt_5444_nand3_x0 1 0 3467 2029 2040 2041 nand3_x0
xsubckt_5513_nxr2_x1 3420 1 0 3424 8085 nxr2_x1
xsubckt_7611_mx2_x2 0 9206 1 8465 6081 1074 mx2_x2
xsubckt_7613_mx2_x2 0 9204 1 8464 6062 1072 mx2_x2
xsubckt_8596_sff1_x4 1 2047 0 9761 1998 sff1_x4
xsubckt_9418_sff1_x4 1 2225 0 9025 926 sff1_x4
xsubckt_9496_sff1_x4 1 2129 0 8947 1839 sff1_x4
xsubckt_2013_nand2_x0 1 0 6434 7907 1902 nand2_x0
xsubckt_1928_nand2_x0 1 0 6471 211 327 nand2_x0
xsubckt_1838_nand2_x0 1 0 6549 6943 7166 nand2_x0
xsubckt_114_inv_x0 1 0 649 8297 inv_x0
xsubckt_116_inv_x0 1 0 644 8291 inv_x0
xsubckt_537_nand2_x0 1 0 7802 8285 216 nand2_x0
xsubckt_1164_oa22_x2 0 7199 1 7200 7204 7793 oa22_x2
xsubckt_2730_mx2_x2 0 10409 1 5995 5627 221 mx2_x2
xsubckt_3658_mx2_x2 0 4714 1 799 1652 1620 mx2_x2
xsubckt_4811_nand4_x0 1 0 4012 4016 4028 4142 1942 nand4_x0
xsubckt_6883_oa22_x2 0 9661 1 8823 8798 8796 oa22_x2
xsubckt_7222_mx2_x2 0 9515 1 8832 8599 746 mx2_x2
xsubckt_7357_mx3_x2 1 0 9478 8502 6291 1573 6226 6230 mx3_x2
xsubckt_7359_mx3_x2 1 0 9476 8502 6291 1601 6206 6210 mx3_x2
xsubckt_7615_mx2_x2 0 9202 1 8465 6044 1070 mx2_x2
xsubckt_7617_mx2_x2 0 9200 1 8465 6027 1067 mx2_x2
xsubckt_8073_sff1_x4 1 2098 0 10284 1161 sff1_x4
xsubckt_8430_sff1_x4 1 2057 0 9927 1915 sff1_x4
xsubckt_8518_sff1_x4 1 2153 0 9839 144 sff1_x4
xsubckt_8953_sff1_x4 1 2238 0 9472 1597 sff1_x4
xsubckt_9330_sff1_x4 1 2145 0 9110 1010 sff1_x4
xsubckt_2343_mx2_x2 0 10417 1 6300 6027 1803 mx2_x2
xsubckt_1612_a4_x2 0 6760 1 6802 8056 8057 8058 a4_x2
xsubckt_118_inv_x0 1 0 216 8286 inv_x0
xsubckt_995_a2_x2 0 7359 1 7360 7366 a2_x2
xsubckt_3317_oa22_x2 0 5049 1 5050 5089 5958 oa22_x2
xsubckt_5495_nxr2_x1 3432 1 0 3435 2031 nxr2_x1
xsubckt_5522_a4_x2 0 3414 1 3421 2021 2022 2023 a4_x2
xsubckt_5548_oa22_x2 0 3396 1 2013 3401 2012 oa22_x2
xsubckt_6300_mx2_x2 0 2720 1 8211 2721 2724 mx2_x2
xsubckt_6302_mx2_x2 0 2718 1 853 1369 1337 mx2_x2
xsubckt_7228_mx2_x2 0 9513 1 8832 8595 748 mx2_x2
xsubckt_7571_mx2_x2 0 9244 1 8470 6134 1209 mx2_x2
xsubckt_7573_mx2_x2 0 9242 1 8469 6115 1206 mx2_x2
xsubckt_7575_mx2_x2 0 9240 1 8469 6098 1204 mx2_x2
xsubckt_8069_sff1_x4 1 2123 0 10288 1187 sff1_x4
xsubckt_9326_sff1_x4 1 2216 0 9114 1014 sff1_x4
xsubckt_1911_nand2_x0 1 0 6484 7810 191 nand2_x0
xsubckt_610_nand2_x0 1 0 7729 7730 7798 nand2_x0
xsubckt_2692_mx2_x2 0 5664 1 797 1767 1735 mx2_x2
xsubckt_4506_a3_x2 1 4165 0 8004 552 8006 a3_x2
xsubckt_5298_ao22_x2 0 3600 1 3601 3607 701 ao22_x2
xsubckt_6304_mx2_x2 0 2716 1 8220 2717 2718 mx2_x2
xsubckt_6306_mx2_x2 0 2714 1 860 1145 1113 mx2_x2
xsubckt_6308_mx2_x2 0 2712 1 8211 2713 2716 mx2_x2
xsubckt_6356_oa22_x2 0 2665 1 3191 2668 2666 oa22_x2
xsubckt_6651_mx2_x2 0 2379 1 860 1774 1742 mx2_x2
xsubckt_7175_nor2_x0 1 0 8633 6496 7993 nor2_x0
xsubckt_7289_nand2_x0 1 0 8548 8549 8577 nand2_x0
xsubckt_7577_mx2_x2 0 9238 1 8470 6080 1202 mx2_x2
xsubckt_7579_mx2_x2 0 9236 1 8470 6062 1200 mx2_x2
xsubckt_7654_a4_x2 0 8456 1 6306 6310 6312 551 a4_x2
xsubckt_8426_sff1_x4 1 2060 0 9931 1943 sff1_x4
xsubckt_8861_sff1_x4 1 2079 0 9564 576 sff1_x4
xsubckt_8949_sff1_x4 1 2235 0 9476 1601 sff1_x4
xsubckt_6264_mx2_x2 0 2755 1 8210 2756 2759 mx2_x2
xsubckt_6653_mx2_x2 0 2377 1 8210 2378 2381 mx2_x2
xsubckt_6655_mx2_x2 0 2375 1 859 1166 1070 mx2_x2
xsubckt_6980_a4_x2 0 8724 1 8725 8768 8244 700 a4_x2
xsubckt_7961_sff1_x4 1 2166 0 10396 238 sff1_x4
xsubckt_9234_sff1_x4 1 2145 0 9206 1074 sff1_x4
xsubckt_6262_mx2_x2 0 2757 1 859 1050 1018 mx2_x2
xsubckt_6260_mx2_x2 0 2759 1 8220 2760 2761 mx2_x2
xsubckt_5650_a3_x2 1 3323 0 567 8289 68 a3_x2
xsubckt_5455_a3_x2 1 9804 0 3460 3461 54 a3_x2
xsubckt_2696_mx2_x2 0 5660 1 821 1831 1799 mx2_x2
xsubckt_2613_nand2_x0 1 0 5741 6011 8134 nand2_x0
xsubckt_963_o2_x2 0 7390 1 7391 7393 o2_x2
xsubckt_1760_a3_x2 1 6621 0 6622 6623 6624 a3_x2
xsubckt_1821_nand2_x0 1 0 2301 6565 6569 nand2_x0
xsubckt_2053_a2_x2 0 6395 1 6396 6427 a2_x2
xsubckt_2325_oa22_x2 0 6049 1 6066 73 72 oa22_x2
xsubckt_8857_sff1_x4 1 2138 0 9568 1515 sff1_x4
xsubckt_8334_sff1_x4 1 2235 0 10023 1316 sff1_x4
xsubckt_7957_sff1_x4 1 2166 0 10400 242 sff1_x4
xsubckt_7903_buf_x1 1 0 1867 8976 buf_x1
xsubckt_7901_buf_x1 1 0 1870 8978 buf_x1
xsubckt_7381_a2_x2 0 8497 1 4165 4182 a2_x2
xsubckt_6893_a3_x2 1 8789 0 8245 564 703 a3_x2
xsubckt_6659_mx2_x2 0 2371 1 834 2372 2373 mx2_x2
xsubckt_6657_mx2_x2 0 2373 1 858 974 942 mx2_x2
xsubckt_6268_mx2_x2 0 2751 1 8221 2752 2753 mx2_x2
xsubckt_6266_mx2_x2 0 2753 1 858 1370 1338 mx2_x2
xsubckt_5583_a2_x2 0 3372 1 3375 2000 a2_x2
xsubckt_5543_a2_x2 0 9776 1 3400 47 a2_x2
xsubckt_4913_oa22_x2 0 9867 1 7886 3939 3941 oa22_x2
xsubckt_4654_a2_x2 0 9933 1 4132 47 a2_x2
xsubckt_4033_oa22_x2 0 4345 1 4346 4347 8017 oa22_x2
xsubckt_3451_a2_x2 0 4918 1 238 757 a2_x2
xsubckt_3405_nand2_x0 1 0 4963 4964 8025 nand2_x0
xsubckt_1396_nor3_x0 1 0 6969 6971 7003 7178 nor3_x0
xsubckt_1438_a2_x2 0 6922 1 6923 6924 a2_x2
xsubckt_2354_o4_x2 0 6009 1 616 618 617 619 o4_x2
xsubckt_9142_sff1_x4 1 2142 0 9298 1102 sff1_x4
xsubckt_8765_sff1_x4 1 2053 0 9657 627 sff1_x4
xsubckt_5420_nand2_x0 1 0 3487 3488 8294 nand2_x0
xsubckt_5077_nand2_x0 1 0 3806 3807 8294 nand2_x0
xsubckt_4860_nxr2_x1 3976 1 0 3978 8349 nxr2_x1
xsubckt_4204_mx3_x2 1 0 10343 4217 6294 1124 6215 6219 mx3_x2
xsubckt_4202_mx3_x2 1 0 10345 4217 6294 1126 6236 6240 mx3_x2
xsubckt_3225_nand2_x0 1 0 5140 5141 8025 nand2_x0
xsubckt_1478_a2_x2 0 6885 1 6886 8415 a2_x2
xsubckt_1551_nand2_x0 1 0 6817 6947 7068 nand2_x0
xsubckt_1673_a2_x2 0 6703 1 6704 240 a2_x2
xcmpt_abc_30082_new_n4018_hfns_2 1 0 7615 7612 buf_x4
xcmpt_abc_30082_new_n4018_hfns_1 1 0 7612 7613 buf_x4
xcmpt_abc_30082_new_n4018_hfns_0 1 0 7612 7614 buf_x4
xsubckt_9138_sff1_x4 1 2145 0 9302 1106 sff1_x4
xsubckt_8242_sff1_x4 1 2225 0 10115 1694 sff1_x4
xsubckt_7271_ao22_x2 0 8563 1 662 644 392 ao22_x2
xsubckt_5739_mx2_x2 0 3263 1 3271 3264 504 mx2_x2
xsubckt_5693_mx2_x2 0 9742 1 3282 475 512 mx2_x2
xsubckt_5691_mx2_x2 0 9744 1 3282 489 526 mx2_x2
xsubckt_4909_oa22_x2 0 9868 1 7885 3942 3944 oa22_x2
xsubckt_4553_mx3_x2 1 0 10022 4159 6294 1345 6205 6210 mx3_x2
xsubckt_4551_mx3_x2 1 0 10024 4159 6294 1317 6225 6230 mx3_x2
xsubckt_4420_mx2_x2 0 10145 1 4179 6161 1276 mx2_x2
xsubckt_4206_mx3_x2 1 0 10341 4217 6294 1152 6197 6201 mx3_x2
xsubckt_3564_oa22_x2 0 4806 1 4807 4854 5993 oa22_x2
xsubckt_3045_nand2_x0 1 0 5317 5318 8024 nand2_x0
xsubckt_1132_o2_x2 0 7230 1 746 71 o2_x2
xsubckt_921_oa22_x2 0 178 1 7443 7442 7430 oa22_x2
xsubckt_867_nand2_x0 1 0 7481 7639 328 nand2_x0
xsubckt_30_inv_x0 1 0 147 8381 inv_x0
xsubckt_32_inv_x0 1 0 149 8379 inv_x0
xsubckt_1967_a2_x2 0 6451 1 541 559 a2_x2
xsubckt_9050_sff1_x4 1 2198 0 9380 1377 sff1_x4
xsubckt_8673_sff1_x4 1 2182 0 9716 514 sff1_x4
xsubckt_8238_sff1_x4 1 2189 0 10119 1668 sff1_x4
xsubckt_5994_ao22_x2 0 3017 1 574 567 737 ao22_x2
xsubckt_5699_mx2_x2 0 9736 1 3283 499 536 mx2_x2
xsubckt_5697_mx2_x2 0 9738 1 3283 471 508 mx2_x2
xsubckt_5695_mx2_x2 0 9740 1 3283 473 510 mx2_x2
xsubckt_4426_mx2_x2 0 10139 1 4179 6108 1269 mx2_x2
xsubckt_4424_mx2_x2 0 10141 1 4178 6125 1272 mx2_x2
xsubckt_4422_mx2_x2 0 10143 1 4179 6142 1274 mx2_x2
xsubckt_4166_mx3_x2 1 0 10375 4226 6295 1764 6215 6219 mx3_x2
xsubckt_4164_mx3_x2 1 0 10377 4226 6295 1766 6236 6240 mx3_x2
xsubckt_1103_nand2_x0 1 0 7257 7990 2021 nand2_x0
xsubckt_687_nand2_x0 1 0 7655 221 1899 nand2_x0
xsubckt_34_inv_x0 1 0 151 8377 inv_x0
xsubckt_36_inv_x0 1 0 153 8375 inv_x0
xsubckt_38_inv_x0 1 0 125 8373 inv_x0
xsubckt_509_nand2_x0 1 0 7828 7888 328 nand2_x0
xsubckt_1367_nand3_x0 1 0 6998 7119 206 8095 nand3_x0
xsubckt_1426_o2_x2 0 2320 1 6934 6951 o2_x2
xsubckt_2148_nor2_x0 1 0 6310 552 553 nor2_x0
xsubckt_2176_nxr2_x1 6261 1 0 6270 8358 nxr2_x1
xcmpt_abc_30082_new_n3834_hfns_2 1 0 7794 7791 buf_x4
xcmpt_abc_30082_new_n3834_hfns_1 1 0 7791 7792 buf_x4
xcmpt_abc_30082_new_n3834_hfns_0 1 0 7791 7793 buf_x4
xsubckt_9046_sff1_x4 1 2217 0 9384 1351 sff1_x4
xsubckt_8150_sff1_x4 1 2245 0 10207 1466 sff1_x4
xsubckt_4885_nand2_x0 1 0 3959 3960 8354 nand2_x0
xsubckt_4428_mx2_x2 0 10137 1 4179 6088 1267 mx2_x2
xsubckt_4382_mx2_x2 0 10179 1 4186 6178 1726 mx2_x2
xsubckt_4168_mx3_x2 1 0 10373 4226 6295 1792 6196 6200 mx3_x2
xsubckt_2505_nor2_x0 1 0 5847 237 756 nor2_x0
xsubckt_940_nand2_x0 1 0 177 7412 7424 nand2_x0
xsubckt_1898_nand2_x0 1 0 6494 7804 7807 nand2_x0
xsubckt_9481_sff1_x4 1 2222 0 8962 1855 sff1_x4
xsubckt_9403_sff1_x4 1 2136 0 9040 939 sff1_x4
xsubckt_8669_sff1_x4 1 2182 0 9720 519 sff1_x4
xsubckt_8581_sff1_x4 1 2057 0 9776 2014 sff1_x4
xsubckt_8146_sff1_x4 1 2245 0 10211 1470 sff1_x4
xsubckt_5137_nxr2_x1 3750 1 0 3925 736 nxr2_x1
xsubckt_4388_mx2_x2 0 10173 1 4186 6125 1720 mx2_x2
xsubckt_4386_mx2_x2 0 10175 1 4186 6143 1722 mx2_x2
xsubckt_4384_mx2_x2 0 10177 1 4186 6161 1724 mx2_x2
xsubckt_3825_nand2_x0 1 0 4550 4551 8022 nand2_x0
xsubckt_3115_mx2_x2 0 5248 1 806 1438 1406 mx2_x2
xsubckt_3111_mx2_x2 0 5252 1 806 1854 1822 mx2_x2
xsubckt_846_nand3_x0 1 0 7501 7502 7503 1902 nand3_x0
xsubckt_387_nor2_x0 1 0 7958 612 617 nor2_x0
xsubckt_491_a3_x2 1 7844 0 7886 702 8294 a3_x2
xsubckt_1633_nxr2_x1 6740 1 0 6741 8060 nxr2_x1
xsubckt_9477_sff1_x4 1 2172 0 8966 1829 sff1_x4
xsubckt_8503_sff1_x4 1 2156 0 9854 83 sff1_x4
xsubckt_7812_mx2_x2 0 9018 1 8434 6115 918 mx2_x2
xsubckt_7810_mx2_x2 0 9020 1 8434 6134 921 mx2_x2
xsubckt_7421_mx2_x2 0 9386 1 8490 6259 1353 mx2_x2
xsubckt_7252_nor2_x0 1 0 8578 8579 8580 nor2_x0
xsubckt_6801_nor2_x0 1 0 8856 1912 1902 nor2_x0
xsubckt_5375_ao22_x2 0 3529 1 3540 3873 8294 ao22_x2
xsubckt_5319_nand2_x0 1 0 3581 3885 730 nand2_x0
xsubckt_5176_oa22_x2 0 3714 1 3918 3742 3915 oa22_x2
xsubckt_4691_nand4_x0 1 0 4104 4107 4117 4142 1973 nand4_x0
xsubckt_3645_nand2_x0 1 0 4727 4728 8021 nand2_x0
xsubckt_3464_mx2_x2 0 4905 1 8028 4906 4907 mx2_x2
xsubckt_3462_mx2_x2 0 4907 1 805 1880 1528 mx2_x2
xsubckt_3460_mx2_x2 0 4909 1 787 4910 4911 mx2_x2
xsubckt_3144_ao22_x2 0 5219 1 5268 5267 5220 ao22_x2
xsubckt_3119_mx2_x2 0 5244 1 805 1598 1566 mx2_x2
xsubckt_2853_nand2_x0 1 0 5506 218 737 nand2_x0
xsubckt_2568_oa22_x2 0 5785 1 5960 5801 5786 oa22_x2
xsubckt_899_oa22_x2 0 7450 1 7451 7455 7793 oa22_x2
xsubckt_311_inv_x0 1 0 439 8065 inv_x0
xsubckt_501_ao22_x2 0 7835 1 7962 7984 571 ao22_x2
xsubckt_9311_sff1_x4 1 2242 0 9129 1000 sff1_x4
xsubckt_8577_sff1_x4 1 2050 0 9780 2019 sff1_x4
xsubckt_8054_sff1_x4 1 2222 0 10303 1754 sff1_x4
xsubckt_7818_mx2_x2 0 9012 1 8434 6062 912 mx2_x2
xsubckt_7816_mx2_x2 0 9014 1 8434 6080 914 mx2_x2
xsubckt_7814_mx2_x2 0 9016 1 8434 6098 916 mx2_x2
xsubckt_7423_mx2_x2 0 9384 1 8490 6245 1351 mx2_x2
xsubckt_7034_mx2_x2 0 9623 1 6440 9410 735 mx2_x2
xsubckt_7032_mx2_x2 0 9392 1 7917 407 375 mx2_x2
xsubckt_7030_mx2_x2 0 9393 1 7917 409 377 mx2_x2
xsubckt_5732_ao22_x2 0 3270 1 7839 8270 8402 ao22_x2
xsubckt_3468_mx2_x2 0 4901 1 788 4902 4903 mx2_x2
xsubckt_3466_mx2_x2 0 4903 1 804 1720 1688 mx2_x2
xsubckt_3465_nand2_x0 1 0 4904 4905 8021 nand2_x0
xsubckt_638_a2_x2 0 7702 1 7703 1895 a2_x2
xsubckt_313_inv_x0 1 0 441 8063 inv_x0
xsubckt_315_inv_x0 1 0 209 8061 inv_x0
xsubckt_317_inv_x0 1 0 211 8059 inv_x0
xsubckt_1881_nand2_x0 1 0 6508 6943 7175 nand2_x0
xsubckt_9385_sff1_x4 1 2242 0 9058 959 sff1_x4
xsubckt_8934_sff1_x4 1 2089 0 9491 741 sff1_x4
xsubckt_8411_sff1_x4 1 2238 0 9946 1620 sff1_x4
xsubckt_7774_mx2_x2 0 9054 1 8439 6151 955 mx2_x2
xsubckt_7772_mx2_x2 0 9056 1 8439 6169 957 mx2_x2
xsubckt_7770_mx2_x2 0 9058 1 8439 6189 959 mx2_x2
xsubckt_7429_mx2_x2 0 9378 1 8489 6189 1375 mx2_x2
xsubckt_7383_mx2_x2 0 9454 1 8495 6282 1571 mx2_x2
xsubckt_7244_nand2_x0 1 0 8584 7976 385 nand2_x0
xsubckt_7038_mx2_x2 0 9619 1 6441 9391 730 mx2_x2
xsubckt_7036_mx2_x2 0 9621 1 6441 9408 733 mx2_x2
xsubckt_5084_oa22_x2 0 3799 1 3800 3806 8277 oa22_x2
xsubckt_4864_nand3_x0 1 0 3973 3978 1928 1927 nand3_x0
xsubckt_4668_nxr2_x1 4121 1 0 4123 8311 nxr2_x1
xsubckt_2935_mx2_x2 0 5425 1 803 1505 1473 mx2_x2
xsubckt_2933_mx2_x2 0 5427 1 8031 5428 5429 mx2_x2
xsubckt_2931_mx2_x2 0 5429 1 803 929 897 mx2_x2
xsubckt_2544_mx2_x2 0 5809 1 803 1644 1612 mx2_x2
xsubckt_2542_mx2_x2 0 5811 1 782 5812 5815 mx2_x2
xsubckt_2540_mx2_x2 0 5813 1 803 1356 1324 mx2_x2
xsubckt_929_nand2_x0 1 0 7422 7423 1895 nand2_x0
xsubckt_271_inv_x0 1 0 244 8105 inv_x0
xsubckt_273_inv_x0 1 0 2035 8103 inv_x0
xsubckt_319_inv_x0 1 0 213 8057 inv_x0
xsubckt_9307_sff1_x4 1 2136 0 9133 1026 sff1_x4
xsubckt_8842_sff1_x4 1 2212 0 9583 1532 sff1_x4
xsubckt_8485_sff1_x4 1 2050 0 9872 1917 sff1_x4
xsubckt_8407_sff1_x4 1 2232 0 9950 1625 sff1_x4
xsubckt_7778_mx2_x2 0 9050 1 8439 6116 950 mx2_x2
xsubckt_7776_mx2_x2 0 9052 1 8438 6135 953 mx2_x2
xsubckt_7389_mx2_x2 0 9448 1 8494 6244 1543 mx2_x2
xsubckt_7387_mx2_x2 0 9450 1 8495 6259 1545 mx2_x2
xsubckt_7385_mx2_x2 0 9452 1 8494 6273 1559 mx2_x2
xsubckt_6507_mx2_x2 0 2519 1 838 1778 1746 mx2_x2
xsubckt_6505_mx2_x2 0 2521 1 8225 2522 2523 mx2_x2
xsubckt_6503_mx2_x2 0 2523 1 838 914 882 mx2_x2
xsubckt_6114_mx2_x2 0 2901 1 864 1886 1534 mx2_x2
xsubckt_6112_mx2_x2 0 2903 1 835 2904 2905 mx2_x2
xsubckt_6110_mx2_x2 0 2905 1 864 1726 1694 mx2_x2
xsubckt_5566_nand3_x0 1 0 3384 3389 2005 2006 nand3_x0
xsubckt_5559_a4_x2 0 3389 1 3395 2008 2009 2010 a4_x2
xsubckt_5476_nxr2_x1 3445 1 0 3449 8107 nxr2_x1
xsubckt_4825_a4_x2 0 4002 1 4003 4016 4028 4142 a4_x2
xsubckt_4077_nand2_x0 1 0 4302 4303 8025 nand2_x0
xsubckt_3285_nand2_x0 1 0 5081 5082 8025 nand2_x0
xsubckt_2939_mx2_x2 0 5421 1 808 1665 1633 mx2_x2
xsubckt_2937_mx2_x2 0 5423 1 8031 5424 5425 mx2_x2
xsubckt_2548_mx2_x2 0 5805 1 8031 5806 5807 mx2_x2
xsubckt_2546_mx2_x2 0 5807 1 807 1484 1452 mx2_x2
xsubckt_839_nand2_x0 1 0 7507 7508 7516 nand2_x0
xsubckt_729_oa22_x2 0 7615 1 7637 7640 8412 oa22_x2
xsubckt_275_inv_x0 1 0 242 8101 inv_x0
xsubckt_277_inv_x0 1 0 2033 8099 inv_x0
xsubckt_279_inv_x0 1 0 240 8097 inv_x0
xsubckt_372_o2_x2 0 7976 1 644 662 o2_x2
xsubckt_1433_nand2_x0 1 0 6927 467 468 nand2_x0
xsubckt_2332_a3_x2 1 6040 0 6041 541 8409 a3_x2
xcmpt_abc_30082_new_n5520_hfns_2 1 0 6171 6168 buf_x4
xcmpt_abc_30082_new_n5520_hfns_1 1 0 6168 6169 buf_x4
xcmpt_abc_30082_new_n5520_hfns_0 1 0 6168 6170 buf_x4
xsubckt_9293_sff1_x4 1 2222 0 9147 1048 sff1_x4
xsubckt_9215_sff1_x4 1 2245 0 9225 1064 sff1_x4
xsubckt_7942_sff1_x4 1 2066 0 10415 249 sff1_x4
xsubckt_6509_mx2_x2 0 2517 1 8214 2518 2521 mx2_x2
xsubckt_6461_mx2_x2 0 2563 1 8207 2564 2579 mx2_x2
xsubckt_6118_mx2_x2 0 2897 1 843 1054 1022 mx2_x2
xsubckt_6116_mx2_x2 0 2899 1 8225 2900 2901 mx2_x2
xsubckt_6072_mx2_x2 0 2942 1 843 1855 1823 mx2_x2
xsubckt_5627_a3_x2 1 3341 0 3346 1986 1987 a3_x2
xsubckt_5579_a4_x2 0 3375 1 3382 2001 2002 2003 a4_x2
xsubckt_5401_a2_x2 0 3505 1 3506 8295 a2_x2
xsubckt_4740_ao22_x2 0 9912 1 4067 4068 40 ao22_x2
xsubckt_3153_nxr2_x1 5211 1 0 243 762 nxr2_x1
xsubckt_749_nand2_x0 1 0 7593 633 1914 nand2_x0
xsubckt_1417_nor2_x0 1 0 6945 663 664 nor2_x0
xsubckt_1495_nor2_x0 1 0 6869 6870 8127 nor2_x0
xcmpt_abc_30082_new_n5480_hfns_2 1 0 6237 6234 buf_x4
xcmpt_abc_30082_new_n5480_hfns_1 1 0 6234 6235 buf_x4
xcmpt_abc_30082_new_n5480_hfns_0 1 0 6234 6236 buf_x4
xcmpt_abc_30082_new_n5526_hfns_2 1 0 6163 6160 buf_x4
xcmpt_abc_30082_new_n5526_hfns_1 1 0 6160 6161 buf_x4
xcmpt_abc_30082_new_n5526_hfns_0 1 0 6160 6162 buf_x4
xsubckt_9289_sff1_x4 1 2212 0 9151 1052 sff1_x4
xsubckt_8838_sff1_x4 1 2192 0 9587 1536 sff1_x4
xsubckt_8750_sff1_x4 1 2073 0 9672 644 sff1_x4
xsubckt_8393_sff1_x4 1 2106 0 9964 1609 sff1_x4
xsubckt_8315_sff1_x4 1 2238 0 10042 1652 sff1_x4
xsubckt_7344_ao22_x2 0 8504 1 8248 8607 8505 ao22_x2
xsubckt_6469_mx2_x2 0 2556 1 8218 2557 2558 mx2_x2
xsubckt_6467_mx2_x2 0 2558 1 840 915 883 mx2_x2
xsubckt_6429_a2_x2 0 9689 1 2595 2629 a2_x2
xsubckt_6078_mx2_x2 0 2936 1 840 1887 1535 mx2_x2
xsubckt_6076_mx2_x2 0 2938 1 836 2939 2940 mx2_x2
xsubckt_6074_mx2_x2 0 2940 1 840 1727 1695 mx2_x2
xsubckt_5930_mx2_x2 0 3080 1 840 1701 1669 mx2_x2
xsubckt_5306_nxr2_x1 3593 1 0 3594 3595 nxr2_x1
xsubckt_4758_a3_x2 1 4053 0 4054 4065 4143 a3_x2
xsubckt_3623_a2_x2 0 4748 1 4749 4754 a2_x2
xsubckt_3192_oa22_x2 0 5172 1 5173 5174 775 oa22_x2
xsubckt_944_xr2_x1 7408 0 1 757 82 xr2_x1
xsubckt_912_nand2_x0 1 0 7438 240 1899 nand2_x0
xsubckt_1376_a2_x2 0 6989 1 6990 6993 a2_x2
xcmpt_abc_30082_new_n5484_hfns_2 1 0 6231 6228 buf_x4
xcmpt_abc_30082_new_n5484_hfns_1 1 0 6228 6229 buf_x4
xcmpt_abc_30082_new_n5484_hfns_0 1 0 6228 6230 buf_x4
xsubckt_9123_sff1_x4 1 2194 0 9317 1092 sff1_x4
xsubckt_8389_sff1_x4 1 2099 0 9968 1635 sff1_x4
xsubckt_7938_sff1_x4 1 2066 0 10456 837 sff1_x4
xsubckt_6938_a2_x2 0 9646 1 8756 45 a2_x2
xsubckt_6680_oa22_x2 0 2350 1 3191 2353 2351 oa22_x2
xsubckt_6103_o2_x2 0 2911 1 2912 7931 o2_x2
xsubckt_5936_mx2_x2 0 3074 1 8218 3075 3076 mx2_x2
xsubckt_5934_mx2_x2 0 3076 1 842 1861 1509 mx2_x2
xsubckt_5932_mx2_x2 0 3078 1 834 3079 3080 mx2_x2
xsubckt_4846_a2_x2 0 9886 1 3987 44 a2_x2
xsubckt_4826_a2_x2 0 4001 1 4002 1938 a2_x2
xsubckt_4088_oa22_x2 0 4291 1 4292 4293 776 oa22_x2
xsubckt_3683_a2_x2 0 4689 1 4690 4695 a2_x2
xsubckt_2915_nand2_x0 1 0 5445 5446 5451 nand2_x0
xsubckt_2610_nxr2_x1 5744 1 0 5745 5751 nxr2_x1
xsubckt_442_nor3_x0 1 0 7896 648 643 647 nor3_x0
xsubckt_1590_nand3_x0 1 0 6780 6781 6782 6940 nand3_x0
xsubckt_1841_oa22_x2 0 6546 1 6560 6554 6555 oa22_x2
xsubckt_1876_nxr2_x1 6513 1 0 6516 225 nxr2_x1
xsubckt_9197_sff1_x4 1 2225 0 9243 1208 sff1_x4
xsubckt_8746_sff1_x4 1 2150 0 2299 2267 sff1_x4
xsubckt_8223_sff1_x4 1 2203 0 10134 1264 sff1_x4
xsubckt_5938_mx2_x2 0 3072 1 844 1029 997 mx2_x2
xsubckt_5892_mx2_x2 0 3117 1 844 1830 1798 mx2_x2
xsubckt_5812_nand2_x0 1 0 3194 3196 6427 nand2_x0
xsubckt_5214_o2_x2 0 9826 1 3679 3691 o2_x2
xsubckt_5059_o2_x2 0 9837 1 3823 3836 o2_x2
xsubckt_5021_ao22_x2 0 3857 1 3859 3951 7885 ao22_x2
xsubckt_1058_xr2_x1 7300 0 1 750 75 xr2_x1
xsubckt_642_nand2_x0 1 0 7698 629 1947 nand2_x0
xsubckt_1324_o2_x2 0 7041 1 445 226 o2_x2
xsubckt_1885_a2_x2 0 6505 1 6511 6514 a2_x2
xsubckt_2018_o2_x2 0 6430 1 727 712 o2_x2
xsubckt_9119_sff1_x4 1 2251 0 9321 1096 sff1_x4
xsubckt_9031_sff1_x4 1 2066 0 9399 383 sff1_x4
xsubckt_8297_sff1_x4 1 2106 0 10060 1641 sff1_x4
xsubckt_7484_nand2_x0 1 0 8481 4182 4219 nand2_x0
xsubckt_5898_mx2_x2 0 3111 1 854 1862 1510 mx2_x2
xsubckt_5896_mx2_x2 0 3113 1 833 3114 3115 mx2_x2
xsubckt_5894_mx2_x2 0 3115 1 854 1702 1670 mx2_x2
xsubckt_4837_nxr2_x1 3993 1 0 3994 8343 nxr2_x1
xsubckt_4625_mx2_x2 0 9954 1 4147 6169 1629 mx2_x2
xsubckt_4623_mx2_x2 0 9956 1 4147 6188 1631 mx2_x2
xsubckt_4234_mx2_x2 0 10316 1 4209 6258 1737 mx2_x2
xsubckt_4232_mx2_x2 0 10318 1 4209 6273 1751 mx2_x2
xsubckt_4230_mx2_x2 0 10320 1 4209 6283 1763 mx2_x2
xsubckt_3744_ao22_x2 0 4629 1 4678 4677 4630 ao22_x2
xsubckt_552_nand2_x0 1 0 7784 768 1902 nand2_x0
xsubckt_350_nor3_x0 1 0 7999 506 504 505 nor3_x0
xsubckt_398_nor4_x0 1 0 7947 656 658 663 666 nor4_x0
xsubckt_462_nand2_x0 1 0 10459 7871 7874 nand2_x0
xsubckt_1189_o2_x2 0 7176 1 194 225 o2_x2
xsubckt_1785_o3_x2 0 6598 1 6599 6600 6939 o3_x2
xfeed_19 1 0 decap_w0
xfeed_18 1 0 tie
xfeed_17 1 0 decap_w0
xfeed_16 1 0 decap_w0
xfeed_15 1 0 decap_w0
xfeed_14 1 0 decap_w0
xfeed_13 1 0 decap_w0
xfeed_12 1 0 decap_w0
xfeed_11 1 0 decap_w0
xfeed_10 1 0 decap_w0
xsubckt_8654_sff1_x4 1 2185 0 9735 535 sff1_x4
xsubckt_8219_sff1_x4 1 2238 0 10138 1268 sff1_x4
xsubckt_8131_sff1_x4 1 2139 0 10226 1227 sff1_x4
xsubckt_5289_nand2_x0 1 0 3609 3624 3891 nand2_x0
xsubckt_4972_mx2_x2 0 3894 1 6445 6122 143 mx2_x2
xsubckt_4629_mx2_x2 0 9950 1 4146 6135 1625 mx2_x2
xsubckt_4627_mx2_x2 0 9952 1 4146 6152 1627 mx2_x2
xsubckt_4581_mx2_x2 0 9996 1 4152 6259 1481 mx2_x2
xsubckt_4236_mx2_x2 0 10314 1 4209 6244 1735 mx2_x2
xsubckt_3096_oa22_x2 0 5267 1 5270 5275 7907 oa22_x2
xsubckt_3018_oa22_x2 0 5343 1 5344 5383 5958 oa22_x2
xsubckt_810_oa22_x2 0 7535 1 7536 7613 8284 oa22_x2
xsubckt_1745_oa22_x2 0 6636 1 6659 6645 6646 oa22_x2
xcmpt_abc_30082_new_n3648_hfns_2 1 0 7992 7989 buf_x4
xcmpt_abc_30082_new_n3648_hfns_1 1 0 7989 7990 buf_x4
xcmpt_abc_30082_new_n3648_hfns_0 1 0 7989 7991 buf_x4
xsubckt_9462_sff1_x4 1 2108 0 8981 1873 sff1_x4
xsubckt_9027_sff1_x4 1 2083 0 9403 388 sff1_x4
xsubckt_8127_sff1_x4 1 2132 0 10230 1232 sff1_x4
xsubckt_5684_oa22_x2 0 3289 1 3328 3327 3290 oa22_x2
xsubckt_5538_nand3_x0 1 0 3403 3407 2016 2015 nand3_x0
xsubckt_4976_mx2_x2 0 3891 1 6445 6113 142 mx2_x2
xsubckt_4745_nxr2_x1 4062 1 0 4064 8324 nxr2_x1
xsubckt_4583_mx2_x2 0 9994 1 4152 6245 1479 mx2_x2
xsubckt_4196_mx2_x2 0 10351 1 4215 6277 1154 mx2_x2
xsubckt_3703_mx2_x2 0 4670 1 812 1171 1075 mx2_x2
xsubckt_989_nand2_x0 1 0 7365 7990 2027 nand2_x0
xsubckt_884_oa22_x2 0 7465 1 7487 7486 7485 oa22_x2
xsubckt_1405_nand2_x0 1 0 6960 6961 7966 nand2_x0
xfeed_29 1 0 decap_w0
xfeed_28 1 0 decap_w0
xfeed_27 1 0 decap_w0
xfeed_26 1 0 decap_w0
xfeed_25 1 0 decap_w0
xfeed_24 1 0 decap_w0
xfeed_23 1 0 decap_w0
xfeed_22 1 0 tie
xfeed_21 1 0 tie
xfeed_20 1 0 decap_w0
xsubckt_9458_sff1_x4 1 2216 0 8985 1877 sff1_x4
xsubckt_8562_sff1_x4 1 2053 0 9795 2035 sff1_x4
xsubckt_7360_mx3_x2 1 0 9475 8502 6293 1600 6196 6200 mx3_x2
xsubckt_6937_oa22_x2 0 8756 1 8759 8757 8758 oa22_x2
xsubckt_5157_oa22_x2 0 3731 1 3732 3743 7881 oa22_x2
xsubckt_4589_mx2_x2 0 9988 1 4152 6189 1503 mx2_x2
xsubckt_4198_mx2_x2 0 10349 1 4215 6266 1132 mx2_x2
xsubckt_3707_mx2_x2 0 4666 1 813 1779 1747 mx2_x2
xsubckt_3663_mx2_x2 0 4709 1 813 1140 1108 mx2_x2
xsubckt_2910_oa22_x2 0 5450 1 5508 5504 5507 oa22_x2
xsubckt_2892_nand3_x0 1 0 5467 5492 5496 8011 nand3_x0
xsubckt_1130_oa22_x2 0 166 1 7246 7244 7232 oa22_x2
xsubckt_917_a3_x2 1 7433 0 7434 7435 7436 a3_x2
xsubckt_731_a2_x2 0 7610 1 219 1898 a2_x2
xsubckt_536_a2_x2 0 7803 1 8285 217 a2_x2
xsubckt_516_a2_x2 0 7822 1 563 47 a2_x2
xsubckt_1688_nxr2_x1 6689 1 0 6690 8041 nxr2_x1
xsubckt_2271_nand4_x0 1 0 6119 6147 83 82 80 nand4_x0
xsubckt_9370_sff1_x4 1 2119 0 9073 973 sff1_x4
xsubckt_8993_sff1_x4 1 2238 0 9432 1556 sff1_x4
xsubckt_8558_sff1_x4 1 2047 0 9799 2039 sff1_x4
xsubckt_8035_sff1_x4 1 2139 0 10322 1131 sff1_x4
xsubckt_7626_mx2_x2 0 9193 1 8460 6252 1416 mx2_x2
xsubckt_7624_mx2_x2 0 9195 1 8460 6265 1420 mx2_x2
xsubckt_7622_mx2_x2 0 9197 1 8460 6277 1442 mx2_x2
xsubckt_7231_mx2_x2 0 9512 1 8831 8593 749 mx2_x2
xsubckt_5182_nand2_x0 1 0 3708 3710 3712 nand2_x0
xsubckt_5103_a4_x2 0 3782 1 3820 3930 3933 3936 a4_x2
xsubckt_4653_nxr2_x1 4132 1 0 4134 8308 nxr2_x1
xsubckt_4122_nand2_x0 1 0 4258 4259 8023 nand2_x0
xsubckt_3753_nxr2_x1 4621 1 0 232 751 nxr2_x1
xsubckt_3667_mx2_x2 0 4705 1 813 1300 1268 mx2_x2
xsubckt_1135_nand2_x0 1 0 7227 7228 7231 nand2_x0
xsubckt_791_a2_x2 0 7553 1 246 1897 a2_x2
xsubckt_771_a2_x2 0 7572 1 247 1897 a2_x2
xsubckt_725_nor2_x0 1 0 7619 557 558 nor2_x0
xsubckt_123_inv_x0 1 0 59 8281 inv_x0
xsubckt_121_inv_x0 1 0 1897 8283 inv_x0
xsubckt_2001_mx2_x2 0 10452 1 6440 9407 716 mx2_x2
xsubckt_2003_mx2_x2 0 10451 1 6440 9406 715 mx2_x2
xfeed_39 1 0 tie
xfeed_38 1 0 tie
xfeed_37 1 0 decap_w0
xfeed_36 1 0 decap_w0
xfeed_35 1 0 decap_w0
xfeed_34 1 0 decap_w0
xfeed_33 1 0 decap_w0
xfeed_32 1 0 decap_w0
xfeed_31 1 0 decap_w0
xfeed_30 1 0 tie
xsubckt_9366_sff1_x4 1 2116 0 9077 977 sff1_x4
xsubckt_8915_sff1_x4 1 2089 0 9510 751 sff1_x4
xsubckt_8470_sff1_x4 1 2047 0 9887 1934 sff1_x4
xsubckt_7582_mx2_x2 0 9233 1 8470 6035 1197 mx2_x2
xsubckt_7580_mx2_x2 0 9235 1 8470 6054 1199 mx2_x2
xsubckt_7237_mx2_x2 0 9510 1 8832 8589 751 mx2_x2
xsubckt_7191_mx2_x2 0 9524 1 8622 8621 556 mx2_x2
xsubckt_6700_mx2_x2 0 2331 1 8222 2332 2333 mx2_x2
xsubckt_6322_oa22_x2 0 2699 1 46 1906 205 oa22_x2
xsubckt_5461_nxr2_x1 3455 1 0 3459 8121 nxr2_x1
xsubckt_5065_oa22_x2 0 3817 1 3831 3829 3830 oa22_x2
xsubckt_4649_nxr2_x1 4135 1 0 4138 8307 nxr2_x1
xsubckt_3792_oa22_x2 0 4582 1 4583 4584 776 oa22_x2
xsubckt_3278_mx2_x2 0 5088 1 815 987 955 mx2_x2
xsubckt_2906_oa22_x2 0 5453 1 5454 5501 5993 oa22_x2
xsubckt_1045_nand2_x0 1 0 7312 232 1899 nand2_x0
xsubckt_972_nand2_x0 1 0 7381 1993 638 nand2_x0
xsubckt_882_nand2_x0 1 0 7466 7467 7475 nand2_x0
xsubckt_129_inv_x0 1 0 564 8270 inv_x0
xsubckt_127_inv_x0 1 0 571 8272 inv_x0
xsubckt_125_inv_x0 1 0 562 8274 inv_x0
xsubckt_2005_mx2_x2 0 10450 1 6441 9405 714 mx2_x2
xsubckt_2007_mx2_x2 0 10449 1 6440 9404 713 mx2_x2
xsubckt_2009_mx2_x2 0 10448 1 6441 9403 732 mx2_x2
xsubckt_2299_ao22_x2 0 6083 1 76 6093 6295 ao22_x2
xsubckt_2350_mx2_x2 0 10416 1 6299 6018 1802 mx2_x2
xsubckt_9200_sff1_x4 1 2229 0 9240 1204 sff1_x4
xsubckt_8989_sff1_x4 1 2232 0 9436 1561 sff1_x4
xsubckt_8466_sff1_x4 1 2057 0 9891 1938 sff1_x4
xsubckt_7588_mx2_x2 0 9229 1 8464 6277 1090 mx2_x2
xsubckt_7584_mx2_x2 0 9231 1 8470 6018 1194 mx2_x2
xsubckt_7197_mx2_x2 0 9521 1 8622 8618 553 mx2_x2
xsubckt_7195_mx2_x2 0 9522 1 8622 8619 551 mx2_x2
xsubckt_7193_mx2_x2 0 9523 1 8622 8620 555 mx2_x2
xsubckt_6706_mx2_x2 0 2325 1 866 1581 1549 mx2_x2
xsubckt_6704_mx2_x2 0 2327 1 8215 2328 2331 mx2_x2
xsubckt_6702_mx2_x2 0 2329 1 866 1133 1101 mx2_x2
xsubckt_6315_mx2_x2 0 2705 1 8215 2706 2709 mx2_x2
xsubckt_6313_mx2_x2 0 2707 1 866 1433 1401 mx2_x2
xsubckt_6311_mx2_x2 0 2709 1 8222 2710 2711 mx2_x2
xsubckt_5457_nxr2_x1 3458 1 0 3462 8125 nxr2_x1
xsubckt_5429_nor2_x0 1 0 3478 3479 8277 nor2_x0
xsubckt_4743_a4_x2 0 4064 1 4066 4078 4091 4142 a4_x2
xsubckt_4028_nand3_x0 1 0 4350 4375 4379 8011 nand3_x0
xsubckt_3093_xr2_x1 5270 0 1 244 763 xr2_x1
xsubckt_2975_nand2_x0 1 0 5386 5387 5392 nand2_x0
xsubckt_2747_mx2_x2 0 5610 1 819 1702 1670 mx2_x2
xsubckt_1126_a3_x2 1 7235 0 7236 7237 7238 a3_x2
xsubckt_540_mx2_x2 0 7799 1 217 401 414 mx2_x2
xsubckt_349_o2_x2 0 8003 1 506 504 o2_x2
xsubckt_1567_a4_x2 0 6802 1 6845 8054 8055 8065 a4_x2
xfeed_46 1 0 decap_w0
xfeed_45 1 0 decap_w0
xfeed_44 1 0 decap_w0
xfeed_43 1 0 decap_w0
xfeed_42 1 0 decap_w0
xfeed_41 1 0 decap_w0
xfeed_40 1 0 decap_w0
xsubckt_9274_sff1_x4 1 2103 0 9166 1059 sff1_x4
xsubckt_8823_sff1_x4 1 2083 0 9600 563 sff1_x4
xsubckt_8300_sff1_x4 1 2229 0 10057 1638 sff1_x4
xsubckt_7199_mx2_x2 0 9520 1 8622 8617 552 mx2_x2
xsubckt_6708_mx2_x2 0 2323 1 849 1485 1453 mx2_x2
xsubckt_6662_mx2_x2 0 2368 1 849 1358 1326 mx2_x2
xsubckt_6660_mx2_x2 0 2370 1 8212 2371 2374 mx2_x2
xsubckt_6317_mx2_x2 0 2703 1 8207 2704 2719 mx2_x2
xsubckt_6271_mx2_x2 0 2748 1 8223 2749 2750 mx2_x2
xsubckt_6033_a2_x2 0 9700 1 2980 3014 a2_x2
xsubckt_5565_a3_x2 1 3385 0 3389 2005 2006 a3_x2
xsubckt_4809_ao22_x2 0 4014 1 1942 4015 49 ao22_x2
xsubckt_4783_a4_x2 0 4034 1 4035 4042 4054 4065 a4_x2
xsubckt_2733_nor2_x0 1 0 5624 220 739 nor2_x0
xsubckt_1019_a2_x2 0 7337 1 752 77 a2_x2
xsubckt_622_oa22_x2 0 7717 1 7718 7722 7793 oa22_x2
xsubckt_1382_nand3_x0 1 0 6983 7158 198 8080 nand3_x0
xsubckt_2171_xr2_x1 6268 0 1 81 70 xr2_x1
xsubckt_2264_nand3_x0 1 0 6128 6147 83 82 nand3_x0
xsubckt_2290_a3_x2 1 6094 0 6095 541 8409 a3_x2
xfeed_49 1 0 tie
xfeed_48 1 0 decap_w0
xfeed_47 1 0 decap_w0
xsubckt_8897_sff1_x4 1 2066 0 9528 325 sff1_x4
xsubckt_8819_sff1_x4 1 2053 0 9604 571 sff1_x4
xsubckt_8374_sff1_x4 1 2245 0 9983 1498 sff1_x4
xsubckt_7923_sff1_x4 1 2212 0 10429 1817 sff1_x4
xsubckt_6668_mx2_x2 0 2362 1 8211 2363 2366 mx2_x2
xsubckt_6666_mx2_x2 0 2364 1 848 1134 1102 mx2_x2
xsubckt_6664_mx2_x2 0 2366 1 8226 2367 2368 mx2_x2
xsubckt_6277_mx2_x2 0 2742 1 848 1434 1402 mx2_x2
xsubckt_6275_mx2_x2 0 2744 1 8226 2745 2746 mx2_x2
xsubckt_6273_mx2_x2 0 2746 1 853 1658 1626 mx2_x2
xsubckt_5633_a2_x2 0 3337 1 3339 1983 a2_x2
xsubckt_5613_a2_x2 0 3351 1 3353 1990 a2_x2
xsubckt_5458_a2_x2 0 9803 1 3458 52 a2_x2
xsubckt_5004_mx2_x2 0 3870 1 6445 6051 135 mx2_x2
xsubckt_5000_mx2_x2 0 3873 1 6445 6059 136 mx2_x2
xsubckt_4704_a2_x2 0 9921 1 4094 4095 a2_x2
xsubckt_4656_a3_x2 1 4130 0 4134 1965 8309 a3_x2
xsubckt_3696_oa22_x2 0 4677 1 4680 4685 7907 oa22_x2
xsubckt_3409_nand2_x0 1 0 4959 4960 779 nand2_x0
xsubckt_2722_oa22_x2 0 5634 1 5635 5674 5958 oa22_x2
xsubckt_1703_a2_x2 0 6675 1 6676 8415 a2_x2
xsubckt_1861_nxr2_x1 6527 1 0 6529 6534 nxr2_x1
xsubckt_1999_nand3_x0 1 0 6442 7912 51 504 nand3_x0
xfeed_53 1 0 decap_w0
xfeed_52 1 0 decap_w0
xfeed_51 1 0 decap_w0
xfeed_50 1 0 decap_w0
xcmpt_cpu_state_bit6_hfns_3 1 0 1907 1892 buf_x4
xcmpt_cpu_state_bit6_hfns_2 1 0 1892 1893 buf_x4
xcmpt_cpu_state_bit6_hfns_1 1 0 1892 1894 buf_x4
xcmpt_cpu_state_bit6_hfns_0 1 0 1892 1895 buf_x4
xcmpt_cpu_state_bit4_hfns_3 1 0 1909 1896 buf_x4
xcmpt_cpu_state_bit4_hfns_2 1 0 1896 1897 buf_x4
xcmpt_cpu_state_bit4_hfns_1 1 0 1896 1898 buf_x4
xcmpt_cpu_state_bit4_hfns_0 1 0 1896 1899 buf_x4
xcmpt_cpu_state_bit2_hfns_2 1 0 1911 1904 buf_x4
xcmpt_cpu_state_bit2_hfns_1 1 0 1904 1905 buf_x4
xcmpt_cpu_state_bit2_hfns_0 1 0 1904 1906 buf_x4
xsubckt_9182_sff1_x4 1 2106 0 9258 1193 sff1_x4
xsubckt_8731_sff1_x4 1 2185 0 2315 2283 sff1_x4
xsubckt_7997_sff1_x4 1 2142 0 10360 1778 sff1_x4
xsubckt_7919_sff1_x4 1 2212 0 10433 1821 sff1_x4
xsubckt_6948_ao22_x2 0 9644 1 8748 8751 51 ao22_x2
xsubckt_6279_mx2_x2 0 2740 1 8211 2741 2744 mx2_x2
xsubckt_5478_a2_x2 0 3444 1 3446 2036 a2_x2
xsubckt_5168_ao22_x2 0 3721 1 3722 3723 3728 ao22_x2
xsubckt_5008_mx2_x2 0 3867 1 6445 6041 134 mx2_x2
xsubckt_4953_oa22_x2 0 9857 1 7884 3909 3911 oa22_x2
xsubckt_4764_a2_x2 0 4049 1 1956 1955 a2_x2
xsubckt_4542_nand2_x0 1 0 4158 4183 4194 nand2_x0
xsubckt_3815_a2_x2 0 4560 1 4561 4568 a2_x2
xsubckt_3229_nand2_x0 1 0 5136 5137 782 nand2_x0
xsubckt_2954_nand3_x0 1 0 5406 5426 5430 8012 nand3_x0
xsubckt_817_ao22_x2 0 7528 1 7529 7533 7795 ao22_x2
xsubckt_1857_nxr2_x1 6531 1 0 6533 195 nxr2_x1
xsubckt_2273_oa22_x2 0 6117 1 6118 6119 6121 oa22_x2
xfeed_59 1 0 decap_w0
xfeed_58 1 0 decap_w0
xfeed_57 1 0 decap_w0
xfeed_56 1 0 decap_w0
xfeed_55 1 0 decap_w0
xfeed_54 1 0 decap_w0
xsubckt_9104_sff1_x4 1 2209 0 9336 884 sff1_x4
xsubckt_8727_sff1_x4 1 2193 0 2289 2257 sff1_x4
xsubckt_8282_sff1_x4 1 2219 0 10075 1301 sff1_x4
xsubckt_8204_sff1_x4 1 2198 0 10153 1254 sff1_x4
xsubckt_7876_buf_x1 1 0 1868 9003 buf_x1
xsubckt_7874_buf_x1 1 0 1890 9005 buf_x1
xsubckt_5748_mx2_x2 0 3257 1 851 1379 1347 mx2_x2
xsubckt_4951_mx3_x2 1 0 3910 6450 545 8379 8179 8180 mx3_x2
xsubckt_4949_oa22_x2 0 9858 1 7886 3912 3914 oa22_x2
xsubckt_526_oa22_x2 0 10462 1 7832 7814 7816 oa22_x2
xsubckt_2151_o2_x2 0 6307 1 540 559 o2_x2
xfeed_60 1 0 tie
xsubckt_9178_sff1_x4 1 2103 0 9262 1219 sff1_x4
xsubckt_9090_sff1_x4 1 2209 0 9350 869 sff1_x4
xsubckt_8278_sff1_x4 1 2248 0 10079 1306 sff1_x4
xsubckt_7878_buf_x1 1 0 1864 9001 buf_x1
xsubckt_6804_o2_x2 0 8854 1 1895 1912 o2_x2
xsubckt_6355_o2_x2 0 2666 1 2667 7931 o2_x2
xsubckt_5154_nand2_x0 1 0 3734 3736 3738 nand2_x0
xsubckt_4955_mx3_x2 1 0 3907 6448 547 8380 8177 8178 mx3_x2
xsubckt_4433_mx2_x2 0 10132 1 4179 6044 1262 mx2_x2
xsubckt_4431_mx2_x2 0 10134 1 4179 6062 1264 mx2_x2
xsubckt_3049_nand2_x0 1 0 5313 5314 782 nand2_x0
xsubckt_41_inv_x0 1 0 128 8370 inv_x0
xsubckt_43_inv_x0 1 0 130 8368 inv_x0
xsubckt_45_inv_x0 1 0 144 8366 inv_x0
xsubckt_1765_nxr2_x1 6617 1 0 6619 201 nxr2_x1
xsubckt_2397_o3_x2 0 5959 1 1898 1908 1894 o3_x2
xfeed_69 1 0 decap_w0
xfeed_68 1 0 decap_w0
xfeed_67 1 0 decap_w0
xfeed_66 1 0 tie
xfeed_65 1 0 tie
xfeed_64 1 0 tie
xfeed_63 1 0 decap_w0
xfeed_62 1 0 tie
xfeed_61 1 0 decap_w0
xsubckt_9012_sff1_x4 1 2053 0 9418 373 sff1_x4
xsubckt_8635_sff1_x4 1 2156 0 172 109 sff1_x4
xsubckt_8190_sff1_x4 1 2109 0 10167 1713 sff1_x4
xsubckt_8112_sff1_x4 1 2235 0 10245 1248 sff1_x4
xsubckt_6933_nor2_x0 1 0 8759 8764 8832 nor2_x0
xsubckt_5064_nand2_x0 1 0 3818 3819 8294 nand2_x0
xsubckt_4959_mx3_x2 1 0 3904 6448 547 8381 8175 8176 mx3_x2
xsubckt_4439_mx2_x2 0 10128 1 4173 6282 1699 mx2_x2
xsubckt_4435_mx2_x2 0 10130 1 4178 6027 1259 mx2_x2
xsubckt_3919_nand2_x0 1 0 4457 6011 8083 nand2_x0
xsubckt_3212_nand2_x0 1 0 5153 242 761 nand2_x0
xsubckt_3077_oa22_x2 0 5285 1 5286 5325 5957 oa22_x2
xsubckt_47_inv_x0 1 0 91 8364 inv_x0
xsubckt_49_inv_x0 1 0 63 8362 inv_x0
xsubckt_1369_oa22_x2 0 6996 1 6997 7000 7123 oa22_x2
xsubckt_1480_ao22_x2 0 6883 1 615 6887 8062 ao22_x2
xsubckt_9443_sff1_x4 1 2142 0 9000 1863 sff1_x4
xsubckt_9086_sff1_x4 1 2100 0 9354 873 sff1_x4
xsubckt_9008_sff1_x4 1 2047 0 9422 399 sff1_x4
xsubckt_8186_sff1_x4 1 2217 0 10171 1717 sff1_x4
xsubckt_5995_o2_x2 0 3016 1 3017 7931 o2_x2
xsubckt_5491_nand3_x0 1 0 3435 3439 2032 2033 nand3_x0
xsubckt_4395_mx2_x2 0 10166 1 4186 6062 1712 mx2_x2
xsubckt_4393_mx2_x2 0 10168 1 4186 6081 1714 mx2_x2
xsubckt_4391_mx2_x2 0 10170 1 4186 6098 1716 mx2_x2
xsubckt_3906_mx2_x2 0 4470 1 795 1296 1264 mx2_x2
xsubckt_3902_mx2_x2 0 4474 1 795 1136 1104 mx2_x2
xsubckt_3829_nand2_x0 1 0 4546 4547 784 nand2_x0
xsubckt_3122_mx2_x2 0 5241 1 795 1246 1214 mx2_x2
xsubckt_3120_mx2_x2 0 5243 1 8032 5244 5245 mx2_x2
xsubckt_854_nand2_x0 1 0 7493 630 1936 nand2_x0
xfeed_79 1 0 tie
xfeed_78 1 0 decap_w0
xfeed_77 1 0 tie
xfeed_76 1 0 decap_w0
xfeed_75 1 0 decap_w0
xfeed_74 1 0 decap_w0
xfeed_73 1 0 decap_w0
xfeed_72 1 0 decap_w0
xfeed_71 1 0 tie
xfeed_70 1 0 decap_w0
xcmpt_abc_30082_new_n3458_hfns_9 1 0 8227 8217 buf_x4
xcmpt_abc_30082_new_n3458_hfns_8 1 0 8217 8218 buf_x4
xcmpt_abc_30082_new_n3458_hfns_7 1 0 8217 8219 buf_x4
xcmpt_abc_30082_new_n3458_hfns_6 1 0 8217 8220 buf_x4
xcmpt_abc_30082_new_n3458_hfns_5 1 0 8217 8221 buf_x4
xcmpt_abc_30082_new_n3458_hfns_4 1 0 8217 8222 buf_x4
xcmpt_abc_30082_new_n3458_hfns_3 1 0 8217 8223 buf_x4
xcmpt_abc_30082_new_n3458_hfns_2 1 0 8217 8224 buf_x4
xcmpt_abc_30082_new_n3458_hfns_1 1 0 8217 8225 buf_x4
xcmpt_abc_30082_new_n3458_hfns_0 1 0 8217 8226 buf_x4
xsubckt_8543_sff1_x4 1 2153 0 9814 136 sff1_x4
xsubckt_8108_sff1_x4 1 2194 0 10249 1222 sff1_x4
xsubckt_8020_sff1_x4 1 2212 0 10337 1148 sff1_x4
xsubckt_7518_nand2_x0 1 0 8476 4182 4195 nand2_x0
xsubckt_4399_mx2_x2 0 10162 1 4186 6027 1707 mx2_x2
xsubckt_4397_mx2_x2 0 10164 1 4186 6044 1710 mx2_x2
xsubckt_3649_nand2_x0 1 0 4723 4724 784 nand2_x0
xsubckt_3519_mx2_x2 0 4851 1 795 1046 1014 mx2_x2
xsubckt_3471_mx2_x2 0 4898 1 795 1848 1816 mx2_x2
xsubckt_3128_mx2_x2 0 5235 1 8032 5236 5237 mx2_x2
xsubckt_3126_mx2_x2 0 5237 1 794 1374 1342 mx2_x2
xsubckt_3124_mx2_x2 0 5239 1 8032 5240 5241 mx2_x2
xsubckt_1111_oa22_x2 0 167 1 7263 7262 7250 oa22_x2
xcmpt_abc_30082_new_n7762_hfns_2 1 0 4169 4166 buf_x4
xcmpt_abc_30082_new_n7762_hfns_1 1 0 4166 4167 buf_x4
xcmpt_abc_30082_new_n7762_hfns_0 1 0 4166 4168 buf_x4
xspare_buffer_209 1 0 2146 2135 buf_x4
xspare_buffer_208 1 0 2146 2136 buf_x4
xspare_buffer_206 1 0 2146 2137 buf_x4
xspare_buffer_205 1 0 2146 2138 buf_x4
xspare_buffer_204 1 0 2146 2139 buf_x4
xspare_buffer_202 1 0 2146 2140 buf_x4
xspare_buffer_201 1 0 2146 2141 buf_x4
xspare_buffer_200 1 0 2146 2142 buf_x4
xsubckt_9439_sff1_x4 1 2126 0 9004 1879 sff1_x4
xsubckt_9351_sff1_x4 1 2235 0 9092 993 sff1_x4
xsubckt_8900_sff1_x4 1 2103 0 9525 322 sff1_x4
xsubckt_8094_sff1_x4 1 2109 0 10263 1169 sff1_x4
xsubckt_7823_mx2_x2 0 9007 1 8434 6018 906 mx2_x2
xsubckt_7821_mx2_x2 0 9009 1 8434 6034 909 mx2_x2
xsubckt_7563_mx3_x2 1 0 9252 8472 6289 1217 6206 6210 mx3_x2
xsubckt_7561_mx3_x2 1 0 9254 8472 6291 1189 6226 6229 mx3_x2
xsubckt_7432_mx2_x2 0 9375 1 8490 6162 1372 mx2_x2
xsubckt_7430_mx2_x2 0 9377 1 8490 6178 1374 mx2_x2
xsubckt_7338_nand2_x0 1 0 8509 710 653 nand2_x0
xsubckt_7214_nor2_x0 1 0 8604 8605 8608 nor2_x0
xsubckt_7041_mx2_x2 0 9414 1 7918 401 369 mx2_x2
xsubckt_5050_oa22_x2 0 3831 1 3845 3844 3843 oa22_x2
xsubckt_3812_nand2_x0 1 0 4563 231 750 nand2_x0
xsubckt_3475_mx2_x2 0 4894 1 793 1432 1400 mx2_x2
xsubckt_2965_oa22_x2 0 5395 1 5396 5443 5995 oa22_x2
xsubckt_943_a2_x2 0 7409 1 757 82 a2_x2
xsubckt_923_a2_x2 0 7428 1 758 83 a2_x2
xsubckt_748_a2_x2 0 7594 1 7991 1978 a2_x2
xsubckt_584_nand2_x0 1 0 7754 7755 7757 nand2_x0
xsubckt_320_inv_x0 1 0 214 8056 inv_x0
xsubckt_322_inv_x0 1 0 192 8054 inv_x0
xsubckt_324_inv_x0 1 0 195 8052 inv_x0
xsubckt_494_a2_x2 0 7842 1 7913 44 a2_x2
xsubckt_2200_mx2_x2 0 6221 1 547 93 2257 mx2_x2
xsubckt_2202_mx2_x2 0 6213 1 6297 6216 6220 mx2_x2
xfeed_89 1 0 decap_w0
xfeed_88 1 0 decap_w0
xfeed_87 1 0 decap_w0
xfeed_86 1 0 tie
xfeed_85 1 0 decap_w0
xfeed_84 1 0 decap_w0
xfeed_83 1 0 decap_w0
xfeed_82 1 0 decap_w0
xfeed_81 1 0 decap_w0
xfeed_80 1 0 decap_w0
xsubckt_8974_sff1_x4 1 2099 0 9451 1548 sff1_x4
xsubckt_8539_sff1_x4 1 2156 0 9818 140 sff1_x4
xsubckt_8451_sff1_x4 1 2044 0 9906 1955 sff1_x4
xsubckt_8016_sff1_x4 1 2235 0 10341 1152 sff1_x4
xsubckt_7829_mx2_x2 0 8971 1 8429 6266 1836 mx2_x2
xsubckt_7827_mx2_x2 0 8973 1 8429 6278 1858 mx2_x2
xsubckt_7781_mx2_x2 0 9047 1 8439 6089 947 mx2_x2
xsubckt_7438_mx2_x2 0 9369 1 8490 6108 1365 mx2_x2
xsubckt_7436_mx2_x2 0 9371 1 8490 6125 1368 mx2_x2
xsubckt_7434_mx2_x2 0 9373 1 8490 6142 1370 mx2_x2
xsubckt_7288_nor2_x0 1 0 8549 8550 8551 nor2_x0
xsubckt_7133_a4_x2 0 8645 1 7997 8300 43 503 a4_x2
xsubckt_7047_mx2_x2 0 9411 1 7918 428 396 mx2_x2
xsubckt_7045_mx2_x2 0 9412 1 7918 429 397 mx2_x2
xsubckt_7043_mx2_x2 0 9413 1 7918 400 368 mx2_x2
xsubckt_7006_a3_x2 1 8699 0 8701 8721 8725 a3_x2
xsubckt_3479_mx2_x2 0 4890 1 799 1592 1560 mx2_x2
xsubckt_3469_nand2_x0 1 0 4900 4901 780 nand2_x0
xsubckt_2940_mx2_x2 0 5420 1 799 1601 1569 mx2_x2
xsubckt_2930_nand2_x0 1 0 5430 5431 779 nand2_x0
xsubckt_2551_mx2_x2 0 5802 1 8013 5803 5818 mx2_x2
xsubckt_280_inv_x0 1 0 1995 8096 inv_x0
xsubckt_326_inv_x0 1 0 197 8050 inv_x0
xsubckt_328_inv_x0 1 0 199 8048 inv_x0
xspare_buffer_218 1 0 2133 2127 buf_x4
xspare_buffer_217 1 0 2133 2128 buf_x4
xspare_buffer_216 1 0 2133 2129 buf_x4
xspare_buffer_214 1 0 2133 2130 buf_x4
xspare_buffer_213 1 0 2133 2131 buf_x4
xspare_buffer_212 1 0 2133 2132 buf_x4
xspare_buffer_210 1 0 2146 2134 buf_x4
xsubckt_9347_sff1_x4 1 2215 0 9096 967 sff1_x4
xsubckt_7787_mx2_x2 0 9041 1 8439 6035 941 mx2_x2
xsubckt_7785_mx2_x2 0 9043 1 8439 6054 943 mx2_x2
xsubckt_7783_mx2_x2 0 9045 1 8439 6070 945 mx2_x2
xsubckt_7396_mx2_x2 0 9441 1 8495 6178 1566 mx2_x2
xsubckt_7066_a3_x2 1 8674 0 9417 8843 8844 a3_x2
xsubckt_6514_mx2_x2 0 2512 1 860 1042 1010 mx2_x2
xsubckt_6512_mx2_x2 0 2514 1 8220 2515 2516 mx2_x2
xsubckt_6510_mx2_x2 0 2516 1 860 1874 1522 mx2_x2
xsubckt_6121_mx2_x2 0 2894 1 827 2895 2902 mx2_x2
xsubckt_5926_oa22_x2 0 3084 1 43 1906 192 oa22_x2
xsubckt_5590_a4_x2 0 3367 1 3375 1998 1999 2000 a4_x2
xsubckt_5550_a4_x2 0 3395 1 3401 2011 2012 2013 a4_x2
xsubckt_4192_a4_x2 0 4218 1 4220 6307 7884 551 a4_x2
xsubckt_4146_oa22_x2 0 4234 1 4235 4274 5958 oa22_x2
xsubckt_3289_nand2_x0 1 0 5077 5078 783 nand2_x0
xsubckt_3011_nand3_x0 1 0 5350 5375 5379 8011 nand3_x0
xsubckt_2948_mx2_x2 0 5412 1 797 1313 1281 mx2_x2
xsubckt_2944_mx2_x2 0 5416 1 797 1153 1121 mx2_x2
xsubckt_2836_nand3_x0 1 0 5522 5542 5546 8012 nand3_x0
xsubckt_1093_oa22_x2 0 7267 1 7285 7283 7284 oa22_x2
xsubckt_769_oa22_x2 0 7574 1 7575 7576 7617 oa22_x2
xsubckt_282_inv_x0 1 0 238 8094 inv_x0
xsubckt_284_inv_x0 1 0 236 8092 inv_x0
xsubckt_286_inv_x0 1 0 1991 8090 inv_x0
xsubckt_1437_nand2_x0 1 0 6923 467 615 nand2_x0
xsubckt_2160_mx2_x2 0 6285 1 545 124 2288 mx2_x2
xsubckt_2162_mx2_x2 0 10447 1 6299 6282 1827 mx2_x2
xsubckt_2164_mx2_x2 0 6279 1 6293 6280 92 mx2_x2
xsubckt_2179_a4_x2 0 6256 1 81 70 67 66 a4_x2
xsubckt_2227_a3_x2 1 6175 0 6176 541 8409 a3_x2
xsubckt_2319_nand2_x0 1 0 6057 6066 73 nand2_x0
xfeed_99 1 0 decap_w0
xfeed_98 1 0 decap_w0
xfeed_97 1 0 tie
xfeed_96 1 0 decap_w0
xfeed_95 1 0 tie
xfeed_94 1 0 decap_w0
xfeed_93 1 0 tie
xfeed_92 1 0 tie
xfeed_91 1 0 decap_w0
xfeed_90 1 0 decap_w0
xsubckt_8882_sff1_x4 1 2050 0 9543 354 sff1_x4
xsubckt_8804_sff1_x4 1 2066 0 9618 721 sff1_x4
xsubckt_8447_sff1_x4 1 2044 0 9910 1959 sff1_x4
xsubckt_7982_sff1_x4 1 2189 0 10375 1764 sff1_x4
xsubckt_7789_mx2_x2 0 9039 1 8439 6017 938 mx2_x2
xsubckt_7398_mx2_x2 0 9439 1 8495 6162 1564 mx2_x2
xsubckt_6518_mx2_x2 0 2508 1 859 1362 1330 mx2_x2
xsubckt_6516_mx2_x2 0 2510 1 8210 2511 2514 mx2_x2
xsubckt_6470_mx2_x2 0 2555 1 859 1715 1683 mx2_x2
xsubckt_6127_mx2_x2 0 2888 1 8221 2889 2890 mx2_x2
xsubckt_6125_mx2_x2 0 2890 1 859 1246 1214 mx2_x2
xsubckt_6123_mx2_x2 0 2892 1 859 1310 1278 mx2_x2
xsubckt_5602_ao22_x2 0 3358 1 3362 1994 54 ao22_x2
xsubckt_5443_a3_x2 1 3468 0 2029 2040 2041 a3_x2
xsubckt_4808_a3_x2 1 4015 0 4016 4028 4142 a3_x2
xsubckt_4334_nand2_x0 1 0 4192 4194 4195 nand2_x0
xsubckt_3452_nand2_x0 1 0 4917 238 757 nand2_x0
xsubckt_681_oa22_x2 0 7661 1 7806 7939 8228 oa22_x2
xsubckt_288_inv_x0 1 0 234 8088 inv_x0
xsubckt_1347_nand2_x0 1 0 7018 191 8113 nand2_x0
xsubckt_1538_oa22_x2 0 6829 1 6845 8065 615 oa22_x2
xsubckt_2166_mx2_x2 0 6275 1 547 112 2276 mx2_x2
xsubckt_2168_mx2_x2 0 10445 1 6300 6273 1815 mx2_x2
xspare_buffer_229 1 0 2120 2118 buf_x4
xspare_buffer_228 1 0 2120 2119 buf_x4
xspare_buffer_226 1 0 2133 2121 buf_x4
xspare_buffer_225 1 0 2133 2122 buf_x4
xspare_buffer_224 1 0 2133 2123 buf_x4
xspare_buffer_222 1 0 2133 2124 buf_x4
xspare_buffer_221 1 0 2133 2125 buf_x4
xspare_buffer_220 1 0 2133 2126 buf_x4
xsubckt_9255_sff1_x4 1 2245 0 9185 1438 sff1_x4
xsubckt_8878_sff1_x4 1 2050 0 9547 358 sff1_x4
xsubckt_8355_sff1_x4 1 2137 0 10002 1323 sff1_x4
xsubckt_7194_a2_x2 0 8619 1 719 8422 a2_x2
xsubckt_6869_mx2_x2 0 8804 1 7917 8242 8258 mx2_x2
xsubckt_6841_a3_x2 1 8826 0 8245 702 577 a3_x2
xsubckt_6476_mx2_x2 0 2549 1 8221 2550 2551 mx2_x2
xsubckt_6474_mx2_x2 0 2551 1 858 1875 1523 mx2_x2
xsubckt_6472_mx2_x2 0 2553 1 835 2554 2555 mx2_x2
xsubckt_6285_a2_x2 0 9693 1 2735 2769 a2_x2
xsubckt_6129_mx2_x2 0 2886 1 864 1662 1630 mx2_x2
xsubckt_6085_mx2_x2 0 2929 1 828 2930 2937 mx2_x2
xsubckt_6083_mx2_x2 0 2931 1 835 2932 2933 mx2_x2
xsubckt_6081_mx2_x2 0 2933 1 857 991 959 mx2_x2
xsubckt_5737_a3_x2 1 3265 0 3266 7913 47 a3_x2
xsubckt_5334_mx3_x2 1 0 3567 702 652 3883 3568 3571 mx3_x2
xsubckt_5036_nand2_x0 1 0 3844 3946 8250 nand2_x0
xsubckt_4848_a3_x2 1 3985 0 3986 3991 4142 a3_x2
xsubckt_4193_a2_x2 0 4217 1 4218 4221 a2_x2
xsubckt_1089_oa22_x2 0 7270 1 7271 7275 7793 oa22_x2
xsubckt_916_nand2_x0 1 0 7434 634 1968 nand2_x0
xsubckt_1406_a2_x2 0 6959 1 6960 8413 a2_x2
xsubckt_1601_a2_x2 0 6770 1 6771 245 a2_x2
xcmpt_abc_30082_new_n9107_hfns_2 1 0 3192 3189 buf_x4
xcmpt_abc_30082_new_n9107_hfns_1 1 0 3189 3190 buf_x4
xcmpt_abc_30082_new_n9107_hfns_0 1 0 3189 3191 buf_x4
xsubckt_8790_sff1_x4 1 2073 0 9632 655 sff1_x4
xsubckt_8712_sff1_x4 1 2089 0 9678 542 sff1_x4
xsubckt_7978_sff1_x4 1 2245 0 10379 1768 sff1_x4
xsubckt_7306_ao22_x2 0 9495 1 8538 8536 8535 ao22_x2
xsubckt_7227_nand3_x0 1 0 8595 8596 8604 8609 nand3_x0
xsubckt_6478_mx2_x2 0 2547 1 862 1043 1011 mx2_x2
xsubckt_6089_mx2_x2 0 2925 1 862 1247 1215 mx2_x2
xsubckt_6087_mx2_x2 0 2927 1 863 1311 1279 mx2_x2
xsubckt_5943_mx2_x2 0 3067 1 863 1285 1253 mx2_x2
xsubckt_5941_mx2_x2 0 3069 1 827 3070 3077 mx2_x2
xsubckt_5571_a2_x2 0 9767 1 3381 46 a2_x2
xsubckt_3677_oa22_x2 0 4695 1 4696 4735 5958 oa22_x2
xsubckt_3611_nand3_x0 1 0 4760 4770 4774 770 nand3_x0
xsubckt_2738_nxr2_x1 5619 1 0 5620 5626 nxr2_x1
xsubckt_2669_a2_x2 0 5686 1 5687 5689 a2_x2
xsubckt_1506_nand3_x0 1 0 6859 6887 8062 8063 nand3_x0
xsubckt_1915_a2_x2 0 6481 1 6482 6483 a2_x2
xsubckt_1935_a2_x2 0 6465 1 6466 6467 a2_x2
xcmpt_abc_30082_new_n5495_hfns_2 1 0 6207 6204 buf_x4
xcmpt_abc_30082_new_n5495_hfns_1 1 0 6204 6205 buf_x4
xcmpt_abc_30082_new_n5495_hfns_0 1 0 6204 6206 buf_x4
xcmpt_abc_30082_new_n5499_hfns_2 1 0 6198 6195 buf_x4
xcmpt_abc_30082_new_n5499_hfns_1 1 0 6195 6196 buf_x4
xcmpt_abc_30082_new_n5499_hfns_0 1 0 6195 6197 buf_x4
xspare_buffer_238 1 0 2120 2111 buf_x4
xspare_buffer_237 1 0 2120 2112 buf_x4
xspare_buffer_236 1 0 2120 2113 buf_x4
xspare_buffer_234 1 0 2120 2114 buf_x4
xspare_buffer_233 1 0 2120 2115 buf_x4
xspare_buffer_232 1 0 2120 2116 buf_x4
xspare_buffer_230 1 0 2120 2117 buf_x4
xsubckt_9163_sff1_x4 1 2245 0 9277 1402 sff1_x4
xsubckt_8786_sff1_x4 1 2073 0 9636 618 sff1_x4
xsubckt_8263_sff1_x4 1 2132 0 10094 1303 sff1_x4
xsubckt_5949_mx2_x2 0 3061 1 862 1637 1605 mx2_x2
xsubckt_5947_mx2_x2 0 3063 1 8222 3064 3065 mx2_x2
xsubckt_5945_mx2_x2 0 3065 1 861 1221 1189 mx2_x2
xsubckt_5742_oa22_x2 0 9712 1 7910 7900 3262 oa22_x2
xsubckt_4803_nxr2_x1 4019 1 0 4021 8338 nxr2_x1
xsubckt_4667_nand4_x0 1 0 4122 4124 4129 4143 1921 nand4_x0
xsubckt_4416_mx3_x2 1 0 10149 4181 6295 1280 6197 6201 mx3_x2
xsubckt_4414_mx3_x2 1 0 10151 4181 6295 1252 6216 6220 mx3_x2
xsubckt_4412_mx3_x2 1 0 10153 4181 6295 1254 6236 6240 mx3_x2
xsubckt_3092_nand2_x0 1 0 5271 244 763 nand2_x0
xsubckt_2976_ao22_x2 0 5385 1 5387 5392 7904 ao22_x2
xsubckt_1561_o3_x2 0 6807 1 6809 6810 218 o3_x2
xsubckt_1750_nxr2_x1 6631 1 0 6632 8045 nxr2_x1
xsubckt_9159_sff1_x4 1 2245 0 9281 1406 sff1_x4
xsubckt_9071_sff1_x4 1 2119 0 9359 1354 sff1_x4
xsubckt_8708_sff1_x4 1 2086 0 9682 196 sff1_x4
xsubckt_8620_sff1_x4 1 2169 0 158 95 sff1_x4
xsubckt_5611_nxr2_x1 3352 1 0 3356 8090 nxr2_x1
xsubckt_5169_mx2_x2 0 3720 1 8277 3721 3919 mx2_x2
xsubckt_4877_nxr2_x1 3964 1 0 3968 8352 nxr2_x1
xsubckt_4632_mx2_x2 0 9947 1 4147 6107 1621 mx2_x2
xsubckt_4630_mx2_x2 0 9949 1 4147 6125 1624 mx2_x2
xsubckt_3431_nand3_x0 1 0 4937 4947 4951 770 nand3_x0
xsubckt_1434_o2_x2 0 6926 1 467 468 o2_x2
xsubckt_1843_nand4_x0 1 0 6544 6593 8048 8049 8050 nand4_x0
xspare_buffer_249 1 0 2107 2102 buf_x4
xspare_buffer_248 1 0 2107 2103 buf_x4
xspare_buffer_246 1 0 2107 2104 buf_x4
xspare_buffer_245 1 0 2107 2105 buf_x4
xspare_buffer_244 1 0 2107 2106 buf_x4
xspare_buffer_242 1 0 2120 2108 buf_x4
xspare_buffer_241 1 0 2120 2109 buf_x4
xspare_buffer_240 1 0 2120 2110 buf_x4
xsubckt_8694_sff1_x4 1 2172 0 9696 210 sff1_x4
xsubckt_8259_sff1_x4 1 2119 0 10098 1675 sff1_x4
xsubckt_8171_sff1_x4 1 2205 0 10186 1703 sff1_x4
xsubckt_5414_ao22_x2 0 3492 1 3493 3508 7886 ao22_x2
xsubckt_4638_mx2_x2 0 9941 1 4147 6054 1615 mx2_x2
xsubckt_4636_mx2_x2 0 9943 1 4147 6071 1617 mx2_x2
xsubckt_4634_mx2_x2 0 9945 1 4146 6089 1619 mx2_x2
xsubckt_4378_mx3_x2 1 0 10183 4188 6290 1700 6216 6220 mx3_x2
xsubckt_4376_mx3_x2 1 0 10185 4188 6290 1702 6236 6240 mx3_x2
xsubckt_4245_mx2_x2 0 10305 1 4209 6161 1756 mx2_x2
xsubckt_4243_mx2_x2 0 10307 1 4209 6179 1758 mx2_x2
xsubckt_3454_nxr2_x1 4915 1 0 238 757 nxr2_x1
xsubckt_3251_nand3_x0 1 0 5114 5124 5128 772 nand3_x0
xsubckt_2990_nand2_x0 1 0 5371 5372 780 nand2_x0
xsubckt_2902_nand2_x0 1 0 5457 6011 8115 nand2_x0
xsubckt_2812_nand2_x0 1 0 5546 5547 780 nand2_x0
xsubckt_386_nor3_x0 1 0 7959 7960 7961 7987 nor3_x0
xsubckt_9067_sff1_x4 1 2132 0 9363 1359 sff1_x4
xsubckt_8616_sff1_x4 1 2089 0 164 101 sff1_x4
xsubckt_7802_mx3_x2 1 0 9028 8436 6290 929 6206 6210 mx3_x2
xsubckt_4785_nxr2_x1 4032 1 0 4034 8333 nxr2_x1
xsubckt_4594_mx2_x2 0 9983 1 4151 6142 1498 mx2_x2
xsubckt_4592_mx2_x2 0 9985 1 4151 6162 1500 mx2_x2
xsubckt_4590_mx2_x2 0 9987 1 4151 6179 1502 mx2_x2
xsubckt_4249_mx2_x2 0 10301 1 4208 6124 1752 mx2_x2
xsubckt_4247_mx2_x2 0 10303 1 4208 6143 1754 mx2_x2
xsubckt_3712_mx2_x2 0 4661 1 8028 4662 4663 mx2_x2
xsubckt_3710_mx2_x2 0 4663 1 805 915 883 mx2_x2
xsubckt_850_oa22_x2 0 7497 1 7498 7614 8284 oa22_x2
xsubckt_518_a3_x2 1 7820 0 7821 7833 7834 a3_x2
xspare_buffer_258 1 0 2107 2095 buf_x4
xspare_buffer_257 1 0 2107 2096 buf_x4
xspare_buffer_256 1 0 2107 2097 buf_x4
xspare_buffer_254 1 0 2107 2098 buf_x4
xspare_buffer_253 1 0 2107 2099 buf_x4
xspare_buffer_252 1 0 2107 2100 buf_x4
xspare_buffer_250 1 0 2107 2101 buf_x4
xsubckt_9424_sff1_x4 1 2222 0 9019 920 sff1_x4
xsubckt_8167_sff1_x4 1 2095 0 10190 1719 sff1_x4
xsubckt_4598_mx2_x2 0 9979 1 4152 6107 1493 mx2_x2
xsubckt_4596_mx2_x2 0 9981 1 4152 6125 1496 mx2_x2
xsubckt_3718_mx2_x2 0 4655 1 805 1651 1619 mx2_x2
xsubckt_3716_mx2_x2 0 4657 1 8028 4658 4659 mx2_x2
xsubckt_3714_mx2_x2 0 4659 1 805 1491 1459 mx2_x2
xsubckt_3692_nand2_x0 1 0 4681 233 752 nand2_x0
xsubckt_3514_nand2_x0 1 0 4856 4857 4862 nand2_x0
xsubckt_3071_nand3_x0 1 0 5291 5301 5305 770 nand3_x0
xsubckt_2896_nand3_x0 1 0 5463 5468 5472 770 nand3_x0
xsubckt_2718_nand3_x0 1 0 5638 5658 5662 8012 nand3_x0
xsubckt_1693_oa22_x2 0 6684 1 6686 6692 6939 oa22_x2
xcmpt_latched_stalu_hfns_4 1 0 548 543 buf_x4
xcmpt_latched_stalu_hfns_3 1 0 543 544 buf_x4
xcmpt_latched_stalu_hfns_2 1 0 543 545 buf_x4
xcmpt_latched_stalu_hfns_1 1 0 543 546 buf_x4
xcmpt_latched_stalu_hfns_0 1 0 543 547 buf_x4
xsubckt_9498_sff1_x4 1 2113 0 8945 1837 sff1_x4
xsubckt_8598_sff1_x4 1 2047 0 9759 1995 sff1_x4
xsubckt_8524_sff1_x4 1 2179 0 9833 126 sff1_x4
xsubckt_8001_sff1_x4 1 2108 0 10356 1774 sff1_x4
xsubckt_7766_mx3_x2 1 0 9062 8441 6288 933 6226 6230 mx3_x2
xsubckt_7633_mx2_x2 0 9186 1 8460 6189 1439 mx2_x2
xsubckt_7291_nand2_x0 1 0 8547 712 653 nand2_x0
xsubckt_7273_nor2_x0 1 0 8561 8562 8563 nor2_x0
xsubckt_7240_mx2_x2 0 9509 1 8832 8587 752 mx2_x2
xsubckt_6977_oa22_x2 0 9636 1 8760 8753 8727 oa22_x2
xsubckt_5186_nand2_x0 1 0 9828 3705 3718 nand2_x0
xsubckt_4126_nand2_x0 1 0 4254 4255 783 nand2_x0
xsubckt_3283_mx2_x2 0 5083 1 804 1179 1083 mx2_x2
xsubckt_130_inv_x0 1 0 374 8269 inv_x0
xspare_buffer_268 1 0 2094 2067 buf_x4
xspare_buffer_264 1 0 2094 2080 buf_x4
xspare_buffer_260 1 0 2094 2093 buf_x4
xsubckt_9332_sff1_x4 1 2129 0 9108 1008 sff1_x4
xsubckt_8955_sff1_x4 1 2203 0 9470 1595 sff1_x4
xsubckt_8432_sff1_x4 1 2057 0 9925 1975 sff1_x4
xsubckt_8075_sff1_x4 1 2142 0 10282 1159 sff1_x4
xsubckt_7768_mx3_x2 1 0 9060 8441 6288 961 6206 6210 mx3_x2
xsubckt_7639_mx2_x2 0 9180 1 8460 6134 1433 mx2_x2
xsubckt_7637_mx2_x2 0 9182 1 8460 6151 1435 mx2_x2
xsubckt_7635_mx2_x2 0 9184 1 8460 6169 1437 mx2_x2
xsubckt_7246_mx2_x2 0 9507 1 8831 8583 754 mx2_x2
xsubckt_3851_nand3_x0 1 0 4524 4534 4538 771 nand3_x0
xsubckt_3287_mx2_x2 0 5079 1 803 1787 1755 mx2_x2
xsubckt_3154_nand2_x0 1 0 5210 5211 5216 nand2_x0
xsubckt_2750_mx2_x2 0 5607 1 803 902 870 mx2_x2
xsubckt_1049_nand2_x0 1 0 7308 634 1960 nand2_x0
xsubckt_881_a2_x2 0 7467 1 7468 7474 a2_x2
xsubckt_136_inv_x0 1 0 713 8263 inv_x0
xsubckt_134_inv_x0 1 0 380 8265 inv_x0
xsubckt_132_inv_x0 1 0 377 8267 inv_x0
xsubckt_9328_sff1_x4 1 2209 0 9112 1012 sff1_x4
xsubckt_7593_mx2_x2 0 9224 1 8465 6245 1063 mx2_x2
xsubckt_7591_mx2_x2 0 9226 1 8465 6258 1065 mx2_x2
xsubckt_6713_mx2_x2 0 8939 1 8207 8940 2334 mx2_x2
xsubckt_6711_mx2_x2 0 8941 1 8215 2321 2324 mx2_x2
xsubckt_5301_a3_x2 1 3598 0 42 141 8397 a3_x2
xsubckt_5273_a4_x2 0 3624 1 3663 3894 3897 3900 a4_x2
xsubckt_3671_nand3_x0 1 0 4701 4711 4715 772 nand3_x0
xsubckt_2756_mx2_x2 0 5601 1 8031 5602 5603 mx2_x2
xsubckt_2754_mx2_x2 0 5603 1 808 1030 998 mx2_x2
xsubckt_2752_mx2_x2 0 5605 1 8031 5606 5607 mx2_x2
xsubckt_708_nand2_x0 1 0 7635 7991 1980 nand2_x0
xsubckt_618_nand2_x0 1 0 7721 629 1948 nand2_x0
xsubckt_138_inv_x0 1 0 393 8261 inv_x0
xsubckt_430_ao22_x2 0 7911 1 7913 8305 506 ao22_x2
xsubckt_1212_nand2_x0 1 0 7153 7154 7158 nand2_x0
xsubckt_1919_nand2_x0 1 0 6478 445 330 nand2_x0
xsubckt_2365_mx2_x2 0 5991 1 808 1443 1411 mx2_x2
xspare_buffer_278 1 0 2093 2090 buf_x4
xspare_buffer_277 1 0 2093 2091 buf_x4
xspare_buffer_276 1 0 2093 2092 buf_x4
xspare_buffer_272 1 0 2094 2054 buf_x4
xsubckt_9240_sff1_x4 1 2137 0 9200 1067 sff1_x4
xsubckt_8863_sff1_x4 1 2060 0 9562 366 sff1_x4
xsubckt_8428_sff1_x4 1 2060 0 9929 1921 sff1_x4
xsubckt_8340_sff1_x4 1 2212 0 10017 1340 sff1_x4
xsubckt_7599_mx2_x2 0 9218 1 8465 6189 1087 mx2_x2
xsubckt_7170_oa22_x2 0 8637 1 7998 7997 3285 oa22_x2
xsubckt_7072_a2_x2 0 8670 1 8683 8837 a2_x2
xsubckt_6719_mx2_x2 0 8934 1 864 907 875 mx2_x2
xsubckt_6358_oa22_x2 0 2664 1 40 1905 204 oa22_x2
xsubckt_6328_mx2_x2 0 2693 1 835 2694 2695 mx2_x2
xsubckt_6326_mx2_x2 0 2695 1 864 1720 1688 mx2_x2
xsubckt_6324_mx2_x2 0 2697 1 864 1848 1816 mx2_x2
xsubckt_5419_nxr2_x1 3488 1 0 3507 3865 nxr2_x1
xsubckt_5234_a2_x2 0 3660 1 3661 3662 a2_x2
xsubckt_4658_a4_x2 0 4129 1 1977 1976 1965 1954 a4_x2
xsubckt_3142_a2_x2 0 5221 1 5222 5224 a2_x2
xsubckt_2758_mx2_x2 0 5599 1 807 1862 1510 mx2_x2
xsubckt_1122_nand2_x0 1 0 7239 7990 2020 nand2_x0
xsubckt_1109_a2_x2 0 7251 1 7252 7258 a2_x2
xsubckt_1074_oa22_x2 0 7285 1 7303 7302 7301 oa22_x2
xsubckt_803_xr2_x1 7542 0 1 764 89 xr2_x1
xcmpt_zero_0 1 0 698 zero_x1
xcmpt_zero_1 1 0 697 zero_x1
xcmpt_zero_2 1 0 686 zero_x1
xcmpt_zero_3 1 0 675 zero_x1
xcmpt_zero_4 1 0 672 zero_x1
xcmpt_zero_5 1 0 671 zero_x1
xcmpt_zero_6 1 0 670 zero_x1
xcmpt_zero_7 1 0 669 zero_x1
xcmpt_zero_8 1 0 668 zero_x1
xcmpt_zero_9 1 0 667 zero_x1
xsubckt_1386_nand3_x0 1 0 6979 7168 196 8075 nand3_x0
xsubckt_2367_mx2_x2 0 5989 1 791 5990 5991 mx2_x2
xsubckt_2369_mx2_x2 0 5987 1 806 1603 1571 mx2_x2
xsubckt_9236_sff1_x4 1 2129 0 9204 1072 sff1_x4
xsubckt_7963_sff1_x4 1 2166 0 10394 235 sff1_x4
xsubckt_6914_ao22_x2 0 8774 1 707 8278 641 ao22_x2
xsubckt_6675_mx2_x2 0 2355 1 8215 2356 2359 mx2_x2
xsubckt_6673_mx2_x2 0 2357 1 843 1422 1390 mx2_x2
xsubckt_6671_mx2_x2 0 2359 1 8226 2360 2361 mx2_x2
xsubckt_6280_mx2_x2 0 2739 1 826 2740 2747 mx2_x2
xsubckt_5079_a2_x2 0 3804 1 3936 725 a2_x2
xsubckt_3491_nand3_x0 1 0 4878 4888 4892 771 nand3_x0
xsubckt_3313_nand3_x0 1 0 5053 5073 5077 8012 nand3_x0
xsubckt_2799_nand2_x0 1 0 5559 5560 7904 nand2_x0
xsubckt_2507_a2_x2 0 5845 1 237 756 a2_x2
xsubckt_1090_a2_x2 0 7269 1 7270 7276 a2_x2
xsubckt_658_oa22_x2 0 7683 1 7801 7804 8128 oa22_x2
xsubckt_1344_a2_x2 0 7021 1 7022 7023 a2_x2
xsubckt_1969_mx3_x2 1 0 489 8001 6449 237 112 144 mx3_x2
xspare_buffer_289 1 0 2093 2082 buf_x4
xspare_buffer_288 1 0 2093 2083 buf_x4
xspare_buffer_286 1 0 2093 2084 buf_x4
xspare_buffer_285 1 0 2093 2085 buf_x4
xspare_buffer_284 1 0 2093 2086 buf_x4
xspare_buffer_282 1 0 2093 2087 buf_x4
xspare_buffer_281 1 0 2093 2088 buf_x4
xspare_buffer_280 1 0 2093 2089 buf_x4
xsubckt_8859_sff1_x4 1 2053 0 9566 579 sff1_x4
xsubckt_8771_sff1_x4 1 2070 0 9651 641 sff1_x4
xsubckt_8336_sff1_x4 1 2198 0 10021 1344 sff1_x4
xsubckt_7959_sff1_x4 1 2166 0 10398 240 sff1_x4
xsubckt_6677_mx2_x2 0 2353 1 8207 2354 2369 mx2_x2
xsubckt_6288_mx2_x2 0 2732 1 841 1849 1817 mx2_x2
xsubckt_5751_mx2_x2 0 3254 1 841 1155 1123 mx2_x2
xsubckt_4993_oa22_x2 0 9847 1 7884 3879 3881 oa22_x2
xsubckt_4814_a2_x2 0 9894 1 4011 45 a2_x2
xsubckt_4035_oa22_x2 0 4343 1 4344 4383 5957 oa22_x2
xsubckt_3754_nand2_x0 1 0 4620 4621 4626 nand2_x0
xsubckt_3691_a2_x2 0 4682 1 233 752 a2_x2
xsubckt_3135_oa22_x2 0 5228 1 5229 5230 8017 oa22_x2
xsubckt_3133_nand3_x0 1 0 5230 5250 5254 8011 nand3_x0
xsubckt_857_ao22_x2 0 7490 1 7491 7495 7795 ao22_x2
xsubckt_763_xr2_x1 7580 0 1 766 91 xr2_x1
xsubckt_9144_sff1_x4 1 2139 0 9296 1099 sff1_x4
xsubckt_7883_buf_x1 1 0 1889 8996 buf_x1
xsubckt_7881_buf_x1 1 0 1861 8998 buf_x1
xsubckt_5757_mx2_x2 0 3248 1 841 1603 1571 mx2_x2
xsubckt_5755_mx2_x2 0 3250 1 841 1507 1475 mx2_x2
xsubckt_5753_mx2_x2 0 3252 1 8212 3253 3256 mx2_x2
xsubckt_5338_nand2_x0 1 0 3564 3879 8279 nand2_x0
xsubckt_4989_oa22_x2 0 9848 1 7886 3882 3884 oa22_x2
xsubckt_4894_a2_x2 0 9872 1 3953 44 a2_x2
xsubckt_4699_a2_x2 0 4098 1 1973 1972 a2_x2
xspare_buffer_298 1 0 2080 2074 buf_x4
xspare_buffer_297 1 0 2080 2075 buf_x4
xspare_buffer_296 1 0 2080 2076 buf_x4
xspare_buffer_294 1 0 2080 2077 buf_x4
xspare_buffer_293 1 0 2080 2078 buf_x4
xspare_buffer_292 1 0 2080 2079 buf_x4
xspare_buffer_290 1 0 2093 2081 buf_x4
xsubckt_9501_sff1_x4 1 2060 0 8942 364 sff1_x4
xsubckt_8767_sff1_x4 1 2070 0 9655 665 sff1_x4
xsubckt_8244_sff1_x4 1 2209 0 10113 1692 sff1_x4
xsubckt_7889_buf_x1 1 0 1883 8990 buf_x1
xsubckt_7887_buf_x1 1 0 1885 8992 buf_x1
xsubckt_7885_buf_x1 1 0 1887 8994 buf_x1
xsubckt_6900_nand3_x0 1 0 8784 8244 579 702 nand3_x0
xsubckt_6896_ao22_x2 0 8787 1 707 8279 626 ao22_x2
xsubckt_5922_ao22_x2 0 3087 1 573 568 739 ao22_x2
xsubckt_5759_mx2_x2 0 3246 1 832 3247 3248 mx2_x2
xsubckt_5158_nand2_x0 1 0 9830 3731 3744 nand2_x0
xsubckt_4883_nand3_x0 1 0 3960 3966 1922 1920 nand3_x0
xsubckt_4858_nxr2_x1 3977 1 0 3979 8348 nxr2_x1
xsubckt_4619_mx3_x2 1 0 9960 4149 6292 1605 6226 6230 mx3_x2
xsubckt_4440_mx2_x2 0 10127 1 4173 6277 1698 mx2_x2
xsubckt_3913_nand3_x0 1 0 4463 4468 4472 772 nand3_x0
xsubckt_2778_nand3_x0 1 0 5579 5580 5584 772 nand3_x0
xsubckt_2514_nand2_x0 1 0 5838 5839 7856 nand2_x0
xsubckt_50_inv_x0 1 0 64 8361 inv_x0
xsubckt_52_inv_x0 1 0 66 8359 inv_x0
xsubckt_417_nand3_x0 1 0 7926 7927 7936 7942 nand3_x0
xsubckt_503_a4_x2 0 7833 1 7840 7866 7936 7942 a4_x2
xsubckt_2157_nand4_x0 1 0 6301 6303 6305 6313 7885 nand4_x0
xsubckt_9052_sff1_x4 1 2246 0 9378 1375 sff1_x4
xsubckt_8675_sff1_x4 1 2083 0 9714 506 sff1_x4
xsubckt_8601_sff1_x4 1 2047 0 9756 1992 sff1_x4
xsubckt_7181_ao22_x2 0 8628 1 3285 3288 323 ao22_x2
xsubckt_6947_nor3_x0 1 0 8748 8749 8764 8822 nor3_x0
xsubckt_5068_nand2_x0 1 0 3814 3815 3817 nand2_x0
xsubckt_4897_oa22_x2 0 9871 1 7884 3951 3952 oa22_x2
xsubckt_4444_mx2_x2 0 10123 1 4174 6252 1672 mx2_x2
xsubckt_4442_mx2_x2 0 10125 1 4174 6266 1676 mx2_x2
xsubckt_3394_nand2_x0 1 0 4974 4975 4980 nand2_x0
xsubckt_997_oa22_x2 0 173 1 7371 7370 7358 oa22_x2
xsubckt_948_nand2_x0 1 0 7404 7405 1894 nand2_x0
xsubckt_58_inv_x0 1 0 1922 8353 inv_x0
xsubckt_56_inv_x0 1 0 1918 8355 inv_x0
xsubckt_54_inv_x0 1 0 81 8357 inv_x0
xsubckt_9048_sff1_x4 1 2198 0 9382 1349 sff1_x4
xsubckt_8152_sff1_x4 1 2251 0 10205 1464 sff1_x4
xsubckt_4059_mx2_x2 0 4320 1 812 1165 1069 mx2_x2
xsubckt_4055_mx2_x2 0 4324 1 812 1037 1005 mx2_x2
xsubckt_3733_nand3_x0 1 0 4640 4660 4664 8012 nand3_x0
xsubckt_3520_mx2_x2 0 4850 1 788 4851 4852 mx2_x2
xsubckt_838_nor2_x0 1 0 7508 7509 7515 nor2_x0
xsubckt_768_nand2_x0 1 0 7575 7810 429 nand2_x0
xsubckt_1452_nand2_x0 1 0 6909 6947 7044 nand2_x0
xsubckt_9483_sff1_x4 1 2232 0 8960 1853 sff1_x4
xsubckt_9405_sff1_x4 1 2096 0 9038 931 sff1_x4
xsubckt_8583_sff1_x4 1 2060 0 9774 2012 sff1_x4
xsubckt_8148_sff1_x4 1 2212 0 10209 1468 sff1_x4
xsubckt_8060_sff1_x4 1 2142 0 10297 1747 sff1_x4
xsubckt_7177_ao22_x2 0 9527 1 8632 8633 8634 ao22_x2
xsubckt_6969_nor2_x0 1 0 8732 8764 8810 nor2_x0
xsubckt_3553_nand3_x0 1 0 4817 4837 4841 8012 nand3_x0
xsubckt_3526_mx2_x2 0 4844 1 812 1718 1686 mx2_x2
xsubckt_3524_mx2_x2 0 4846 1 8034 4847 4848 mx2_x2
xsubckt_3522_mx2_x2 0 4848 1 812 1878 1526 mx2_x2
xsubckt_700_nxr2_x1 7643 1 0 739 64 nxr2_x1
xsubckt_504_a2_x2 0 7832 1 7833 7834 a2_x2
xsubckt_1358_nand3_x0 1 0 7007 7099 210 8102 nand3_x0
xsubckt_2353_nor4_x0 1 0 6013 616 618 617 619 nor4_x0
xsubckt_9479_sff1_x4 1 2192 0 8964 1857 sff1_x4
xsubckt_9391_sff1_x4 1 2232 0 9052 953 sff1_x4
xsubckt_8940_sff1_x4 1 2100 0 9485 1602 sff1_x4
xsubckt_8505_sff1_x4 1 2156 0 9852 80 sff1_x4
xsubckt_7832_mx2_x2 0 8968 1 8429 6245 1831 mx2_x2
xsubckt_7830_mx2_x2 0 8970 1 8429 6258 1833 mx2_x2
xsubckt_7242_nand3_x0 1 0 8585 8586 8604 8609 nand3_x0
xsubckt_5178_oa22_x2 0 3712 1 3727 3725 3726 oa22_x2
xsubckt_5047_nand3_x0 1 0 3834 3942 3945 3948 nand3_x0
xsubckt_3528_mx2_x2 0 4842 1 788 4843 4844 mx2_x2
xsubckt_3482_mx2_x2 0 4887 1 812 1240 1208 mx2_x2
xsubckt_3480_mx2_x2 0 4889 1 8035 4890 4891 mx2_x2
xsubckt_3373_nand3_x0 1 0 4994 5014 5018 8011 nand3_x0
xsubckt_2600_mx2_x2 0 5754 1 776 5755 5762 mx2_x2
xsubckt_1092_nand2_x0 1 0 168 7268 7280 nand2_x0
xsubckt_931_nand2_x0 1 0 7420 239 1898 nand2_x0
xsubckt_564_a2_x2 0 7773 1 7991 2040 a2_x2
xsubckt_331_inv_x0 1 0 202 8045 inv_x0
xsubckt_389_a2_x2 0 7956 1 7957 7958 a2_x2
xsubckt_9313_sff1_x4 1 2198 0 9127 998 sff1_x4
xsubckt_8579_sff1_x4 1 2047 0 9778 2016 sff1_x4
xsubckt_8491_sff1_x4 1 2169 0 9866 65 sff1_x4
xsubckt_8056_sff1_x4 1 2216 0 10301 1752 sff1_x4
xsubckt_7859_nand3_x0 1 0 8425 2 8304 47 nand3_x0
xsubckt_7838_mx2_x2 0 8962 1 8428 6189 1855 mx2_x2
xsubckt_7445_mx2_x2 0 9362 1 8489 6044 1358 mx2_x2
xsubckt_7443_mx2_x2 0 9364 1 8489 6061 1360 mx2_x2
xsubckt_7441_mx2_x2 0 9366 1 8490 6081 1362 mx2_x2
xsubckt_5600_a4_x2 0 3360 1 3367 1994 1995 1997 a4_x2
xsubckt_5211_ao22_x2 0 3681 1 3682 3683 3687 ao22_x2
xsubckt_3879_mx2_x2 0 4497 1 789 4498 4499 mx2_x2
xsubckt_3877_mx2_x2 0 4499 1 813 976 944 mx2_x2
xsubckt_3488_mx2_x2 0 4881 1 8035 4882 4883 mx2_x2
xsubckt_3486_mx2_x2 0 4883 1 814 1368 1336 mx2_x2
xsubckt_3484_mx2_x2 0 4885 1 8035 4886 4887 mx2_x2
xsubckt_2934_nand2_x0 1 0 5426 5427 8023 nand2_x0
xsubckt_927_nand3_x0 1 0 7424 7425 7426 1902 nand3_x0
xsubckt_751_nand2_x0 1 0 7591 2005 637 nand2_x0
xsubckt_333_inv_x0 1 0 204 8043 inv_x0
xsubckt_335_inv_x0 1 0 206 8041 inv_x0
xsubckt_337_inv_x0 1 0 208 8039 inv_x0
xsubckt_498_nand2_x0 1 0 7838 7839 7933 nand2_x0
xsubckt_1221_a4_x2 0 7144 1 7145 7149 7154 7158 a4_x2
xsubckt_1241_a4_x2 0 7124 1 7125 7129 7134 7138 a4_x2
xsubckt_1582_oa22_x2 0 6788 1 6803 6796 6797 oa22_x2
xsubckt_1869_ao22_x2 0 6520 1 6539 6528 6530 ao22_x2
xsubckt_9387_sff1_x4 1 2232 0 9056 957 sff1_x4
xsubckt_8936_sff1_x4 1 2083 0 9489 745 sff1_x4
xsubckt_8413_sff1_x4 1 2145 0 9944 1618 sff1_x4
xsubckt_7794_mx2_x2 0 9036 1 8434 6273 919 mx2_x2
xsubckt_7792_mx2_x2 0 9038 1 8434 6283 931 mx2_x2
xsubckt_7447_mx2_x2 0 9360 1 8490 6027 1355 mx2_x2
xsubckt_6521_mx2_x2 0 2505 1 866 1234 1202 mx2_x2
xsubckt_5620_a4_x2 0 3346 1 3353 1988 1989 1990 a4_x2
xsubckt_5465_a4_x2 0 3453 1 3459 1978 1979 1980 a4_x2
xsubckt_4711_a4_x2 0 4088 1 4092 4102 1973 1972 a4_x2
xsubckt_4262_a4_x2 0 4206 1 6306 6309 8007 555 a4_x2
xsubckt_3735_oa22_x2 0 4638 1 4639 4640 8017 oa22_x2
xsubckt_3193_nand3_x0 1 0 5171 5191 5195 8011 nand3_x0
xsubckt_3099_mx2_x2 0 5264 1 815 1054 1022 mx2_x2
xsubckt_3015_nand3_x0 1 0 5346 5351 5355 771 nand3_x0
xsubckt_2603_ao22_x2 0 5751 1 5800 5796 5797 ao22_x2
xsubckt_291_inv_x0 1 0 2024 8085 inv_x0
xsubckt_293_inv_x0 1 0 231 8083 inv_x0
xsubckt_339_inv_x0 1 0 791 8037 inv_x0
xsubckt_464_o3_x2 0 319 1 658 622 623 o3_x2
xsubckt_1346_ao22_x2 0 7019 1 7020 7027 7065 ao22_x2
xsubckt_1451_nxr2_x1 6910 1 0 6911 6917 nxr2_x1
xsubckt_1539_nxr2_x1 6828 1 0 6829 192 nxr2_x1
xsubckt_1962_nand2_x0 1 0 446 6454 6469 nand2_x0
xsubckt_2217_mx2_x2 0 10435 1 6299 6188 1823 mx2_x2
xsubckt_2223_nand3_x0 1 0 6181 6182 6184 6295 nand3_x0
xsubckt_2249_a4_x2 0 6147 1 6174 86 85 84 a4_x2
xsubckt_9309_sff1_x4 1 2103 0 9131 1004 sff1_x4
xsubckt_9221_sff1_x4 1 2189 0 9219 1088 sff1_x4
xsubckt_8487_sff1_x4 1 2169 0 9870 81 sff1_x4
xsubckt_8409_sff1_x4 1 2215 0 9948 1622 sff1_x4
xsubckt_7798_mx2_x2 0 9032 1 8433 6245 903 mx2_x2
xsubckt_7796_mx2_x2 0 9034 1 8433 6258 905 mx2_x2
xsubckt_6527_mx2_x2 0 2499 1 8223 2500 2501 mx2_x2
xsubckt_6525_mx2_x2 0 2501 1 850 1650 1618 mx2_x2
xsubckt_6523_mx2_x2 0 2503 1 8223 2504 2505 mx2_x2
xsubckt_6134_mx2_x2 0 2881 1 8223 2882 2883 mx2_x2
xsubckt_6132_mx2_x2 0 2883 1 850 1502 1470 mx2_x2
xsubckt_6130_mx2_x2 0 2885 1 850 1598 1566 mx2_x2
xsubckt_5485_a4_x2 0 3439 1 3446 2034 2035 2036 a4_x2
xsubckt_5390_nxr2_x1 3515 1 0 3531 3870 nxr2_x1
xsubckt_4791_a4_x2 0 4028 1 4029 4041 4054 4065 a4_x2
xsubckt_2835_oa22_x2 0 5523 1 5524 5525 776 oa22_x2
xsubckt_2664_nand2_x0 1 0 5691 6012 8130 nand2_x0
xsubckt_1055_oa22_x2 0 7303 1 7321 7319 7320 oa22_x2
xsubckt_295_inv_x0 1 0 2022 8081 inv_x0
xsubckt_297_inv_x0 1 0 1986 8079 inv_x0
xsubckt_299_inv_x0 1 0 1984 8077 inv_x0
xsubckt_1222_a2_x2 0 7143 1 7144 7163 a2_x2
xsubckt_1448_a3_x2 1 6913 0 6915 6916 237 a3_x2
xsubckt_2173_mx2_x2 0 10444 1 6300 6266 1804 mx2_x2
xsubckt_2175_mx2_x2 0 6262 1 547 98 2262 mx2_x2
xsubckt_2177_mx2_x2 0 6260 1 6297 6261 6262 mx2_x2
xsubckt_9295_sff1_x4 1 2216 0 9145 1045 sff1_x4
xsubckt_8844_sff1_x4 1 2242 0 9581 1530 sff1_x4
xsubckt_8321_sff1_x4 1 2112 0 10036 1646 sff1_x4
xsubckt_7944_sff1_x4 1 2086 0 10413 237 sff1_x4
xsubckt_7235_nand2_x0 1 0 8590 7976 382 nand2_x0
xsubckt_6529_mx2_x2 0 2497 1 849 1426 1394 mx2_x2
xsubckt_6483_mx2_x2 0 2542 1 849 1299 1267 mx2_x2
xsubckt_6481_mx2_x2 0 2544 1 828 2545 2552 mx2_x2
xsubckt_6136_mx2_x2 0 2879 1 828 2880 2887 mx2_x2
xsubckt_6092_mx2_x2 0 2922 1 8212 2923 2926 mx2_x2
xsubckt_6090_mx2_x2 0 2924 1 849 1151 1119 mx2_x2
xsubckt_5439_oa22_x2 0 9810 1 7885 3470 3476 oa22_x2
xsubckt_5192_a2_x2 0 3699 1 3912 733 a2_x2
xsubckt_4918_a3_x2 1 3935 0 53 64 8399 a3_x2
xsubckt_4048_a2_x2 0 4331 1 227 746 a2_x2
xsubckt_3973_nand3_x0 1 0 4404 4424 4428 8013 nand3_x0
xsubckt_3208_oa22_x2 0 5157 1 5215 5212 5214 oa22_x2
xsubckt_407_ao22_x2 0 7938 1 216 249 331 ao22_x2
xsubckt_1262_a2_x2 0 7103 1 7104 7143 a2_x2
xsubckt_1282_a2_x2 0 7083 1 213 246 a2_x2
xsubckt_1447_nxr2_x1 6914 1 0 6925 8066 nxr2_x1
xsubckt_1868_nand3_x0 1 0 6521 6529 6538 6546 nand3_x0
xsubckt_9217_sff1_x4 1 2189 0 9223 1062 sff1_x4
xsubckt_8752_sff1_x4 1 2150 0 9670 654 sff1_x4
xsubckt_8395_sff1_x4 1 2214 0 9962 1607 sff1_x4
xsubckt_8317_sff1_x4 1 2218 0 10040 1650 sff1_x4
xsubckt_6609_a2_x2 0 9684 1 2420 2454 a2_x2
xsubckt_6489_mx2_x2 0 2536 1 853 1651 1619 mx2_x2
xsubckt_6487_mx2_x2 0 2538 1 8223 2539 2540 mx2_x2
xsubckt_6485_mx2_x2 0 2540 1 853 1235 1203 mx2_x2
xsubckt_6098_mx2_x2 0 2916 1 8224 2917 2918 mx2_x2
xsubckt_6096_mx2_x2 0 2918 1 852 1503 1471 mx2_x2
xsubckt_6094_mx2_x2 0 2920 1 852 1599 1567 mx2_x2
xsubckt_5950_mx2_x2 0 3060 1 852 1573 1541 mx2_x2
xsubckt_5212_mx2_x2 0 3680 1 8278 3681 3910 mx2_x2
xsubckt_5203_nand2_x0 1 0 3689 3703 3909 nand2_x0
xsubckt_4978_a3_x2 1 3890 0 51 78 8398 a3_x2
xsubckt_4958_a3_x2 1 3905 0 52 84 8398 a3_x2
xsubckt_4938_a3_x2 1 3920 0 52 89 8398 a3_x2
xsubckt_4738_ao22_x2 0 4068 1 4070 8322 1961 ao22_x2
xsubckt_4732_a2_x2 0 9914 1 4073 51 a2_x2
xsubckt_3803_a2_x2 0 4571 1 4572 4577 a2_x2
xsubckt_3793_nand3_x0 1 0 4581 4601 4605 8012 nand3_x0
xsubckt_2739_a2_x2 0 5618 1 5619 7904 a2_x2
xsubckt_1114_xr2_x1 7247 0 1 747 72 xr2_x1
xsubckt_962_xr2_x1 7391 0 1 755 80 xr2_x1
xsubckt_1410_nand4_x0 1 0 6955 6959 6964 7104 7143 nand4_x0
xsubckt_1731_a2_x2 0 6649 1 6650 8415 a2_x2
xsubckt_2220_oa22_x2 0 6184 1 6203 89 88 oa22_x2
xsubckt_9125_sff1_x4 1 2235 0 9315 1120 sff1_x4
xsubckt_7212_o2_x2 0 8606 1 564 577 o2_x2
xsubckt_6682_oa22_x2 0 2349 1 50 1906 195 oa22_x2
xsubckt_5956_mx2_x2 0 3054 1 826 3055 3062 mx2_x2
xsubckt_5954_mx2_x2 0 3056 1 8224 3057 3058 mx2_x2
xsubckt_5952_mx2_x2 0 3058 1 851 1477 1445 mx2_x2
xsubckt_5347_oa22_x2 0 3555 1 3883 3886 8268 oa22_x2
xsubckt_4998_a3_x2 1 3875 0 50 73 8398 a3_x2
xsubckt_4843_nxr2_x1 3988 1 0 3990 8344 nxr2_x1
xsubckt_4792_a2_x2 0 4027 1 4028 4143 a2_x2
xsubckt_3863_a2_x2 0 4512 1 4513 4518 a2_x2
xsubckt_550_nand3_x0 1 0 7786 7787 7788 7789 nand3_x0
xsubckt_2294_oa22_x2 0 6090 1 6091 6092 6094 oa22_x2
xsubckt_9199_sff1_x4 1 2219 0 9241 1205 sff1_x4
xsubckt_8748_sff1_x4 1 2150 0 2296 2264 sff1_x4
xsubckt_8660_sff1_x4 1 2185 0 9729 529 sff1_x4
xsubckt_8225_sff1_x4 1 2136 0 10132 1262 sff1_x4
xsubckt_7304_nand3_x0 1 0 8536 8537 8245 703 nand3_x0
xsubckt_5294_nxr2_x1 3604 1 0 3892 730 nxr2_x1
xsubckt_5266_nor2_x0 1 0 3630 3631 3633 nor2_x0
xsubckt_4882_oa22_x2 0 3961 1 3966 1922 1920 oa22_x2
xsubckt_4834_nand4_x0 1 0 3995 3998 4004 4009 1936 nand4_x0
xsubckt_2850_ao22_x2 0 5509 1 5567 5565 5562 ao22_x2
xsubckt_1076_xr2_x1 7283 0 1 749 74 xr2_x1
xsubckt_991_nand2_x0 1 0 7363 1992 638 nand2_x0
xsubckt_813_nand2_x0 1 0 7532 633 1973 nand2_x0
xsubckt_746_ao22_x2 0 7596 1 7598 7601 1901 ao22_x2
xsubckt_460_nand3_x0 1 0 7872 7900 7910 7967 nand3_x0
xsubckt_1329_o2_x2 0 7036 1 467 217 o2_x2
xsubckt_2216_oa22_x2 0 6190 1 6191 6192 6193 oa22_x2
xcmpt_abc_30082_new_n3702_hfns_2 1 0 7932 7929 buf_x4
xcmpt_abc_30082_new_n3702_hfns_1 1 0 7929 7930 buf_x4
xcmpt_abc_30082_new_n3702_hfns_0 1 0 7929 7931 buf_x4
xsubckt_9033_sff1_x4 1 2079 0 9397 381 sff1_x4
xsubckt_8299_sff1_x4 1 2214 0 10058 1639 sff1_x4
xsubckt_6354_ao22_x2 0 2667 1 573 568 757 ao22_x2
xsubckt_5923_o2_x2 0 3086 1 3087 7930 o2_x2
xsubckt_5100_nor2_x0 1 0 3784 3785 7881 nor2_x0
xsubckt_4744_nand4_x0 1 0 4063 4066 4078 4091 4142 nand4_x0
xsubckt_4723_nor2_x0 1 0 4079 4083 1966 nor2_x0
xsubckt_4641_mx2_x2 0 9938 1 4147 6027 1611 mx2_x2
xsubckt_4252_mx2_x2 0 10298 1 4208 6098 1748 mx2_x2
xsubckt_4250_mx2_x2 0 10300 1 4208 6115 1750 mx2_x2
xsubckt_1064_nand2_x0 1 0 7294 231 1897 nand2_x0
xsubckt_723_nand2_x0 1 0 7621 7799 328 nand2_x0
xsubckt_1708_nxr2_x1 6670 1 0 6671 6678 nxr2_x1
xsubckt_8656_sff1_x4 1 2185 0 9733 533 sff1_x4
xsubckt_8133_sff1_x4 1 2095 0 10224 1475 sff1_x4
xsubckt_7320_oa22_x2 0 8523 1 702 8244 740 oa22_x2
xsubckt_6954_nor2_x0 1 0 8743 8764 8778 nor2_x0
xsubckt_6840_nor3_x0 1 0 8827 395 394 393 nor3_x0
xsubckt_4992_mx2_x2 0 3879 1 6444 6078 138 mx2_x2
xsubckt_4258_mx2_x2 0 10292 1 4208 6044 1742 mx2_x2
xsubckt_4256_mx2_x2 0 10294 1 4209 6062 1744 mx2_x2
xsubckt_4254_mx2_x2 0 10296 1 4209 6081 1746 mx2_x2
xsubckt_2994_nand2_x0 1 0 5367 5368 8023 nand2_x0
xsubckt_2816_nand2_x0 1 0 5542 5543 8023 nand2_x0
xsubckt_2726_nand2_x0 1 0 5630 6012 8127 nand2_x0
xsubckt_890_oa22_x2 0 7459 1 423 7810 7618 oa22_x2
xsubckt_374_nor2_x0 1 0 7974 641 642 nor2_x0
xsubckt_1259_nxr2_x1 7106 1 0 207 240 nxr2_x1
xsubckt_1934_nand2_x0 1 0 6466 440 330 nand2_x0
xcmpt_abc_30082_new_n3664_hfns_2 1 0 7973 7970 buf_x4
xcmpt_abc_30082_new_n3664_hfns_1 1 0 7970 7971 buf_x4
xcmpt_abc_30082_new_n3664_hfns_0 1 0 7970 7972 buf_x4
xcmpt_abc_30082_new_n7623_hfns_2 1 0 4192 4189 buf_x4
xcmpt_abc_30082_new_n7623_hfns_1 1 0 4189 4190 buf_x4
xcmpt_abc_30082_new_n7623_hfns_0 1 0 4189 4191 buf_x4
xsubckt_9464_sff1_x4 1 2123 0 8979 1871 sff1_x4
xsubckt_9029_sff1_x4 1 2063 0 9401 385 sff1_x4
xsubckt_7424_mx3_x2 1 0 9383 8492 6289 1350 6236 6240 mx3_x2
xsubckt_5686_oa22_x2 0 3288 1 8421 7999 7994 oa22_x2
xsubckt_5608_oa22_x2 0 3354 1 1993 3360 1992 oa22_x2
xsubckt_4996_mx2_x2 0 3876 1 6445 6068 137 mx2_x2
xsubckt_3723_mx2_x2 0 4650 1 795 1139 1107 mx2_x2
xsubckt_1616_nxr2_x1 6756 1 0 6758 211 nxr2_x1
xsubckt_8564_sff1_x4 1 2053 0 9793 2033 sff1_x4
xsubckt_8129_sff1_x4 1 2136 0 10228 1230 sff1_x4
xsubckt_8041_sff1_x4 1 2100 0 10316 1737 sff1_x4
xsubckt_7640_mx2_x2 0 9179 1 8460 6125 1432 mx2_x2
xsubckt_7428_mx3_x2 1 0 9379 8492 6289 1376 6197 6201 mx3_x2
xsubckt_7426_mx3_x2 1 0 9381 8492 6289 1348 6216 6220 mx3_x2
xsubckt_7207_nand2_x0 1 0 9518 8611 7854 nand2_x0
xsubckt_5555_nxr2_x1 3391 1 0 3395 8129 nxr2_x1
xsubckt_3727_mx2_x2 0 4646 1 794 1299 1267 mx2_x2
xsubckt_3338_mx2_x2 0 5029 1 794 986 954 mx2_x2
xsubckt_3290_mx2_x2 0 5076 1 794 923 891 mx2_x2
xsubckt_2801_mx2_x2 0 5557 1 794 965 933 mx2_x2
xsubckt_668_a3_x2 1 7673 0 7674 7675 7676 a3_x2
xsubckt_9372_sff1_x4 1 2136 0 9071 970 sff1_x4
xsubckt_8995_sff1_x4 1 2145 0 9430 1554 sff1_x4
xsubckt_8921_sff1_x4 1 2153 0 9504 758 sff1_x4
xsubckt_8037_sff1_x4 1 2096 0 10320 1763 sff1_x4
xsubckt_7646_mx2_x2 0 9173 1 8460 6070 1425 mx2_x2
xsubckt_7644_mx2_x2 0 9175 1 8460 6088 1427 mx2_x2
xsubckt_7642_mx2_x2 0 9177 1 8459 6107 1429 mx2_x2
xsubckt_7415_a4_x2 0 8492 1 4183 6305 6312 7886 a4_x2
xsubckt_7295_nand2_x0 1 0 8543 8544 8609 nand2_x0
xsubckt_7121_nor3_x0 1 0 8655 366 365 503 nor3_x0
xsubckt_5529_nand3_x0 1 0 3409 3414 2019 2020 nand3_x0
xsubckt_5270_ao22_x2 0 3626 1 3627 3638 7886 ao22_x2
xsubckt_5071_oa22_x2 0 3811 1 3812 3818 8276 oa22_x2
xsubckt_3933_xr2_x1 4444 0 1 229 748 xr2_x1
xsubckt_3808_oa22_x2 0 4567 1 4625 4622 4624 oa22_x2
xsubckt_3296_mx2_x2 0 5070 1 8033 5071 5072 mx2_x2
xsubckt_3294_mx2_x2 0 5072 1 793 1499 1467 mx2_x2
xsubckt_3292_mx2_x2 0 5074 1 8033 5075 5076 mx2_x2
xsubckt_2807_mx2_x2 0 5551 1 8033 5552 5553 mx2_x2
xsubckt_2805_mx2_x2 0 5553 1 799 1861 1509 mx2_x2
xsubckt_2803_mx2_x2 0 5555 1 790 5556 5557 mx2_x2
xsubckt_2456_nand2_x0 1 0 5895 5897 5944 nand2_x0
xsubckt_612_nand3_x0 1 0 7727 7728 7729 7731 nand3_x0
xsubckt_143_inv_x0 1 0 736 8256 inv_x0
xsubckt_141_inv_x0 1 0 395 8258 inv_x0
xsubckt_1574_nor2_x0 1 0 6795 6796 6803 nor2_x0
xsubckt_2023_mx2_x2 0 6425 1 855 1367 1335 mx2_x2
xsubckt_2414_mx2_x2 0 10415 1 5994 5937 249 mx2_x2
xsubckt_9368_sff1_x4 1 2123 0 9075 975 sff1_x4
xsubckt_8917_sff1_x4 1 2089 0 9508 753 sff1_x4
xsubckt_8472_sff1_x4 1 2047 0 9885 1931 sff1_x4
xsubckt_7648_mx2_x2 0 9171 1 8460 6053 1423 mx2_x2
xsubckt_7255_mx2_x2 0 9505 1 8832 8576 757 mx2_x2
xsubckt_6847_oa22_x2 0 8821 1 8826 8823 8824 oa22_x2
xsubckt_6720_mx2_x2 0 8933 1 853 1835 1803 mx2_x2
xsubckt_5463_nxr2_x1 3454 1 0 3457 8116 nxr2_x1
xsubckt_5363_a4_x2 0 3540 1 3588 3876 3879 3882 a4_x2
xsubckt_5216_a3_x2 1 3677 0 3703 3906 3909 a3_x2
xsubckt_5188_a4_x2 0 3703 1 3742 3912 3915 3918 a4_x2
xsubckt_4708_a4_x2 0 4091 1 4092 4098 4107 4117 a4_x2
xsubckt_3298_mx2_x2 0 5068 1 798 1659 1627 mx2_x2
xsubckt_2809_mx2_x2 0 5549 1 799 1701 1669 mx2_x2
xsubckt_2763_mx2_x2 0 5594 1 799 1126 1094 mx2_x2
xsubckt_1012_a3_x2 1 7343 0 7344 7345 7346 a3_x2
xsubckt_149_inv_x0 1 0 709 8250 inv_x0
xsubckt_147_inv_x0 1 0 727 8252 inv_x0
xsubckt_145_inv_x0 1 0 724 8254 inv_x0
xsubckt_1394_nand2_x0 1 0 6971 6972 6988 nand2_x0
xsubckt_2025_mx2_x2 0 6423 1 861 1239 1207 mx2_x2
xsubckt_2027_mx2_x2 0 6421 1 8220 6422 6423 mx2_x2
xsubckt_2029_mx2_x2 0 6419 1 861 1431 1399 mx2_x2
xsubckt_2370_mx2_x2 0 5986 1 8033 5987 5988 mx2_x2
xsubckt_2372_mx2_x2 0 5984 1 798 1379 1347 mx2_x2
xsubckt_2416_mx2_x2 0 5935 1 798 1858 1826 mx2_x2
xsubckt_2418_mx2_x2 0 5933 1 787 5934 5935 mx2_x2
xcmpt_abc_30082_new_n10705_hfns_2 1 0 8491 8488 buf_x4
xcmpt_abc_30082_new_n10705_hfns_1 1 0 8488 8489 buf_x4
xcmpt_abc_30082_new_n10705_hfns_0 1 0 8488 8490 buf_x4
xsubckt_9280_sff1_x4 1 2142 0 9160 1031 sff1_x4
xsubckt_9202_sff1_x4 1 2145 0 9238 1202 sff1_x4
xsubckt_8468_sff1_x4 1 2057 0 9889 1936 sff1_x4
xsubckt_8380_sff1_x4 1 2145 0 9977 1491 sff1_x4
xsubckt_6726_mx2_x2 0 8927 1 860 1867 1515 mx2_x2
xsubckt_6724_mx2_x2 0 8929 1 833 8930 8931 mx2_x2
xsubckt_6722_mx2_x2 0 8931 1 860 1707 1675 mx2_x2
xsubckt_6335_mx2_x2 0 2686 1 833 2687 2688 mx2_x2
xsubckt_6333_mx2_x2 0 2688 1 860 984 952 mx2_x2
xsubckt_6331_mx2_x2 0 2690 1 860 1176 1080 mx2_x2
xsubckt_6213_a2_x2 0 9695 1 2805 2839 a2_x2
xsubckt_5471_a3_x2 1 3449 0 3453 2038 2039 a3_x2
xsubckt_5173_nand2_x0 1 0 3717 3915 8277 nand2_x0
xsubckt_2894_oa22_x2 0 5465 1 5466 5467 775 oa22_x2
xsubckt_2767_mx2_x2 0 5590 1 796 1286 1254 mx2_x2
xsubckt_1036_oa22_x2 0 7321 1 7339 7338 7337 oa22_x2
xsubckt_1747_a4_x2 0 6634 1 6677 8042 8043 8044 a4_x2
xsubckt_1970_mx3_x2 1 0 478 8001 6449 226 101 133 mx3_x2
xsubckt_2255_a3_x2 1 6139 0 6140 541 8408 a3_x2
xsubckt_2374_mx2_x2 0 5982 1 8034 5983 5984 mx2_x2
xsubckt_2376_mx2_x2 0 5980 1 821 1155 1123 mx2_x2
xsubckt_9276_sff1_x4 1 2126 0 9164 1047 sff1_x4
xsubckt_8825_sff1_x4 1 2076 0 318 560 sff1_x4
xsubckt_8302_sff1_x4 1 2229 0 10055 1636 sff1_x4
xsubckt_6925_nand2_x0 1 0 8766 8767 8269 nand2_x0
xsubckt_6728_mx2_x2 0 8925 1 8221 8926 8927 mx2_x2
xsubckt_6339_mx2_x2 0 2682 1 859 1304 1272 mx2_x2
xsubckt_6337_mx2_x2 0 2684 1 826 2685 2692 mx2_x2
xsubckt_6291_mx2_x2 0 2729 1 859 1785 1753 mx2_x2
xsubckt_5800_mx2_x2 0 3206 1 834 3207 3208 mx2_x2
xsubckt_5745_a3_x2 1 3259 0 3260 3279 7795 a3_x2
xsubckt_5725_a3_x2 1 3277 0 7822 7840 1905 a3_x2
xsubckt_5498_oa22_x2 0 3430 1 3433 2030 8305 oa22_x2
xsubckt_5324_a2_x2 0 3576 1 3578 651 a2_x2
xsubckt_5090_a2_x2 0 3794 1 3933 724 a2_x2
xsubckt_4023_nand2_x0 1 0 4355 4356 782 nand2_x0
xsubckt_2724_a3_x2 1 5632 0 5633 5790 6391 a3_x2
xsubckt_764_o2_x2 0 7579 1 7580 7582 o2_x2
xsubckt_1670_ao22_x2 0 6706 1 6719 208 8416 ao22_x2
xsubckt_1972_mx3_x2 1 0 474 8002 6448 222 97 129 mx3_x2
xsubckt_1974_mx3_x2 1 0 472 8002 6448 220 95 127 mx3_x2
xsubckt_1976_mx3_x2 1 0 470 8002 6449 218 93 125 mx3_x2
xsubckt_2378_mx2_x2 0 5978 1 8025 5979 5982 mx2_x2
xsubckt_2345_nand3_x0 1 0 6023 6024 540 8409 nand3_x0
xsubckt_1978_mx3_x2 1 0 498 8001 6448 246 121 153 mx3_x2
xsubckt_1906_nand2_x0 1 0 6488 7809 192 nand2_x0
xsubckt_2852_a2_x2 0 5507 1 218 737 a2_x2
xsubckt_2966_nand2_x0 1 0 10405 5395 5452 nand2_x0
xsubckt_4650_a2_x2 0 9934 1 4135 47 a2_x2
xsubckt_4670_a2_x2 0 4120 1 4122 1916 a2_x2
xsubckt_4856_a3_x2 1 3979 0 3980 3991 4142 a3_x2
xsubckt_5367_nxr2_x1 3536 1 0 3537 3538 nxr2_x1
xsubckt_5638_a2_x2 0 9747 1 3334 46 a2_x2
xsubckt_5802_mx2_x2 0 3204 1 863 994 962 mx2_x2
xsubckt_5804_mx2_x2 0 3202 1 835 3203 3204 mx2_x2
xsubckt_5806_mx2_x2 0 3200 1 858 1890 1538 mx2_x2
xsubckt_6293_mx2_x2 0 2727 1 8214 2728 2731 mx2_x2
xsubckt_6295_mx2_x2 0 2725 1 858 1177 1081 mx2_x2
xsubckt_6297_mx2_x2 0 2723 1 858 985 953 mx2_x2
xsubckt_6684_mx2_x2 0 2347 1 858 1837 1805 mx2_x2
xsubckt_6686_mx2_x2 0 2345 1 857 1709 1677 mx2_x2
xsubckt_6688_mx2_x2 0 2343 1 835 2344 2345 mx2_x2
xsubckt_6988_a3_x2 1 8716 0 8717 8266 374 a3_x2
xsubckt_7791_nand4_x0 1 0 8435 6303 6305 6312 7885 nand4_x0
xsubckt_7925_sff1_x4 1 2215 0 10427 1814 sff1_x4
xsubckt_9110_sff1_x4 1 2116 0 9330 878 sff1_x4
xsubckt_8899_sff1_x4 1 2066 0 9526 323 sff1_x4
xsubckt_8376_sff1_x4 1 2251 0 9981 1496 sff1_x4
xsubckt_1859_nxr2_x1 6529 1 0 6532 227 nxr2_x1
xsubckt_425_nand2_x0 1 0 7919 364 367 nand2_x0
xsubckt_2608_nand2_x0 1 0 5746 223 742 nand2_x0
xsubckt_4620_mx3_x2 1 0 9959 4149 6295 1604 6216 6220 mx3_x2
xsubckt_4622_mx3_x2 1 0 9957 4149 6295 1632 6197 6201 mx3_x2
xsubckt_5251_nor2_x0 1 0 3644 3645 3648 nor2_x0
xsubckt_5760_mx2_x2 0 3245 1 830 3246 3249 mx2_x2
xsubckt_5762_mx2_x2 0 3243 1 862 1795 1763 mx2_x2
xsubckt_5764_mx2_x2 0 3241 1 8222 3242 3243 mx2_x2
xsubckt_5808_mx2_x2 0 3198 1 830 3199 3202 mx2_x2
xsubckt_5853_a2_x2 0 9705 1 3155 3193 a2_x2
xsubckt_6140_oa22_x2 0 2875 1 3191 2878 2876 oa22_x2
xsubckt_6299_mx2_x2 0 2721 1 835 2722 2723 mx2_x2
xsubckt_7890_buf_x1 1 0 1882 8989 buf_x1
xsubckt_7999_sff1_x4 1 2203 0 10358 1776 sff1_x4
xsubckt_8210_sff1_x4 1 2251 0 10147 1278 sff1_x4
xsubckt_8733_sff1_x4 1 2185 0 2313 2281 sff1_x4
xsubckt_9184_sff1_x4 1 2217 0 9256 1191 sff1_x4
xsubckt_1726_nand2_x0 1 0 6653 6943 7128 nand2_x0
xsubckt_1247_o2_x2 0 7118 1 206 239 o2_x2
xsubckt_499_nor3_x0 1 0 7837 7838 7937 7943 nor3_x0
xsubckt_2518_nand2_x0 1 0 5834 5835 5850 nand2_x0
xsubckt_4237_mx3_x2 1 0 10313 4211 6295 1734 6235 6240 mx3_x2
xsubckt_4971_mx3_x2 1 0 3895 6449 545 8384 8169 8170 mx3_x2
xsubckt_5766_mx2_x2 0 3239 1 861 931 899 mx2_x2
xsubckt_5768_mx2_x2 0 3237 1 830 3238 3241 mx2_x2
xsubckt_7892_buf_x1 1 0 1880 8987 buf_x1
xsubckt_7894_buf_x1 1 0 1877 8985 buf_x1
xsubckt_7896_buf_x1 1 0 1875 8983 buf_x1
xsubckt_8284_sff1_x4 1 2139 0 10073 1299 sff1_x4
xsubckt_8729_sff1_x4 1 2185 0 2317 2285 sff1_x4
xsubckt_9106_sff1_x4 1 2214 0 9334 882 sff1_x4
xsubckt_1767_nxr2_x1 6615 1 0 6618 233 nxr2_x1
xsubckt_1546_nand2_x0 1 0 6821 6948 7072 nand2_x0
xsubckt_1267_o2_x2 0 7098 1 210 243 o2_x2
xsubckt_61_inv_x0 1 0 1926 8350 inv_x0
xsubckt_63_inv_x0 1 0 1929 8348 inv_x0
xsubckt_65_inv_x0 1 0 1931 8346 inv_x0
xsubckt_4060_mx2_x2 0 4319 1 8029 4320 4321 mx2_x2
xsubckt_4090_nand3_x0 1 0 4289 4294 4298 770 nand3_x0
xsubckt_4108_mx2_x2 0 4272 1 799 1035 1003 mx2_x2
xsubckt_4239_mx3_x2 1 0 10311 4211 6287 1732 6216 6220 mx3_x2
xsubckt_4451_mx2_x2 0 10116 1 4174 6189 1695 mx2_x2
xsubckt_4453_mx2_x2 0 10114 1 4174 6170 1693 mx2_x2
xsubckt_4584_mx3_x2 1 0 9993 4154 6287 1478 6236 6240 mx3_x2
xsubckt_4586_mx3_x2 1 0 9991 4154 6287 1476 6216 6220 mx3_x2
xsubckt_4975_mx3_x2 1 0 3892 6450 545 8385 8167 8168 mx3_x2
xsubckt_6535_o2_x2 0 2491 1 2492 7931 o2_x2
xsubckt_7898_buf_x1 1 0 1873 8981 buf_x1
xsubckt_8206_sff1_x4 1 2235 0 10151 1252 sff1_x4
xsubckt_8641_sff1_x4 1 2076 0 166 103 sff1_x4
xsubckt_9092_sff1_x4 1 2172 0 9348 897 sff1_x4
xcmpt_cpuregs_rdreg_1_q_1_hfns_5 1 0 792 786 buf_x4
xcmpt_cpuregs_rdreg_1_q_1_hfns_4 1 0 786 787 buf_x4
xcmpt_cpuregs_rdreg_1_q_1_hfns_3 1 0 786 788 buf_x4
xcmpt_cpuregs_rdreg_1_q_1_hfns_2 1 0 786 789 buf_x4
xcmpt_cpuregs_rdreg_1_q_1_hfns_1 1 0 786 790 buf_x4
xcmpt_cpuregs_rdreg_1_q_1_hfns_0 1 0 786 791 buf_x4
xcmpt_cpuregs_rdreg_1_q_3_hfns_2 1 0 777 774 buf_x4
xcmpt_cpuregs_rdreg_1_q_3_hfns_1 1 0 774 775 buf_x4
xcmpt_cpuregs_rdreg_1_q_3_hfns_0 1 0 774 776 buf_x4
xsubckt_1756_o2_x2 0 6625 1 6626 6627 o2_x2
xsubckt_1482_ao22_x2 0 6881 1 6883 6884 223 ao22_x2
xsubckt_67_inv_x0 1 0 1934 8344 inv_x0
xsubckt_69_inv_x0 1 0 1937 8342 inv_x0
xsubckt_959_oa22_x2 0 176 1 7407 7406 7394 oa22_x2
xsubckt_4062_mx2_x2 0 4317 1 806 1709 1677 mx2_x2
xsubckt_4064_mx2_x2 0 4315 1 790 4316 4317 mx2_x2
xsubckt_4066_mx2_x2 0 4313 1 806 909 877 mx2_x2
xsubckt_4455_mx2_x2 0 10112 1 4173 6152 1691 mx2_x2
xsubckt_4457_mx2_x2 0 10110 1 4173 6134 1689 mx2_x2
xsubckt_4459_mx2_x2 0 10108 1 4173 6115 1686 mx2_x2
xsubckt_4588_mx3_x2 1 0 9989 4154 6290 1504 6197 6201 mx3_x2
xsubckt_4979_mx3_x2 1 0 3889 6448 546 8386 8165 8166 mx3_x2
xsubckt_5628_nxr2_x1 3340 1 0 3343 8079 nxr2_x1
xsubckt_5958_ao22_x2 0 3052 1 574 569 738 ao22_x2
xsubckt_8114_sff1_x4 1 2251 0 10243 1246 sff1_x4
xsubckt_8192_sff1_x4 1 2123 0 10165 1711 sff1_x4
xsubckt_8637_sff1_x4 1 2156 0 170 107 sff1_x4
xsubckt_9014_sff1_x4 1 2053 0 9416 371 sff1_x4
xsubckt_1883_nand3_x0 1 0 6506 6507 6508 6509 nand3_x0
xsubckt_1675_nxr2_x1 6701 1 0 6705 8097 nxr2_x1
xsubckt_1366_nand2_x0 1 0 6999 205 8094 nand2_x0
xsubckt_3531_mx2_x2 0 4839 1 805 1846 1814 mx2_x2
xsubckt_4068_mx2_x2 0 4311 1 8028 4312 4313 mx2_x2
xsubckt_5145_nand2_x0 1 0 3743 3921 8279 nand2_x0
xsubckt_7340_nand2_x0 1 0 8507 8508 8510 nand2_x0
xsubckt_8188_sff1_x4 1 2132 0 10169 1715 sff1_x4
xsubckt_9088_sff1_x4 1 2204 0 9352 871 sff1_x4
xsubckt_9445_sff1_x4 1 2189 0 8998 1861 sff1_x4
xsubckt_492_nand3_x0 1 0 7843 7884 700 8295 nand3_x0
xsubckt_419_a2_x2 0 7925 1 366 365 a2_x2
xsubckt_614_a2_x2 0 7725 1 7726 1895 a2_x2
xsubckt_845_nand2_x0 1 0 7502 7504 7506 nand2_x0
xsubckt_935_nand2_x0 1 0 7416 633 1967 nand2_x0
xsubckt_1008_nand2_x0 1 0 7347 7991 2026 nand2_x0
xsubckt_3113_nand2_x0 1 0 5250 5251 8021 nand2_x0
xsubckt_3535_mx2_x2 0 4835 1 805 1430 1398 mx2_x2
xsubckt_3539_mx2_x2 0 4831 1 805 1590 1558 mx2_x2
xsubckt_3882_mx2_x2 0 4494 1 804 1168 1072 mx2_x2
xsubckt_5091_nxr2_x1 3793 1 0 3934 724 nxr2_x1
xsubckt_5501_oa22_x2 0 3428 1 2030 3433 2028 oa22_x2
xsubckt_7101_mx2_x2 0 9574 1 8666 6080 1522 mx2_x2
xsubckt_7103_mx2_x2 0 9572 1 8666 6062 1520 mx2_x2
xsubckt_7105_mx2_x2 0 9570 1 8666 6044 1518 mx2_x2
xsubckt_7629_mx3_x2 1 0 9190 8462 6287 1413 6225 6230 mx3_x2
xsubckt_8022_sff1_x4 1 2246 0 10335 1146 sff1_x4
xsubckt_8545_sff1_x4 1 2150 0 9812 134 sff1_x4
xsubckt_8980_sff1_x4 1 2235 0 9445 1540 sff1_x4
xsubckt_1835_ao22_x2 0 6551 1 6553 6560 6940 ao22_x2
xsubckt_479_a2_x2 0 7858 1 7860 1898 a2_x2
xsubckt_344_inv_x0 1 0 555 8008 inv_x0
xsubckt_342_inv_x0 1 0 771 8014 inv_x0
xsubckt_340_inv_x0 1 0 782 8026 inv_x0
xsubckt_674_a2_x2 0 7668 1 740 65 a2_x2
xsubckt_694_a2_x2 0 7648 1 7649 7655 a2_x2
xsubckt_755_nand2_x0 1 0 7587 7779 327 nand2_x0
xsubckt_2938_nand2_x0 1 0 5422 5423 782 nand2_x0
xsubckt_3886_mx2_x2 0 4490 1 803 1776 1744 mx2_x2
xsubckt_6839_nor2_x0 1 0 8828 395 394 nor2_x0
xsubckt_7107_mx2_x2 0 9568 1 8665 6026 1515 mx2_x2
xsubckt_7452_mx2_x2 0 9357 1 8485 6277 898 mx2_x2
xsubckt_7841_mx2_x2 0 8959 1 8429 6162 1852 mx2_x2
xsubckt_7843_mx2_x2 0 8957 1 8428 6142 1850 mx2_x2
xsubckt_7845_mx2_x2 0 8955 1 8428 6125 1848 mx2_x2
xsubckt_8096_sff1_x4 1 2126 0 10261 1167 sff1_x4
xsubckt_8902_sff1_x4 1 2123 0 9523 555 sff1_x4
xsubckt_9353_sff1_x4 1 2242 0 9090 991 sff1_x4
xcmpt_abc_30082_new_n11046_hfns_2 1 0 8440 8437 buf_x4
xcmpt_abc_30082_new_n11046_hfns_1 1 0 8437 8438 buf_x4
xcmpt_abc_30082_new_n11046_hfns_0 1 0 8437 8439 buf_x4
xsubckt_2226_mx2_x2 0 6176 1 546 118 2282 mx2_x2
xsubckt_1966_nand2_x0 1 0 443 6452 6461 nand2_x0
xsubckt_348_inv_x0 1 0 551 8004 inv_x0
xsubckt_346_inv_x0 1 0 553 8006 inv_x0
xsubckt_665_nand2_x0 1 0 7676 629 1946 nand2_x0
xsubckt_2571_mx2_x2 0 5783 1 808 1705 1673 mx2_x2
xsubckt_2619_mx2_x2 0 10411 1 5995 5736 223 mx2_x2
xsubckt_2848_nand2_x0 1 0 10407 5511 5568 nand2_x0
xsubckt_4152_oa22_x2 0 4228 1 4276 4275 4229 oa22_x2
xsubckt_4332_a4_x2 0 4194 1 6307 7886 556 8008 a4_x2
xsubckt_4508_nand4_x0 1 0 4163 4165 6305 6312 7886 nand4_x0
xsubckt_7454_mx2_x2 0 9355 1 8485 6266 876 mx2_x2
xsubckt_7456_mx2_x2 0 9353 1 8485 6252 872 mx2_x2
xsubckt_7847_mx2_x2 0 8953 1 8429 6108 1845 mx2_x2
xsubckt_7849_mx2_x2 0 8951 1 8429 6089 1843 mx2_x2
xsubckt_8018_sff1_x4 1 2251 0 10339 1150 sff1_x4
xsubckt_8453_sff1_x4 1 2050 0 9904 1952 sff1_x4
xsubckt_8976_sff1_x4 1 2251 0 9449 1544 sff1_x4
xsubckt_2182_mx2_x2 0 6253 1 6297 6254 6255 mx2_x2
xsubckt_2180_mx2_x2 0 6255 1 546 97 2261 mx2_x2
xsubckt_1786_nand2_x0 1 0 6597 6947 7150 nand2_x0
xsubckt_1518_a3_x2 1 6847 0 6848 6849 6850 a3_x2
xsubckt_485_nand2_x0 1 0 7849 8278 1912 nand2_x0
xsubckt_1069_a3_x2 1 7289 0 7290 7291 7292 a3_x2
xsubckt_2573_mx2_x2 0 5781 1 790 5782 5783 mx2_x2
xsubckt_2575_mx2_x2 0 5779 1 807 905 873 mx2_x2
xsubckt_2577_mx2_x2 0 5777 1 781 5778 5781 mx2_x2
xsubckt_3252_oa22_x2 0 5113 1 5114 5115 775 oa22_x2
xsubckt_5027_a2_x2 0 3852 1 3951 711 a2_x2
xsubckt_5034_nand3_x0 1 0 3846 40 133 8396 nand3_x0
xsubckt_5048_oa22_x2 0 3833 1 3948 3945 3942 oa22_x2
xsubckt_5174_a3_x2 1 3716 0 3742 3915 3918 a3_x2
xsubckt_5202_a2_x2 0 3690 1 3703 3909 a2_x2
xsubckt_6530_mx2_x2 0 2496 1 8225 2497 2498 mx2_x2
xsubckt_6532_mx2_x2 0 2494 1 828 2495 2502 mx2_x2
xsubckt_8810_sff1_x4 1 2089 0 9612 715 sff1_x4
xsubckt_9261_sff1_x4 1 2251 0 9179 1432 sff1_x4
xsubckt_9349_sff1_x4 1 2235 0 9094 965 sff1_x4
xcmpt_abc_30082_new_n10126_hfns_2 1 0 8833 8830 buf_x4
xcmpt_abc_30082_new_n10126_hfns_1 1 0 8830 8831 buf_x4
xcmpt_abc_30082_new_n10126_hfns_0 1 0 8830 8832 buf_x4
xsubckt_2188_mx2_x2 0 10441 1 6300 6245 1799 mx2_x2
xsubckt_1739_ao22_x2 0 6641 1 6642 6643 6940 ao22_x2
xsubckt_1713_a3_x2 1 6665 0 6666 6667 6668 a3_x2
xsubckt_1696_nand2_x0 1 0 6681 6943 7117 nand2_x0
xsubckt_1608_nand2_x0 1 0 6763 7088 7972 nand2_x0
xsubckt_1352_a2_x2 0 7013 1 7014 7015 a2_x2
xsubckt_1017_oa22_x2 0 7339 1 7357 7355 7356 oa22_x2
xsubckt_1117_a2_x2 0 7244 1 7245 1903 a2_x2
xsubckt_2579_mx2_x2 0 5775 1 813 1033 1001 mx2_x2
xsubckt_3150_a2_x2 0 5214 1 243 762 a2_x2
xsubckt_3713_nand2_x0 1 0 4660 4661 8024 nand2_x0
xsubckt_4333_a2_x2 0 4193 1 4194 4195 a2_x2
xsubckt_4754_a3_x2 1 9909 0 4056 4057 40 a3_x2
xsubckt_5003_mx3_x2 1 0 3871 6449 545 8392 8153 8154 mx3_x2
xsubckt_5007_mx3_x2 1 0 3868 6449 545 8393 8151 8152 mx3_x2
xsubckt_5352_nxr2_x1 3550 1 0 3880 730 nxr2_x1
xsubckt_5405_oa22_x2 0 3501 1 3871 3874 8268 oa22_x2
xsubckt_6143_mx2_x2 0 2873 1 843 925 893 mx2_x2
xsubckt_6145_mx2_x2 0 2871 1 8226 2872 2873 mx2_x2
xsubckt_6147_mx2_x2 0 2869 1 843 1789 1757 mx2_x2
xsubckt_6490_mx2_x2 0 2535 1 843 1587 1555 mx2_x2
xsubckt_6826_a3_x2 1 8841 0 9417 9418 8844 a3_x2
xsubckt_7312_ao22_x2 0 8530 1 8606 8686 379 ao22_x2
xsubckt_7910_sff1_x4 1 2225 0 10442 1800 sff1_x4
xsubckt_7984_sff1_x4 1 2189 0 10373 1792 sff1_x4
xsubckt_8361_sff1_x4 1 2106 0 9996 1481 sff1_x4
xsubckt_8449_sff1_x4 1 2044 0 9908 1957 sff1_x4
xsubckt_8806_sff1_x4 1 2066 0 9616 719 sff1_x4
xsubckt_8884_sff1_x4 1 2076 0 9541 352 sff1_x4
xcmpt_abc_30082_new_n5555_hfns_2 1 0 6126 6123 buf_x4
xcmpt_abc_30082_new_n5555_hfns_1 1 0 6123 6124 buf_x4
xcmpt_abc_30082_new_n5555_hfns_0 1 0 6123 6125 buf_x4
xsubckt_1773_a3_x2 1 6609 0 6610 6611 6612 a3_x2
xsubckt_1428_nand2_x0 1 0 6932 7036 7972 nand2_x0
xsubckt_1392_a2_x2 0 6973 1 6974 6978 a2_x2
xsubckt_628_xr2_x1 7712 0 1 742 67 xr2_x1
xsubckt_2555_a2_x2 0 5798 1 226 745 a2_x2
xsubckt_2917_nand3_x0 1 0 5443 5444 5445 7905 nand3_x0
xsubckt_3447_ao22_x2 0 4922 1 4980 4975 4977 ao22_x2
xsubckt_3533_nand2_x0 1 0 4837 4838 8022 nand2_x0
xsubckt_4802_a2_x2 0 9897 1 4020 45 a2_x2
xsubckt_4822_a2_x2 0 9892 1 4005 45 a2_x2
xsubckt_5391_oa22_x2 0 3514 1 3525 3523 3524 oa22_x2
xsubckt_5556_a2_x2 0 9772 1 3391 44 a2_x2
xsubckt_6149_mx2_x2 0 2867 1 8213 2868 2871 mx2_x2
xsubckt_6465_a2_x2 0 9688 1 2560 2594 a2_x2
xsubckt_6492_mx2_x2 0 2533 1 841 1491 1459 mx2_x2
xsubckt_6494_mx2_x2 0 2531 1 8218 2532 2533 mx2_x2
xsubckt_6496_mx2_x2 0 2529 1 826 2530 2537 mx2_x2
xsubckt_6866_a3_x2 1 8806 0 395 394 393 a3_x2
xsubckt_6935_ao22_x2 0 8758 1 706 8277 666 ao22_x2
xsubckt_7906_sff1_x4 1 2126 0 10446 1826 sff1_x4
xsubckt_8357_sff1_x4 1 2095 0 10000 1507 sff1_x4
xsubckt_9257_sff1_x4 1 2216 0 9183 1436 sff1_x4
xsubckt_3619_nand3_x0 1 0 4752 4753 4928 6392 nand3_x0
xsubckt_4687_a2_x2 0 9924 1 4108 43 a2_x2
xsubckt_5117_nand2_x0 1 0 3769 3927 8279 nand2_x0
xsubckt_5387_oa22_x2 0 9814 1 7885 3518 3533 oa22_x2
xsubckt_5596_a2_x2 0 9760 1 3363 3364 a2_x2
xsubckt_5963_mx2_x2 0 3048 1 843 900 868 mx2_x2
xsubckt_6644_oa22_x2 0 2385 1 3191 2388 2386 oa22_x2
xsubckt_7059_o3_x2 0 8679 1 8766 8814 377 o3_x2
xsubckt_7688_a2_x2 0 8451 1 8457 4194 a2_x2
xsubckt_8714_sff1_x4 1 2169 0 9676 559 sff1_x4
xsubckt_8792_sff1_x4 1 2086 0 9630 727 sff1_x4
xsubckt_2149_nor3_x0 1 0 6309 550 552 553 nor3_x0
xsubckt_1501_nand2_x0 1 0 6863 6942 7055 nand2_x0
xsubckt_1356_oa22_x2 0 7009 1 7010 7011 7094 oa22_x2
xsubckt_1317_nxr2_x1 7048 1 0 442 223 nxr2_x1
xsubckt_786_ao22_x2 0 7558 1 7560 7563 1902 ao22_x2
xsubckt_907_nand2_x0 1 0 7443 7444 7447 nand2_x0
xsubckt_1158_nand2_x0 1 0 7205 225 1897 nand2_x0
xsubckt_2729_o3_x2 0 5627 1 5628 5632 5675 o3_x2
xsubckt_3353_nand2_x0 1 0 5014 5015 8021 nand2_x0
xsubckt_3439_nand3_x0 1 0 4929 4930 5105 6391 nand3_x0
xsubckt_3993_a2_x2 0 4385 1 4387 4389 a2_x2
xsubckt_4301_mx2_x2 0 10253 1 4199 6265 1228 mx2_x2
xsubckt_4303_mx2_x2 0 10251 1 4199 6251 1224 mx2_x2
xsubckt_4752_nand3_x0 1 0 4057 4059 4064 1958 nand3_x0
xsubckt_5309_o2_x2 0 9819 1 3591 3598 o2_x2
xsubckt_5965_mx2_x2 0 3046 1 8219 3047 3048 mx2_x2
xsubckt_5967_mx2_x2 0 3044 1 854 1764 1732 mx2_x2
xsubckt_5969_mx2_x2 0 3042 1 8211 3043 3046 mx2_x2
xsubckt_6843_ao22_x2 0 9669 1 8825 8829 43 ao22_x2
xsubckt_7218_nand3_x0 1 0 8601 8602 8604 8609 nand3_x0
xsubckt_7825_nand4_x0 1 0 8430 4221 6303 6305 7885 nand4_x0
xsubckt_8265_sff1_x4 1 2126 0 10092 1289 sff1_x4
xsubckt_8788_sff1_x4 1 2053 0 9634 639 sff1_x4
xsubckt_9165_sff1_x4 1 2251 0 9275 1400 sff1_x4
xsubckt_392_nor3_x0 1 0 7953 7954 7955 7980 nor3_x0
xsubckt_366_nor4_x0 1 0 7982 666 615 625 613 nor4_x0
xsubckt_1068_nand2_x0 1 0 7290 633 1959 nand2_x0
xsubckt_3173_nand2_x0 1 0 5191 5192 8021 nand2_x0
xsubckt_3509_oa22_x2 0 4861 1 4921 4919 4918 oa22_x2
xsubckt_5369_o2_x2 0 3534 1 3535 7881 o2_x2
xsubckt_8622_sff1_x4 1 2179 0 156 93 sff1_x4
xsubckt_9073_sff1_x4 1 2066 0 316 58 sff1_x4
xsubckt_1938_nand2_x0 1 0 6463 209 328 nand2_x0
xsubckt_1694_o2_x2 0 6683 1 6684 6685 o2_x2
xsubckt_388_nor3_x0 1 0 7957 641 642 664 nor3_x0
xsubckt_2998_nand2_x0 1 0 5363 5364 783 nand2_x0
xsubckt_3259_nand3_x0 1 0 5106 5107 5282 6392 nand3_x0
xsubckt_4261_mx2_x2 0 10289 1 4208 6018 1738 mx2_x2
xsubckt_4265_mx2_x2 0 10287 1 4204 6277 1186 mx2_x2
xsubckt_6787_o2_x2 0 8867 1 8868 7930 o2_x2
xsubckt_6994_nor2_x0 1 0 8710 376 387 nor2_x0
xsubckt_8173_sff1_x4 1 2172 0 10184 1701 sff1_x4
xsubckt_8696_sff1_x4 1 2166 0 9694 208 sff1_x4
xsubckt_9430_sff1_x4 1 2109 0 9013 913 sff1_x4
xsubckt_1848_nand2_x0 1 0 6539 6541 228 nand2_x0
xsubckt_1463_ao22_x2 0 6899 1 615 6904 8067 ao22_x2
xsubckt_512_a2_x2 0 7825 1 7826 7827 a2_x2
xsubckt_547_nand2_x0 1 0 7789 2015 638 nand2_x0
xsubckt_1141_nand2_x0 1 0 7221 7991 2019 nand2_x0
xsubckt_3079_nand3_x0 1 0 5283 5284 5457 6391 nand3_x0
xsubckt_3495_oa22_x2 0 4874 1 4875 4876 8016 oa22_x2
xsubckt_3852_oa22_x2 0 4523 1 4524 4525 775 oa22_x2
xsubckt_3953_nand2_x0 1 0 4424 4425 8020 nand2_x0
xsubckt_4267_mx2_x2 0 10285 1 4204 6265 1164 mx2_x2
xsubckt_4269_mx2_x2 0 10283 1 4204 6251 1160 mx2_x2
xsubckt_4671_nor2_x0 1 0 4119 4122 1916 nor2_x0
xsubckt_6940_nand2_x0 1 0 8754 8267 375 nand2_x0
xsubckt_8530_sff1_x4 1 2179 0 9827 150 sff1_x4
xsubckt_8618_sff1_x4 1 2169 0 160 97 sff1_x4
xsubckt_9069_sff1_x4 1 2119 0 9361 1357 sff1_x4
xsubckt_2450_nand3_x0 1 0 5901 5902 5905 5950 nand3_x0
xsubckt_2203_mx3_x2 1 0 10438 6302 6294 1796 6216 6220 mx3_x2
xsubckt_1758_nand2_x0 1 0 6623 6942 7136 nand2_x0
xsubckt_710_nand2_x0 1 0 7633 2008 637 nand2_x0
xsubckt_721_nxr2_x1 7623 1 0 738 63 nxr2_x1
xsubckt_1172_oa22_x2 0 7192 1 406 7809 7618 oa22_x2
xsubckt_3343_mx2_x2 0 5024 1 813 1178 1082 mx2_x2
xsubckt_3347_mx2_x2 0 5020 1 813 1786 1754 mx2_x2
xsubckt_4034_nand3_x0 1 0 4344 4345 4348 5949 nand3_x0
xsubckt_5523_nand4_x0 1 0 3413 3421 2021 2022 2023 nand4_x0
xsubckt_8081_sff1_x4 1 2242 0 10276 1183 sff1_x4
xsubckt_8169_sff1_x4 1 2100 0 10188 1705 sff1_x4
xsubckt_9426_sff1_x4 1 2218 0 9017 917 sff1_x4
xsubckt_2421_mx2_x2 0 5930 1 790 5931 5932 mx2_x2
xsubckt_2207_mx3_x2 1 0 10437 6302 6294 1825 6206 6209 mx3_x2
xsubckt_2030_mx2_x2 0 6418 1 866 1495 1463 mx2_x2
xsubckt_1921_nand2_x0 1 0 6476 7810 213 nand2_x0
xsubckt_1578_nand2_x0 1 0 6791 6942 7078 nand2_x0
xsubckt_1564_nxr2_x1 6804 1 0 6805 6813 nxr2_x1
xsubckt_384_o4_x2 0 7961 1 652 649 646 616 o4_x2
xsubckt_150_inv_x0 1 0 368 8249 inv_x0
xsubckt_592_a2_x2 0 7746 1 7990 2029 a2_x2
xsubckt_620_nand2_x0 1 0 7719 634 1954 nand2_x0
xsubckt_760_oa22_x2 0 156 1 7597 7596 7583 oa22_x2
xsubckt_993_a3_x2 1 7361 0 7362 7363 7364 a3_x2
xsubckt_2810_mx2_x2 0 5548 1 814 1765 1733 mx2_x2
xsubckt_2814_mx2_x2 0 5544 1 814 1829 1797 mx2_x2
xsubckt_2891_nand2_x0 1 0 5468 5469 8023 nand2_x0
xsubckt_3773_nand2_x0 1 0 4601 4602 8023 nand2_x0
xsubckt_3859_nand3_x0 1 0 4516 4517 4692 6392 nand3_x0
xsubckt_6846_nand3_x0 1 0 8822 395 8259 8261 nand3_x0
xsubckt_6891_oa22_x2 0 9658 1 8815 8798 8791 oa22_x2
xsubckt_7260_mx2_x2 0 9504 1 8832 8572 758 mx2_x2
xsubckt_7391_mx3_x2 1 0 9446 8497 6294 1541 6226 6230 mx3_x2
xsubckt_7393_mx3_x2 1 0 9444 8497 6294 1569 6206 6210 mx3_x2
xsubckt_7552_nand2_x0 1 0 8471 4212 4218 nand2_x0
xsubckt_7651_mx2_x2 0 9168 1 8459 6027 1419 mx2_x2
xsubckt_8003_sff1_x4 1 2119 0 10354 1771 sff1_x4
xsubckt_8526_sff1_x4 1 2179 0 9831 154 sff1_x4
xsubckt_8961_sff1_x4 1 2238 0 9464 1588 sff1_x4
xsubckt_2427_mx2_x2 0 5924 1 816 994 962 mx2_x2
xsubckt_2425_mx2_x2 0 5926 1 791 5927 5928 mx2_x2
xsubckt_2423_mx2_x2 0 5928 1 816 1186 1090 mx2_x2
xsubckt_2396_nor3_x0 1 0 5960 1899 1908 1895 nor3_x0
xsubckt_2036_mx2_x2 0 6412 1 826 6413 6420 mx2_x2
xsubckt_2034_mx2_x2 0 6414 1 836 6415 6416 mx2_x2
xsubckt_2032_mx2_x2 0 6416 1 866 1591 1559 mx2_x2
xsubckt_1741_nand2_x0 1 0 6639 6943 7132 nand2_x0
xsubckt_1488_nand2_x0 1 0 6875 6943 7051 nand2_x0
xsubckt_152_inv_x0 1 0 711 8247 inv_x0
xsubckt_154_inv_x0 1 0 427 8242 inv_x0
xsubckt_156_inv_x0 1 0 425 8240 inv_x0
xsubckt_1080_oa22_x2 0 7279 1 412 7810 7618 oa22_x2
xsubckt_1168_oa22_x2 0 7196 1 7213 7211 7212 oa22_x2
xsubckt_2770_mx2_x2 0 5587 1 816 1638 1606 mx2_x2
xsubckt_2818_mx2_x2 0 5540 1 816 1413 1381 mx2_x2
xsubckt_3593_nand2_x0 1 0 4778 4779 8024 nand2_x0
xsubckt_3698_mx2_x2 0 4675 1 815 979 947 mx2_x2
xsubckt_5033_oa22_x2 0 9839 1 7884 3847 3856 oa22_x2
xsubckt_6887_oa22_x2 0 9660 1 8798 8794 8795 oa22_x2
xsubckt_7123_xr2_x1 8653 0 1 366 365 xr2_x1
xsubckt_7657_mx2_x2 0 9165 1 8454 6278 1058 mx2_x2
xsubckt_7659_mx2_x2 0 9163 1 8454 6266 1036 mx2_x2
xsubckt_8077_sff1_x4 1 2189 0 10280 1157 sff1_x4
xsubckt_8434_sff1_x4 1 2057 0 9923 1973 sff1_x4
xsubckt_8957_sff1_x4 1 2242 0 9468 1593 sff1_x4
xsubckt_9334_sff1_x4 1 2116 0 9106 1006 sff1_x4
xsubckt_2429_mx2_x2 0 5922 1 8022 5923 5926 mx2_x2
xsubckt_2383_mx2_x2 0 5973 1 819 1891 1539 mx2_x2
xsubckt_2381_mx2_x2 0 5975 1 819 1059 1027 mx2_x2
xsubckt_2305_a3_x2 1 6075 0 6093 76 75 a3_x2
xsubckt_2038_mx2_x2 0 6410 1 850 1719 1687 mx2_x2
xsubckt_1827_nand3_x0 1 0 6559 6593 8048 8049 nand3_x0
xsubckt_1651_nand2_x0 1 0 6723 6942 7102 nand2_x0
xsubckt_158_inv_x0 1 0 430 8238 inv_x0
xsubckt_1015_a2_x2 0 7340 1 7341 7349 a2_x2
xsubckt_2520_a3_x2 1 5833 0 569 8290 70 a3_x2
xsubckt_2772_mx2_x2 0 5585 1 8030 5586 5587 mx2_x2
xsubckt_2774_mx2_x2 0 5583 1 819 1478 1446 mx2_x2
xsubckt_2776_mx2_x2 0 5581 1 8030 5582 5583 mx2_x2
xsubckt_3325_nand2_x0 1 0 10399 5042 5099 nand2_x0
xsubckt_3679_nand3_x0 1 0 4693 4694 4869 6391 nand3_x0
xsubckt_5425_nxr2_x1 3482 1 0 3865 8268 nxr2_x1
xsubckt_6340_mx2_x2 0 2681 1 8223 2682 2683 mx2_x2
xsubckt_6342_mx2_x2 0 2679 1 866 1144 1112 mx2_x2
xsubckt_6731_mx2_x2 0 8922 1 836 8923 8924 mx2_x2
xsubckt_6733_mx2_x2 0 8920 1 826 8921 8928 mx2_x2
xsubckt_7585_a4_x2 0 8467 1 6306 6309 556 555 a4_x2
xsubckt_2389_mx2_x2 0 5967 1 8028 5968 5969 mx2_x2
xsubckt_2387_mx2_x2 0 5969 1 818 1795 1763 mx2_x2
xsubckt_2385_mx2_x2 0 5971 1 8028 5972 5973 mx2_x2
xsubckt_1983_mx3_x2 1 0 493 8002 6450 241 116 148 mx3_x2
xsubckt_1981_mx3_x2 1 0 495 8002 6450 243 118 150 mx3_x2
xsubckt_1471_nand2_x0 1 0 6891 6942 7042 nand2_x0
xsubckt_428_ao22_x2 0 7913 1 7914 7917 7923 ao22_x2
xsubckt_877_nand2_x0 1 0 7471 1999 637 nand2_x0
xsubckt_967_nand2_x0 1 0 7386 7387 1894 nand2_x0
xsubckt_1075_a2_x2 0 7284 1 749 74 a2_x2
xsubckt_2786_a4_x2 0 5571 1 5613 5998 6015 7902 a4_x2
xsubckt_2960_nand3_x0 1 0 5400 5401 5617 6392 nand3_x0
xsubckt_3322_a2_x2 0 5044 1 5045 5047 a2_x2
xsubckt_3499_nand3_x0 1 0 4870 4871 5046 6392 nand3_x0
xsubckt_4027_nand2_x0 1 0 4351 4352 8021 nand2_x0
xsubckt_4906_a3_x2 1 3944 0 52 67 8399 a3_x2
xsubckt_5140_ao22_x2 0 3747 1 3748 3749 3754 ao22_x2
xsubckt_5333_nxr2_x1 3568 1 0 3569 3570 nxr2_x1
xsubckt_6344_mx2_x2 0 2677 1 8212 2678 2681 mx2_x2
xsubckt_6346_mx2_x2 0 2675 1 849 1592 1560 mx2_x2
xsubckt_6735_mx2_x2 0 8918 1 849 1291 1259 mx2_x2
xsubckt_6737_mx2_x2 0 8916 1 849 1227 1195 mx2_x2
xsubckt_6739_mx2_x2 0 8914 1 8226 8915 8916 mx2_x2
xsubckt_6920_ao22_x2 0 8770 1 706 8279 614 ao22_x2
xsubckt_7272_a2_x2 0 8562 1 716 652 a2_x2
xsubckt_8342_sff1_x4 1 2248 0 10015 1338 sff1_x4
xsubckt_8865_sff1_x4 1 2076 0 9560 363 sff1_x4
xsubckt_9242_sff1_x4 1 2099 0 9198 1443 sff1_x4
xsubckt_1989_mx3_x2 1 0 486 8001 6450 234 109 141 mx3_x2
xsubckt_1987_mx3_x2 1 0 488 8001 6450 236 111 143 mx3_x2
xsubckt_1985_mx3_x2 1 0 491 8001 6450 239 114 146 mx3_x2
xsubckt_1632_ao22_x2 0 6741 1 6759 211 8415 ao22_x2
xsubckt_1468_nxr2_x1 6894 1 0 6897 8134 nxr2_x1
xsubckt_1467_nand3_x0 1 0 6895 6898 6900 8134 nand3_x0
xsubckt_1381_nand2_x0 1 0 6984 197 8078 nand2_x0
xsubckt_787_nand2_x0 1 0 7557 7730 328 nand2_x0
xsubckt_1095_a2_x2 0 7265 1 748 73 a2_x2
xsubckt_2780_nand3_x0 1 0 5577 5578 5579 8017 nand3_x0
xsubckt_3382_a2_x2 0 4985 1 4986 4988 a2_x2
xsubckt_3811_a2_x2 0 4564 1 231 750 a2_x2
xsubckt_4692_a3_x2 1 4103 0 1915 1914 1974 a3_x2
xsubckt_4921_oa22_x2 0 9865 1 7884 3933 3935 oa22_x2
xsubckt_4926_a3_x2 1 3929 0 51 62 8398 a3_x2
xsubckt_4946_a3_x2 1 3914 0 51 87 8398 a3_x2
xsubckt_4966_a3_x2 1 3899 0 51 82 8398 a3_x2
xsubckt_6348_mx2_x2 0 2673 1 852 1496 1464 mx2_x2
xsubckt_6691_mx2_x2 0 2340 1 852 1165 1069 mx2_x2
xsubckt_6693_mx2_x2 0 2338 1 852 973 941 mx2_x2
xsubckt_6695_mx2_x2 0 2336 1 833 2337 2338 mx2_x2
xsubckt_6812_a2_x2 0 9673 1 8848 51 a2_x2
xsubckt_7965_sff1_x4 1 2092 0 10392 233 sff1_x4
xsubckt_9150_sff1_x4 1 2126 0 9290 1385 sff1_x4
xsubckt_9238_sff1_x4 1 2110 0 9202 1070 sff1_x4
xsubckt_2241_oa22_x2 0 6157 1 6174 86 85 oa22_x2
xsubckt_1341_oa22_x2 0 7024 1 7025 7026 7056 oa22_x2
xsubckt_950_nand2_x0 1 0 7402 238 1898 nand2_x0
xsubckt_3137_oa22_x2 0 5226 1 5227 5266 5958 oa22_x2
xsubckt_3925_nand2_x0 1 0 10389 4452 4509 nand2_x0
xsubckt_4100_nand2_x0 1 0 10386 4280 4334 nand2_x0
xsubckt_4819_a2_x2 0 4006 1 4009 1940 a2_x2
xsubckt_4859_a2_x2 0 9883 1 3977 42 a2_x2
xsubckt_4917_oa22_x2 0 9866 1 7886 3936 3938 oa22_x2
xsubckt_4986_a3_x2 1 3884 0 42 76 8397 a3_x2
xsubckt_5771_mx2_x2 0 3234 1 834 3235 3236 mx2_x2
xsubckt_5817_oa22_x2 0 3193 1 42 1905 441 oa22_x2
xsubckt_5819_mx2_x2 0 3188 1 850 904 872 mx2_x2
xsubckt_6697_mx2_x2 0 2334 1 826 2335 2342 mx2_x2
xsubckt_6699_mx2_x2 0 2332 1 851 1293 1261 mx2_x2
xsubckt_7002_oa22_x2 0 9635 1 8703 8711 8726 oa22_x2
xsubckt_8250_sff1_x4 1 2219 0 10107 1685 sff1_x4
xsubckt_8338_sff1_x4 1 2251 0 10019 1342 sff1_x4
xsubckt_8773_sff1_x4 1 2073 0 9649 614 sff1_x4
xsubckt_2237_oa22_x2 0 6163 1 6164 6165 6166 oa22_x2
xsubckt_1733_nxr2_x1 6647 1 0 6649 203 nxr2_x1
xsubckt_1512_o2_x2 0 6853 1 6854 6860 o2_x2
xsubckt_1284_xr2_x1 7081 0 1 213 246 xr2_x1
xsubckt_860_nand2_x0 1 0 181 7488 7501 nand2_x0
xsubckt_2605_nor2_x0 1 0 5749 223 742 nor2_x0
xsubckt_3330_o2_x2 0 5037 1 240 759 o2_x2
xsubckt_4111_mx2_x2 0 4269 1 795 1867 1515 mx2_x2
xsubckt_4240_mx3_x2 1 0 10310 4211 6288 1761 6206 6210 mx3_x2
xsubckt_4500_mx2_x2 0 10070 1 4168 6061 1296 mx2_x2
xsubckt_4502_mx2_x2 0 10068 1 4168 6044 1294 mx2_x2
xsubckt_5213_nor2_x0 1 0 3679 3680 7881 nor2_x0
xsubckt_5773_mx2_x2 0 3232 1 857 1891 1539 mx2_x2
xsubckt_5775_mx2_x2 0 3230 1 830 3231 3234 mx2_x2
xsubckt_5777_mx2_x2 0 3228 1 823 3229 3244 mx2_x2
xsubckt_9146_sff1_x4 1 2095 0 9294 1411 sff1_x4
xsubckt_1806_o2_x2 0 2302 1 6579 6583 o2_x2
xsubckt_1288_xr2_x1 7077 0 1 214 247 xr2_x1
xsubckt_70_inv_x0 1 0 1938 8341 inv_x0
xsubckt_72_inv_x0 1 0 1941 8339 inv_x0
xsubckt_680_nand2_x0 1 0 7662 7663 7798 nand2_x0
xsubckt_856_nand3_x0 1 0 7491 7492 7493 7494 nand3_x0
xsubckt_2863_nand2_x0 1 0 5496 5497 781 nand2_x0
xsubckt_3568_oa22_x2 0 4803 1 4861 4858 4860 oa22_x2
xsubckt_4094_nand3_x0 1 0 4285 4342 4457 6391 nand3_x0
xsubckt_4113_mx2_x2 0 4267 1 8032 4268 4269 mx2_x2
xsubckt_4115_mx2_x2 0 4265 1 795 1707 1675 mx2_x2
xsubckt_4117_mx2_x2 0 4263 1 790 4264 4265 mx2_x2
xsubckt_4460_mx2_x2 0 10107 1 4174 6108 1685 mx2_x2
xsubckt_4504_mx2_x2 0 10066 1 4168 6026 1291 mx2_x2
xsubckt_5209_nor2_x0 1 0 3683 3684 3686 nor2_x0
xsubckt_5237_nxr2_x1 3657 1 0 3904 714 nxr2_x1
xsubckt_6176_oa22_x2 0 2840 1 3191 2843 2841 oa22_x2
xsubckt_6391_o2_x2 0 2631 1 2632 7930 o2_x2
xsubckt_6898_ao22_x2 0 8786 1 706 8278 665 ao22_x2
xsubckt_8246_sff1_x4 1 2222 0 10111 1690 sff1_x4
xsubckt_8681_sff1_x4 1 2086 0 9709 467 sff1_x4
xsubckt_8769_sff1_x4 1 2070 0 9653 621 sff1_x4
xsubckt_1891_nand2_x0 1 0 6499 6943 7180 nand2_x0
xsubckt_1803_nand2_x0 1 0 6581 6943 7148 nand2_x0
xsubckt_1397_o2_x2 0 6968 1 468 249 o2_x2
xsubckt_74_inv_x0 1 0 1945 8337 inv_x0
xsubckt_76_inv_x0 1 0 1947 8335 inv_x0
xsubckt_78_inv_x0 1 0 1949 8333 inv_x0
xsubckt_601_ao22_x2 0 7738 1 7765 7750 7752 ao22_x2
xsubckt_766_nand3_x0 1 0 7577 7578 7579 1903 nand3_x0
xsubckt_2773_nand2_x0 1 0 5584 5585 8024 nand2_x0
xsubckt_2859_nand3_x0 1 0 5500 567 8289 62 nand3_x0
xsubckt_3565_nand2_x0 1 0 10395 4806 4863 nand2_x0
xsubckt_4071_mx2_x2 0 4308 1 794 1421 1389 mx2_x2
xsubckt_4119_mx2_x2 0 4261 1 794 907 875 mx2_x2
xsubckt_4462_mx2_x2 0 10105 1 4174 6089 1683 mx2_x2
xsubckt_4464_mx2_x2 0 10103 1 4174 6071 1681 mx2_x2
xsubckt_4466_mx2_x2 0 10101 1 4174 6054 1679 mx2_x2
xsubckt_5195_nor2_x0 1 0 3696 3697 3700 nor2_x0
xsubckt_5276_oa22_x2 0 3621 1 3633 3631 3632 oa22_x2
xsubckt_6975_nor2_x0 1 0 9637 8728 8305 nor2_x0
xsubckt_8603_sff1_x4 1 2044 0 9754 1990 sff1_x4
xsubckt_8677_sff1_x4 1 2063 0 9712 505 sff1_x4
xsubckt_9054_sff1_x4 1 2238 0 9376 1373 sff1_x4
xcmpt_abc_30082_new_n7831_hfns_2 1 0 4158 4155 buf_x4
xcmpt_abc_30082_new_n7831_hfns_1 1 0 4155 4156 buf_x4
xcmpt_abc_30082_new_n7831_hfns_0 1 0 4155 4157 buf_x4
xsubckt_1623_nand2_x0 1 0 6749 7092 7972 nand2_x0
xsubckt_1192_nxr2_x1 7173 1 0 194 225 nxr2_x1
xsubckt_410_a2_x2 0 7935 1 7936 7942 a2_x2
xsubckt_2502_oa22_x2 0 5850 1 5851 5886 5958 oa22_x2
xsubckt_3540_mx2_x2 0 4830 1 8033 4831 4832 mx2_x2
xsubckt_4075_mx2_x2 0 4304 1 793 1581 1549 mx2_x2
xsubckt_4079_mx2_x2 0 4300 1 793 1133 1101 mx2_x2
xsubckt_4468_mx2_x2 0 10099 1 4174 6035 1677 mx2_x2
xsubckt_4610_nand2_x0 1 0 4148 4165 4194 nand2_x0
xsubckt_5149_nand2_x0 1 0 3739 3740 3741 nand2_x0
xsubckt_5184_oa22_x2 0 3706 1 3707 3713 8277 oa22_x2
xsubckt_7254_nand2_x0 1 0 8576 8577 8578 nand2_x0
xsubckt_7630_mx3_x2 1 0 9189 8462 6291 1412 6215 6219 mx3_x2
xsubckt_8154_sff1_x4 1 2224 0 10203 1461 sff1_x4
xsubckt_8511_sff1_x4 1 2153 0 9846 74 sff1_x4
xsubckt_9411_sff1_x4 1 2204 0 9032 903 sff1_x4
xsubckt_1801_ao22_x2 0 6583 1 6584 6585 6940 ao22_x2
xsubckt_1533_nand2_x0 1 0 6833 6943 7064 nand2_x0
xsubckt_490_a2_x2 0 7845 1 702 8294 a2_x2
xsubckt_3542_mx2_x2 0 4828 1 799 1238 1206 mx2_x2
xsubckt_3544_mx2_x2 0 4826 1 8033 4827 4828 mx2_x2
xsubckt_3546_mx2_x2 0 4824 1 799 1366 1334 mx2_x2
xsubckt_5106_oa22_x2 0 3779 1 3796 3795 3794 oa22_x2
xsubckt_7110_mx2_x2 0 9566 1 6441 8663 579 mx2_x2
xsubckt_7112_mx2_x2 0 9565 1 6441 8662 578 mx2_x2
xsubckt_7501_mx2_x2 0 9310 1 8480 6152 1115 mx2_x2
xsubckt_7503_mx2_x2 0 9308 1 8480 6135 1113 mx2_x2
xsubckt_7632_mx3_x2 1 0 9187 8462 6291 1440 6197 6201 mx3_x2
xsubckt_8062_sff1_x4 1 2109 0 10295 1745 sff1_x4
xsubckt_8585_sff1_x4 1 2096 0 9772 2010 sff1_x4
xsubckt_9407_sff1_x4 1 2095 0 9036 919 sff1_x4
xsubckt_9485_sff1_x4 1 2203 0 8958 1851 sff1_x4
xsubckt_2235_nand2_x0 1 0 6165 6174 86 nand2_x0
xsubckt_1401_a4_x2 0 6964 1 6965 7047 7066 7085 a4_x2
xsubckt_1188_nxr2_x1 7177 1 0 193 224 nxr2_x1
xsubckt_505_ao22_x2 0 7831 1 7962 7984 42 ao22_x2
xsubckt_589_a2_x2 0 7749 1 7751 7766 a2_x2
xsubckt_741_oa22_x2 0 7601 1 7626 7625 7624 oa22_x2
xsubckt_759_nand2_x0 1 0 7583 7584 7588 nand2_x0
xsubckt_829_oa22_x2 0 7517 1 7518 7519 7617 oa22_x2
xsubckt_2842_nand3_x0 1 0 5516 5517 5691 6391 nand3_x0
xsubckt_3027_nand2_x0 1 0 5335 5993 245 nand2_x0
xsubckt_3117_nand2_x0 1 0 5246 5247 779 nand2_x0
xsubckt_3148_ao22_x2 0 5216 1 5276 5274 5271 ao22_x2
xsubckt_3159_mx2_x2 0 5205 1 797 1053 1021 mx2_x2
xsubckt_3548_mx2_x2 0 4822 1 8033 4823 4824 mx2_x2
xsubckt_3752_xr2_x1 4622 0 1 232 751 xr2_x1
xsubckt_3891_mx2_x2 0 4485 1 8033 4486 4487 mx2_x2
xsubckt_3893_mx2_x2 0 4483 1 798 1488 1456 mx2_x2
xsubckt_3895_mx2_x2 0 4481 1 8033 4482 4483 mx2_x2
xsubckt_3939_mx2_x2 0 4438 1 798 1039 1007 mx2_x2
xsubckt_5053_nxr2_x1 3828 1 0 3943 727 nxr2_x1
xsubckt_7505_mx2_x2 0 9306 1 8479 6115 1110 mx2_x2
xsubckt_7507_mx2_x2 0 9304 1 8480 6097 1108 mx2_x2
xsubckt_7509_mx2_x2 0 9302 1 8480 6081 1106 mx2_x2
xsubckt_7850_mx2_x2 0 8950 1 8429 6081 1842 mx2_x2
xsubckt_7852_mx2_x2 0 8948 1 8429 6061 1840 mx2_x2
xsubckt_8507_sff1_x4 1 2159 0 9850 78 sff1_x4
xsubckt_8942_sff1_x4 1 2099 0 9483 1580 sff1_x4
xsubckt_9393_sff1_x4 1 2216 0 9050 950 sff1_x4
xcmpt_abc_30082_new_n7797_hfns_2 1 0 4163 4160 buf_x4
xcmpt_abc_30082_new_n7797_hfns_1 1 0 4160 4161 buf_x4
xcmpt_abc_30082_new_n7797_hfns_0 1 0 4160 4162 buf_x4
xsubckt_2233_mx2_x2 0 6167 1 545 117 2281 mx2_x2
xsubckt_1149_oa22_x2 0 165 1 7227 7226 7214 oa22_x2
xsubckt_3897_mx2_x2 0 4479 1 821 1648 1616 mx2_x2
xsubckt_3899_mx2_x2 0 4477 1 8034 4478 4479 mx2_x2
xsubckt_4402_a4_x2 0 4182 1 6307 7884 556 555 a4_x2
xsubckt_7118_mx2_x2 0 9563 1 3282 8658 502 mx2_x2
xsubckt_7463_mx2_x2 0 9346 1 8484 6188 895 mx2_x2
xsubckt_7465_mx2_x2 0 9344 1 8484 6169 893 mx2_x2
xsubckt_7594_mx3_x2 1 0 9223 8467 6293 1062 6236 6240 mx3_x2
xsubckt_7596_mx3_x2 1 0 9221 8467 6293 1060 6215 6219 mx3_x2
xsubckt_7598_mx3_x2 1 0 9219 8467 6293 1088 6196 6201 mx3_x2
xsubckt_7854_mx2_x2 0 8946 1 8428 6044 1838 mx2_x2
xsubckt_7856_mx2_x2 0 8944 1 8429 6027 1835 mx2_x2
xsubckt_8058_sff1_x4 1 2219 0 10299 1749 sff1_x4
xsubckt_8493_sff1_x4 1 2169 0 9864 63 sff1_x4
xsubckt_9315_sff1_x4 1 2198 0 9125 996 sff1_x4
xsubckt_2263_a3_x2 1 6129 0 6147 83 82 a3_x2
xsubckt_2239_mx2_x2 0 6159 1 547 116 2280 mx2_x2
xsubckt_489_nand2_x0 1 0 10466 7846 47 nand2_x0
xsubckt_579_nand2_x0 1 0 7759 7760 7798 nand2_x0
xsubckt_684_o3_x2 0 7658 1 403 330 328 o3_x2
xsubckt_1061_oa22_x2 0 7297 1 413 7809 7618 oa22_x2
xsubckt_1083_nand2_x0 1 0 7276 230 1898 nand2_x0
xsubckt_1173_nand2_x0 1 0 7191 7192 1894 nand2_x0
xsubckt_2580_mx2_x2 0 5774 1 789 5775 5776 mx2_x2
xsubckt_2582_mx2_x2 0 5772 1 820 1865 1513 mx2_x2
xsubckt_2584_mx2_x2 0 5770 1 782 5771 5774 mx2_x2
xsubckt_3737_oa22_x2 0 4636 1 4637 4676 5958 oa22_x2
xsubckt_5088_oa22_x2 0 3796 1 3805 3803 3804 oa22_x2
xsubckt_5244_a3_x2 1 3651 0 54 146 8397 a3_x2
xsubckt_6541_mx2_x2 0 2486 1 8221 2487 2488 mx2_x2
xsubckt_7078_mx2_x2 0 9597 1 8666 6278 1538 mx2_x2
xsubckt_7130_a2_x2 0 8647 1 7997 503 a2_x2
xsubckt_7233_nand3_x0 1 0 8591 8592 8604 8609 nand3_x0
xsubckt_7467_mx2_x2 0 9342 1 8485 6152 891 mx2_x2
xsubckt_7469_mx2_x2 0 9340 1 8485 6134 889 mx2_x2
xsubckt_8415_sff1_x4 1 2129 0 9942 1616 sff1_x4
xsubckt_8850_sff1_x4 1 2136 0 9575 1523 sff1_x4
xsubckt_8938_sff1_x4 1 2086 0 9487 767 sff1_x4
xsubckt_9389_sff1_x4 1 2203 0 9054 955 sff1_x4
xcmpt_abc_30082_new_n5604_hfns_2 1 0 6063 6060 buf_x4
xcmpt_abc_30082_new_n5604_hfns_1 1 0 6060 6061 buf_x4
xcmpt_abc_30082_new_n5604_hfns_0 1 0 6060 6062 buf_x4
xsubckt_2197_mx2_x2 0 6223 1 6297 6225 6230 mx2_x2
xsubckt_2195_mx2_x2 0 6231 1 546 94 2258 mx2_x2
xsubckt_1810_nxr2_x1 6575 1 0 6576 8049 nxr2_x1
xsubckt_1492_oa22_x2 0 6872 1 6888 6880 6881 oa22_x2
xsubckt_606_nxr2_x1 7733 1 0 7734 7738 nxr2_x1
xsubckt_1079_nand3_x0 1 0 7280 7281 7282 1902 nand3_x0
xsubckt_2586_mx2_x2 0 5768 1 809 1225 1193 mx2_x2
xsubckt_2588_mx2_x2 0 5766 1 8035 5767 5768 mx2_x2
xsubckt_2979_mx2_x2 0 5382 1 820 992 960 mx2_x2
xsubckt_3010_nand2_x0 1 0 5351 5352 8023 nand2_x0
xsubckt_3717_nand2_x0 1 0 4656 4657 781 nand2_x0
xsubckt_4403_a2_x2 0 4181 1 4182 4183 a2_x2
xsubckt_4776_a4_x2 0 4039 1 4042 4054 4065 1951 a4_x2
xsubckt_5392_nxr2_x1 3513 1 0 3871 730 nxr2_x1
xsubckt_5445_oa22_x2 0 3466 1 2041 2040 2029 oa22_x2
xsubckt_6150_mx2_x2 0 2866 1 864 1885 1533 mx2_x2
xsubckt_6152_mx2_x2 0 2864 1 8221 2865 2866 mx2_x2
xsubckt_6154_mx2_x2 0 2862 1 858 1053 1021 mx2_x2
xsubckt_6543_mx2_x2 0 2484 1 858 1777 1745 mx2_x2
xsubckt_6545_mx2_x2 0 2482 1 8214 2483 2486 mx2_x2
xsubckt_6547_mx2_x2 0 2480 1 858 1169 1073 mx2_x2
xsubckt_7950_sff1_x4 1 2166 0 10407 219 sff1_x4
xsubckt_8489_sff1_x4 1 2169 0 9868 67 sff1_x4
xsubckt_9223_sff1_x4 1 2245 0 9217 1086 sff1_x4
xcmpt_abc_30082_new_n10875_hfns_2 1 0 8466 8463 buf_x4
xcmpt_abc_30082_new_n10875_hfns_1 1 0 8463 8464 buf_x4
xcmpt_abc_30082_new_n10875_hfns_0 1 0 8463 8465 buf_x4
xcmpt_abc_30082_new_n5562_hfns_2 1 0 6117 6114 buf_x4
xcmpt_abc_30082_new_n5562_hfns_1 1 0 6114 6115 buf_x4
xcmpt_abc_30082_new_n5562_hfns_0 1 0 6114 6116 buf_x4
xsubckt_1953_nand2_x0 1 0 6458 7810 199 nand2_x0
xsubckt_1863_nand2_x0 1 0 6525 6947 7169 nand2_x0
xsubckt_1668_a3_x2 1 6707 0 6708 6709 6710 a3_x2
xsubckt_1287_a2_x2 0 7078 1 214 247 a2_x2
xsubckt_652_nand2_x0 1 0 7689 7690 7692 nand2_x0
xsubckt_3627_nand2_x0 1 0 4745 5993 234 nand2_x0
xsubckt_4689_a3_x2 1 4106 0 4107 4117 4143 a3_x2
xsubckt_4884_a3_x2 1 9875 0 3960 3961 46 a3_x2
xsubckt_5372_a2_x2 0 3532 1 3873 8278 a2_x2
xsubckt_5626_a2_x2 0 9751 1 3342 46 a2_x2
xsubckt_6156_mx2_x2 0 2860 1 8215 2861 2864 mx2_x2
xsubckt_6158_mx2_x2 0 2858 1 862 1373 1341 mx2_x2
xsubckt_6549_mx2_x2 0 2478 1 862 977 945 mx2_x2
xsubckt_7050_o3_x2 0 8686 1 579 571 649 o3_x2
xsubckt_7190_a2_x2 0 8621 1 721 8422 a2_x2
xsubckt_7946_sff1_x4 1 2086 0 10411 223 sff1_x4
xsubckt_8323_sff1_x4 1 2119 0 10034 1643 sff1_x4
xsubckt_8846_sff1_x4 1 2222 0 9579 1528 sff1_x4
xsubckt_9297_sff1_x4 1 2136 0 9143 1043 sff1_x4
xcmpt_abc_30082_new_n5568_hfns_2 1 0 6109 6106 buf_x4
xcmpt_abc_30082_new_n5568_hfns_1 1 0 6106 6107 buf_x4
xcmpt_abc_30082_new_n5568_hfns_0 1 0 6106 6108 buf_x4
xsubckt_588_nxr2_x1 7750 1 0 756 81 nxr2_x1
xsubckt_648_nand3_x0 1 0 161 7693 7701 7709 nand3_x0
xsubckt_982_xr2_x1 7372 0 1 754 79 xr2_x1
xsubckt_1134_xr2_x1 7228 0 1 746 71 xr2_x1
xsubckt_3537_nand2_x0 1 0 4833 4834 784 nand2_x0
xsubckt_4737_a2_x2 0 9913 1 4069 55 a2_x2
xsubckt_5970_mx2_x2 0 3041 1 840 1860 1508 mx2_x2
xsubckt_6610_oa22_x2 0 2419 1 55 1906 197 oa22_x2
xsubckt_6809_a2_x2 0 9674 1 8850 55 a2_x2
xsubckt_6996_a3_x2 1 8708 0 371 372 373 a3_x2
xsubckt_8319_sff1_x4 1 2129 0 10038 1648 sff1_x4
xsubckt_8397_sff1_x4 1 2229 0 9960 1605 sff1_x4
xsubckt_8754_sff1_x4 1 2070 0 9668 656 sff1_x4
xsubckt_9131_sff1_x4 1 2251 0 9309 1114 sff1_x4
xsubckt_9219_sff1_x4 1 2192 0 9221 1060 sff1_x4
xsubckt_1796_a2_x2 0 6588 1 6589 231 a2_x2
xsubckt_3357_nand2_x0 1 0 5010 5011 780 nand2_x0
xsubckt_4310_mx2_x2 0 10244 1 4199 6189 1247 mx2_x2
xsubckt_4797_a2_x2 0 9898 1 4024 50 a2_x2
xsubckt_4845_nxr2_x1 3987 1 0 3989 8345 nxr2_x1
xsubckt_5222_nxr2_x1 3671 1 0 3907 715 nxr2_x1
xsubckt_5261_oa22_x2 0 3635 1 3900 3663 3897 oa22_x2
xsubckt_5300_o2_x2 0 9820 1 3599 3612 o2_x2
xsubckt_5972_mx2_x2 0 3039 1 8223 3040 3041 mx2_x2
xsubckt_5974_mx2_x2 0 3037 1 840 1028 996 mx2_x2
xsubckt_5976_mx2_x2 0 3035 1 8213 3036 3039 mx2_x2
xsubckt_7122_nand4_x0 1 0 8654 8655 7999 8300 50 nand4_x0
xsubckt_7226_nand2_x0 1 0 8596 7976 379 nand2_x0
xsubckt_8231_sff1_x4 1 2095 0 10126 1687 sff1_x4
xsubckt_9127_sff1_x4 1 2251 0 9313 1118 sff1_x4
xsubckt_1593_nand2_x0 1 0 6777 7082 7971 nand2_x0
xsubckt_1529_o2_x2 0 6837 1 6838 6846 o2_x2
xsubckt_631_nand3_x0 1 0 7709 7710 7711 1902 nand3_x0
xsubckt_1096_xr2_x1 7264 0 1 748 73 xr2_x1
xsubckt_3177_nand2_x0 1 0 5187 5188 780 nand2_x0
xsubckt_3267_nand2_x0 1 0 5099 5994 241 nand2_x0
xsubckt_4312_mx2_x2 0 10242 1 4199 6169 1245 mx2_x2
xsubckt_4314_mx2_x2 0 10240 1 4199 6152 1243 mx2_x2
xsubckt_4316_mx2_x2 0 10238 1 4198 6134 1241 mx2_x2
xsubckt_4447_mx3_x2 1 0 10120 4176 6290 1669 6226 6230 mx3_x2
xsubckt_4449_mx3_x2 1 0 10118 4176 6290 1697 6205 6210 mx3_x2
xsubckt_5198_mx2_x2 0 3693 1 8279 3694 3913 mx2_x2
xsubckt_5268_nor2_x0 1 0 3628 3629 3630 nor2_x0
xsubckt_5978_mx2_x2 0 3033 1 839 1348 1316 mx2_x2
xsubckt_6805_ao22_x2 0 8853 1 7911 7892 8854 ao22_x2
xsubckt_6861_nand3_x0 1 0 8810 8258 394 393 nand3_x0
xsubckt_7256_ao22_x2 0 8575 1 662 644 389 ao22_x2
xsubckt_8227_sff1_x4 1 2137 0 10130 1259 sff1_x4
xsubckt_8662_sff1_x4 1 2185 0 9727 527 sff1_x4
xcmpt_abc_30082_new_n3724_hfns_2 1 0 7906 7903 buf_x4
xcmpt_abc_30082_new_n3724_hfns_1 1 0 7903 7904 buf_x4
xcmpt_abc_30082_new_n3724_hfns_0 1 0 7903 7905 buf_x4
xsubckt_1744_o2_x2 0 2306 1 6637 6641 o2_x2
xsubckt_1499_nand3_x0 1 0 6865 6866 6867 6940 nand3_x0
xsubckt_486_a4_x2 0 7848 1 7849 7850 7851 7864 a4_x2
xsubckt_3516_nand3_x0 1 0 4854 4855 4856 7905 nand3_x0
xsubckt_3748_ao22_x2 0 4626 1 4686 4684 4681 ao22_x2
xsubckt_4270_mx2_x2 0 10282 1 4204 6245 1159 mx2_x2
xsubckt_4318_mx2_x2 0 10236 1 4199 6116 1238 mx2_x2
xsubckt_5099_ao22_x2 0 3785 1 7852 3792 3786 ao22_x2
xsubckt_6984_o3_x2 0 8720 1 385 384 383 o3_x2
xsubckt_9035_sff1_x4 1 2079 0 9395 379 sff1_x4
xsubckt_9470_sff1_x4 1 2126 0 8973 1858 sff1_x4
xsubckt_2019_nor3_x0 1 0 6429 711 710 709 nor3_x0
xsubckt_457_oa22_x2 0 10460 1 331 7888 7875 oa22_x2
xsubckt_376_nor2_x0 1 0 7969 623 620 nor2_x0
xsubckt_892_oa22_x2 0 7457 1 7614 7478 7458 oa22_x2
xsubckt_3001_mx2_x2 0 5360 1 8030 5361 5362 mx2_x2
xsubckt_3003_mx2_x2 0 5358 1 804 1248 1216 mx2_x2
xsubckt_3005_mx2_x2 0 5356 1 8030 5357 5358 mx2_x2
xsubckt_3957_nand2_x0 1 0 4420 4421 783 nand2_x0
xsubckt_4276_mx2_x2 0 10276 1 4204 6189 1183 mx2_x2
xsubckt_4278_mx2_x2 0 10274 1 4203 6170 1181 mx2_x2
xsubckt_8135_sff1_x4 1 2098 0 10222 1463 sff1_x4
xsubckt_8570_sff1_x4 1 2050 0 9787 2026 sff1_x4
xsubckt_8658_sff1_x4 1 2185 0 9731 531 sff1_x4
xsubckt_1748_nand4_x0 1 0 6633 6677 8042 8043 8044 nand4_x0
xsubckt_1618_nxr2_x1 6754 1 0 6757 244 nxr2_x1
xsubckt_447_a2_x2 0 7891 1 7892 7894 a2_x2
xsubckt_201_inv_x0 1 0 2279 8175 inv_x0
xsubckt_714_nand2_x0 1 0 7629 220 1899 nand2_x0
xsubckt_3007_mx2_x2 0 5354 1 803 1376 1344 mx2_x2
xsubckt_3009_mx2_x2 0 5352 1 8030 5353 5354 mx2_x2
xsubckt_3350_mx2_x2 0 5017 1 804 922 890 mx2_x2
xsubckt_3352_mx2_x2 0 5015 1 8030 5016 5017 mx2_x2
xsubckt_3354_mx2_x2 0 5013 1 804 1498 1466 mx2_x2
xsubckt_3867_nand2_x0 1 0 4509 5995 230 nand2_x0
xsubckt_4735_nand4_x0 1 0 4070 4072 4078 4091 4143 nand4_x0
xsubckt_7702_mx2_x2 0 9122 1 8448 6188 1023 mx2_x2
xsubckt_7833_mx3_x2 1 0 8967 8431 6288 1830 6236 6239 mx3_x2
xsubckt_7835_mx3_x2 1 0 8965 8431 6288 1828 6215 6219 mx3_x2
xsubckt_9466_sff1_x4 1 2111 0 8977 1869 sff1_x4
xsubckt_2364_nand3_x0 1 0 5996 5998 6015 7902 nand3_x0
xsubckt_1568_nand4_x0 1 0 6801 6845 8054 8055 8065 nand4_x0
xsubckt_203_inv_x0 1 0 2278 8173 inv_x0
xsubckt_205_inv_x0 1 0 2277 8171 inv_x0
xsubckt_207_inv_x0 1 0 2275 8169 inv_x0
xsubckt_2821_mx2_x2 0 5537 1 808 1637 1605 mx2_x2
xsubckt_3156_nand3_x0 1 0 5208 5209 5210 7905 nand3_x0
xsubckt_3213_xr2_x1 5152 0 1 242 761 xr2_x1
xsubckt_3356_mx2_x2 0 5011 1 8031 5012 5013 mx2_x2
xsubckt_3358_mx2_x2 0 5009 1 810 1658 1626 mx2_x2
xsubckt_3777_nand2_x0 1 0 4597 4598 782 nand2_x0
xsubckt_5557_nxr2_x1 3390 1 0 3393 8126 nxr2_x1
xsubckt_7660_mx2_x2 0 9162 1 8453 6259 1033 mx2_x2
xsubckt_7704_mx2_x2 0 9120 1 8449 6170 1021 mx2_x2
xsubckt_7706_mx2_x2 0 9118 1 8449 6152 1019 mx2_x2
xsubckt_7708_mx2_x2 0 9116 1 8449 6135 1017 mx2_x2
xsubckt_7837_mx3_x2 1 0 8963 8431 6288 1856 6196 6200 mx3_x2
xsubckt_8043_sff1_x4 1 2205 0 10314 1735 sff1_x4
xsubckt_8566_sff1_x4 1 2053 0 9791 2031 sff1_x4
xsubckt_9300_sff1_x4 1 2129 0 9140 1040 sff1_x4
xsubckt_2434_mx2_x2 0 5917 1 807 1250 1218 mx2_x2
xsubckt_2432_mx2_x2 0 5919 1 790 5920 5921 mx2_x2
xsubckt_2430_mx2_x2 0 5921 1 807 1314 1282 mx2_x2
xsubckt_2043_mx2_x2 0 6405 1 830 6406 6409 mx2_x2
xsubckt_2041_mx2_x2 0 6407 1 864 919 887 mx2_x2
xsubckt_1526_nxr2_x1 6840 1 0 6843 8065 nxr2_x1
xsubckt_1333_ao22_x2 0 7032 1 8285 468 7033 ao22_x2
xsubckt_444_nand2_x0 1 0 7894 1908 503 nand2_x0
xsubckt_161_inv_x0 1 0 376 8235 inv_x0
xsubckt_163_inv_x0 1 0 373 8233 inv_x0
xsubckt_209_inv_x0 1 0 2274 8167 inv_x0
xsubckt_562_o3_x2 0 7775 1 430 330 327 o3_x2
xsubckt_976_a2_x2 0 7377 1 7378 7384 a2_x2
xsubckt_2823_mx2_x2 0 5535 1 8031 5536 5537 mx2_x2
xsubckt_2825_mx2_x2 0 5533 1 808 1221 1189 mx2_x2
xsubckt_2827_mx2_x2 0 5531 1 8031 5532 5533 mx2_x2
xsubckt_3597_nand2_x0 1 0 4774 4775 781 nand2_x0
xsubckt_5102_a3_x2 1 3783 0 41 126 8397 a3_x2
xsubckt_5503_a4_x2 0 3427 1 3433 2027 2028 2030 a4_x2
xsubckt_5614_nand2_x0 1 0 3350 3353 1990 nand2_x0
xsubckt_6000_mx2_x2 0 3012 1 864 1857 1825 mx2_x2
xsubckt_7662_mx2_x2 0 9160 1 8454 6245 1031 mx2_x2
xsubckt_8039_sff1_x4 1 2095 0 10318 1751 sff1_x4
xsubckt_8400_sff1_x4 1 2229 0 9957 1632 sff1_x4
xsubckt_8923_sff1_x4 1 2153 0 9502 760 sff1_x4
xsubckt_8997_sff1_x4 1 2129 0 9428 1552 sff1_x4
xsubckt_9374_sff1_x4 1 2116 0 9069 962 sff1_x4
xsubckt_2447_nand2_x0 1 0 5904 5929 8012 nand2_x0
xsubckt_2438_mx2_x2 0 5913 1 811 1666 1634 mx2_x2
xsubckt_2436_mx2_x2 0 5915 1 8024 5916 5919 mx2_x2
xsubckt_2390_mx2_x2 0 5966 1 811 931 899 mx2_x2
xsubckt_2161_a3_x2 1 6284 0 6285 541 8409 a3_x2
xsubckt_2094_nand3_x0 1 0 6352 6353 7859 1899 nand3_x0
xsubckt_2049_mx2_x2 0 6399 1 836 6400 6401 mx2_x2
xsubckt_2047_mx2_x2 0 6401 1 840 1175 1079 mx2_x2
xsubckt_2045_mx2_x2 0 6403 1 840 1047 1015 mx2_x2
xsubckt_1565_oa22_x2 0 2289 1 6940 6804 6814 oa22_x2
xsubckt_1458_nor3_x0 1 0 6904 456 467 468 nor3_x0
xsubckt_435_o2_x2 0 7906 1 1908 1895 o2_x2
xsubckt_165_inv_x0 1 0 372 8231 inv_x0
xsubckt_167_inv_x0 1 0 371 8229 inv_x0
xsubckt_169_inv_x0 1 0 836 8227 inv_x0
xsubckt_582_o3_x2 0 7756 1 419 330 327 o3_x2
xsubckt_718_oa22_x2 0 7626 1 7646 7645 7644 oa22_x2
xsubckt_1042_oa22_x2 0 7315 1 414 7810 7618 oa22_x2
xsubckt_2829_mx2_x2 0 5529 1 813 1349 1317 mx2_x2
xsubckt_2857_nxr2_x1 5502 1 0 5503 5509 nxr2_x1
xsubckt_4817_ao22_x2 0 4008 1 1940 4009 40 ao22_x2
xsubckt_5416_a3_x2 1 3491 0 40 132 8399 a3_x2
xsubckt_6002_mx2_x2 0 3010 1 842 1729 1697 mx2_x2
xsubckt_6004_mx2_x2 0 3008 1 836 3009 3010 mx2_x2
xsubckt_6006_mx2_x2 0 3006 1 842 1889 1537 mx2_x2
xsubckt_6740_mx2_x2 0 8913 1 8215 8914 8917 mx2_x2
xsubckt_6901_a4_x2 0 8783 1 8827 8245 579 701 a4_x2
xsubckt_7275_mx2_x2 0 9501 1 8832 8560 761 mx2_x2
xsubckt_7668_mx2_x2 0 9154 1 8453 6189 1055 mx2_x2
xsubckt_8474_sff1_x4 1 2044 0 9883 1929 sff1_x4
xsubckt_8831_sff1_x4 1 2100 0 9594 1513 sff1_x4
xsubckt_8919_sff1_x4 1 2089 0 9506 755 sff1_x4
xsubckt_2394_mx2_x2 0 5962 1 8016 5963 5970 mx2_x2
xsubckt_2392_mx2_x2 0 5964 1 8033 5965 5966 mx2_x2
xsubckt_2357_nand2_x0 1 0 6003 6004 7818 nand2_x0
xsubckt_1990_mx3_x2 1 0 485 8002 6448 233 108 140 mx3_x2
xsubckt_1320_a2_x2 0 7045 1 456 237 a2_x2
xsubckt_1300_a2_x2 0 7065 1 7066 7085 a2_x2
xsubckt_475_o2_x2 0 7862 1 61 60 o2_x2
xsubckt_871_nand3_x0 1 0 7477 7480 7481 7619 nand3_x0
xsubckt_904_o2_x2 0 7446 1 759 84 o2_x2
xsubckt_2630_a3_x2 1 5725 0 569 8290 66 a3_x2
xsubckt_4742_a3_x2 1 4065 0 4066 4078 4091 a3_x2
xsubckt_5230_a2_x2 0 3664 1 3903 8279 a2_x2
xsubckt_5344_nand2_x0 1 0 3558 3569 3580 nand2_x0
xsubckt_6008_mx2_x2 0 3004 1 8218 3005 3006 mx2_x2
xsubckt_6351_mx2_x2 0 2670 1 8213 2671 2674 mx2_x2
xsubckt_6353_mx2_x2 0 2668 1 8207 2669 2684 mx2_x2
xsubckt_6742_mx2_x2 0 8911 1 842 1579 1547 mx2_x2
xsubckt_6744_mx2_x2 0 8909 1 842 1483 1451 mx2_x2
xsubckt_6746_mx2_x2 0 8907 1 8218 8908 8909 mx2_x2
xsubckt_7294_a3_x2 1 8544 0 8545 8546 8547 a3_x2
xsubckt_7931_sff1_x4 1 2129 0 10421 1808 sff1_x4
xsubckt_8382_sff1_x4 1 2116 0 9975 1489 sff1_x4
xsubckt_9204_sff1_x4 1 2132 0 9236 1200 sff1_x4
xsubckt_9282_sff1_x4 1 2235 0 9158 1029 sff1_x4
xsubckt_1996_mx3_x2 1 0 479 8002 6450 227 102 134 mx3_x2
xsubckt_1994_mx3_x2 1 0 481 8002 6450 229 104 136 mx3_x2
xsubckt_1992_mx3_x2 1 0 483 8002 6450 231 106 138 mx3_x2
xsubckt_1614_a2_x2 0 6758 1 6759 8416 a2_x2
xsubckt_1385_nand2_x0 1 0 6980 195 8073 nand2_x0
xsubckt_1360_a2_x2 0 7005 1 7006 7009 a2_x2
xsubckt_1185_a2_x2 0 7180 1 193 224 a2_x2
xsubckt_626_oa22_x2 0 7714 1 7737 7735 7736 oa22_x2
xsubckt_1165_a2_x2 0 7198 1 7199 7205 a2_x2
xsubckt_3269_oa22_x2 0 5097 1 5157 5155 5154 oa22_x2
xsubckt_3756_nand3_x0 1 0 4618 4619 4620 7905 nand3_x0
xsubckt_4830_a2_x2 0 9890 1 3999 43 a2_x2
xsubckt_4961_oa22_x2 0 9855 1 7885 3903 3905 oa22_x2
xsubckt_5820_mx2_x2 0 3187 1 844 1832 1800 mx2_x2
xsubckt_6359_mx2_x2 0 2663 1 844 918 886 mx2_x2
xsubckt_6748_mx2_x2 0 8905 1 827 8906 8913 mx2_x2
xsubckt_6834_a3_x2 1 8835 0 9419 9422 9421 a3_x2
xsubckt_7167_a2_x2 0 8640 1 435 436 a2_x2
xsubckt_8304_sff1_x4 1 2229 0 10053 1664 sff1_x4
xsubckt_8827_sff1_x4 1 2123 0 9598 1539 sff1_x4
xsubckt_9278_sff1_x4 1 2106 0 9162 1033 sff1_x4
xsubckt_1998_mx3_x2 1 0 476 8001 6450 224 99 131 mx3_x2
xsubckt_1331_xr2_x1 7034 0 1 467 217 xr2_x1
xsubckt_1281_nand4_x0 1 0 7084 7086 7090 7095 7099 nand4_x0
xsubckt_954_nand2_x0 1 0 7398 633 1966 nand2_x0
xsubckt_3921_a2_x2 0 4455 1 4456 4458 a2_x2
xsubckt_4104_nand2_x0 1 0 4276 4277 4279 nand2_x0
xsubckt_4695_a2_x2 0 9923 1 4101 4104 a2_x2
xsubckt_4870_a2_x2 0 9879 1 3970 55 a2_x2
xsubckt_4890_a2_x2 0 3955 1 3958 1918 a2_x2
xsubckt_5164_nand2_x0 1 0 3725 3919 8257 nand2_x0
xsubckt_5564_a2_x2 0 9769 1 3386 55 a2_x2
xsubckt_5822_mx2_x2 0 3185 1 865 1704 1672 mx2_x2
xsubckt_5824_mx2_x2 0 3183 1 833 3184 3185 mx2_x2
xsubckt_5826_mx2_x2 0 3181 1 865 1864 1512 mx2_x2
xsubckt_7927_sff1_x4 1 2209 0 10425 1812 sff1_x4
xsubckt_8290_sff1_x4 1 2119 0 10067 1293 sff1_x4
xsubckt_8378_sff1_x4 1 2223 0 9979 1493 sff1_x4
xsubckt_9112_sff1_x4 1 2138 0 9328 875 sff1_x4
xsubckt_9190_sff1_x4 1 2247 0 9250 1215 sff1_x4
xsubckt_2402_ao22_x2 0 5951 1 5952 5954 8271 ao22_x2
xsubckt_2340_nand2_x0 1 0 6030 6039 69 nand2_x0
xsubckt_1826_oa22_x2 0 6560 1 6577 6572 6573 oa22_x2
xsubckt_534_oa22_x2 0 7805 1 7806 7939 8239 oa22_x2
xcmpt_zero_105 1 0 3 zero_x1
xcmpt_zero_104 1 0 10 zero_x1
xcmpt_zero_103 1 0 11 zero_x1
xcmpt_zero_102 1 0 12 zero_x1
xcmpt_zero_101 1 0 13 zero_x1
xcmpt_zero_100 1 0 14 zero_x1
xsubckt_1027_nand2_x0 1 0 7329 7990 2025 nand2_x0
xsubckt_3396_nand3_x0 1 0 4972 4973 4974 7905 nand3_x0
xsubckt_4900_mx2_x2 0 3948 1 6444 6275 144 mx2_x2
xsubckt_4957_oa22_x2 0 9856 1 7884 3906 3908 oa22_x2
xsubckt_5780_mx2_x2 0 3226 1 865 1314 1282 mx2_x2
xsubckt_5782_mx2_x2 0 3224 1 833 3225 3226 mx2_x2
xsubckt_5784_mx2_x2 0 3222 1 865 1154 1122 mx2_x2
xsubckt_5828_mx2_x2 0 3179 1 8220 3180 3181 mx2_x2
xsubckt_6142_oa22_x2 0 2874 1 54 1906 210 oa22_x2
xsubckt_6864_ao22_x2 0 8808 1 706 8277 659 ao22_x2
xsubckt_7329_ao22_x2 0 8516 1 8253 8607 8517 ao22_x2
xsubckt_8212_sff1_x4 1 2212 0 10145 1276 sff1_x4
xsubckt_8735_sff1_x4 1 2182 0 2311 2279 sff1_x4
xsubckt_9186_sff1_x4 1 2189 0 9254 1189 sff1_x4
xsubckt_1377_oa22_x2 0 6988 1 6989 6996 7142 oa22_x2
xsubckt_1297_xr2_x1 7068 0 1 191 218 xr2_x1
xsubckt_1293_xr2_x1 7072 0 1 192 219 xr2_x1
xsubckt_1250_nxr2_x1 7115 1 0 206 239 nxr2_x1
xsubckt_774_nand2_x0 1 0 7569 629 1940 nand2_x0
xsubckt_2867_nand2_x0 1 0 5492 5493 8025 nand2_x0
xsubckt_3265_o2_x2 0 5100 1 5101 5994 o2_x2
xsubckt_4120_mx2_x2 0 4260 1 813 1835 1803 mx2_x2
xsubckt_4124_mx2_x2 0 4256 1 813 1419 1387 mx2_x2
xsubckt_4511_mx2_x2 0 10062 1 4162 6273 1655 mx2_x2
xsubckt_4513_mx2_x2 0 10060 1 4162 6259 1641 mx2_x2
xsubckt_4515_mx2_x2 0 10058 1 4162 6244 1639 mx2_x2
xsubckt_4904_mx2_x2 0 3945 1 6445 6269 133 mx2_x2
xsubckt_4908_mx2_x2 0 3942 1 6445 6262 130 mx2_x2
xsubckt_4991_mx3_x2 1 0 3880 6448 547 8389 8159 8160 mx3_x2
xsubckt_5786_mx2_x2 0 3220 1 8213 3221 3224 mx2_x2
xsubckt_5788_mx2_x2 0 3218 1 866 1506 1474 mx2_x2
xsubckt_6715_o2_x2 0 8937 1 8938 7931 o2_x2
xsubckt_8286_sff1_x4 1 2137 0 10071 1297 sff1_x4
xsubckt_9020_sff1_x4 1 2079 0 9410 395 sff1_x4
xsubckt_9108_sff1_x4 1 2129 0 9332 880 sff1_x4
xsubckt_1364_nand3_x0 1 0 7001 7106 208 8098 nand3_x0
xsubckt_1246_nxr2_x1 7119 1 0 205 238 nxr2_x1
xsubckt_81_inv_x0 1 0 1952 8330 inv_x0
xsubckt_83_inv_x0 1 0 1955 8328 inv_x0
xsubckt_85_inv_x0 1 0 1957 8326 inv_x0
xsubckt_594_nand2_x0 1 0 7744 634 1965 nand2_x0
xsubckt_1010_nand2_x0 1 0 7345 1991 638 nand2_x0
xsubckt_1100_nand2_x0 1 0 7260 7261 1893 nand2_x0
xsubckt_2777_nand2_x0 1 0 5580 5581 781 nand2_x0
xsubckt_4080_mx2_x2 0 4299 1 8035 4300 4301 mx2_x2
xsubckt_4128_mx2_x2 0 4252 1 814 1579 1547 mx2_x2
xsubckt_4517_mx2_x2 0 10056 1 4161 6223 1637 mx2_x2
xsubckt_4995_mx3_x2 1 0 3877 6448 546 8390 8157 8158 mx3_x2
xsubckt_5634_nxr2_x1 3336 1 0 3339 8074 nxr2_x1
xsubckt_6930_o2_x2 0 9648 1 8762 8769 o2_x2
xsubckt_8120_sff1_x4 1 2223 0 10237 1240 sff1_x4
xsubckt_8208_sff1_x4 1 2198 0 10149 1280 sff1_x4
xsubckt_8643_sff1_x4 1 2076 0 163 100 sff1_x4
xsubckt_9094_sff1_x4 1 2222 0 9346 895 sff1_x4
xsubckt_1627_nand2_x0 1 0 6746 6943 7097 nand2_x0
xsubckt_1613_nand4_x0 1 0 6759 6802 8056 8057 8058 nand4_x0
xsubckt_432_a3_x2 1 7909 0 1908 55 8421 a3_x2
xsubckt_87_inv_x0 1 0 1960 8324 inv_x0
xsubckt_89_inv_x0 1 0 1962 8322 inv_x0
xsubckt_873_oa22_x2 0 7475 1 7613 7478 7476 oa22_x2
xsubckt_3201_nand3_x0 1 0 5163 5164 5342 7857 nand3_x0
xsubckt_3449_nor2_x0 1 0 4920 238 757 nor2_x0
xsubckt_4082_mx2_x2 0 4297 1 815 1357 1325 mx2_x2
xsubckt_4084_mx2_x2 0 4295 1 8036 4296 4297 mx2_x2
xsubckt_4475_mx2_x2 0 10095 1 4168 6278 1314 mx2_x2
xsubckt_4477_mx2_x2 0 10093 1 4168 6266 1292 mx2_x2
xsubckt_4999_mx3_x2 1 0 3874 6449 544 8391 8155 8156 mx3_x2
xsubckt_5150_oa22_x2 0 3738 1 3753 3751 3752 oa22_x2
xsubckt_7348_nand2_x0 1 0 8501 4165 4171 nand2_x0
xsubckt_8116_sff1_x4 1 2209 0 10241 1244 sff1_x4
xsubckt_8194_sff1_x4 1 2111 0 10163 1709 sff1_x4
xsubckt_8639_sff1_x4 1 2150 0 168 105 sff1_x4
xsubckt_9016_sff1_x4 1 2066 0 9414 369 sff1_x4
xsubckt_9451_sff1_x4 1 2232 0 8992 1885 sff1_x4
xsubckt_2405_nand4_x0 1 0 5945 6008 7860 1899 216 nand4_x0
xsubckt_2329_nand2_x0 1 0 6045 6046 6050 nand2_x0
xsubckt_3160_mx2_x2 0 5204 1 791 5205 5206 mx2_x2
xsubckt_3940_mx2_x2 0 4437 1 791 4438 4439 mx2_x2
xsubckt_3942_mx2_x2 0 4435 1 817 1871 1519 mx2_x2
xsubckt_3944_mx2_x2 0 4433 1 8036 4434 4435 mx2_x2
xsubckt_4479_mx2_x2 0 10091 1 4168 6251 1288 mx2_x2
xsubckt_5542_nxr2_x1 3400 1 0 3403 2014 nxr2_x1
xsubckt_7510_mx2_x2 0 9301 1 8480 6071 1105 mx2_x2
xsubckt_8551_sff1_x4 1 2060 0 9806 2018 sff1_x4
xsubckt_9447_sff1_x4 1 2195 0 8996 1889 sff1_x4
xsubckt_1511_nxr2_x1 6854 1 0 6857 221 nxr2_x1
xsubckt_1357_nand2_x0 1 0 7008 209 8101 nand2_x0
xsubckt_781_oa22_x2 0 7563 1 7582 7580 7581 oa22_x2
xsubckt_869_oa22_x2 0 7479 1 7480 7481 8411 oa22_x2
xsubckt_3162_mx2_x2 0 5202 1 819 1885 1533 mx2_x2
xsubckt_3164_mx2_x2 0 5200 1 8030 5201 5202 mx2_x2
xsubckt_3166_mx2_x2 0 5198 1 819 1725 1693 mx2_x2
xsubckt_3946_mx2_x2 0 4431 1 819 1711 1679 mx2_x2
xsubckt_3948_mx2_x2 0 4429 1 790 4430 4431 mx2_x2
xsubckt_7004_a4_x2 0 8701 1 8245 8265 379 703 a4_x2
xsubckt_7512_mx2_x2 0 9299 1 8480 6054 1103 mx2_x2
xsubckt_7514_mx2_x2 0 9297 1 8480 6035 1101 mx2_x2
xsubckt_7516_mx2_x2 0 9295 1 8480 6017 1098 mx2_x2
xsubckt_8024_sff1_x4 1 2225 0 10333 1144 sff1_x4
xsubckt_8547_sff1_x4 1 2153 0 9810 131 sff1_x4
xsubckt_8982_sff1_x4 1 2229 0 9443 1568 sff1_x4
xsubckt_1610_nand2_x0 1 0 2316 6762 6766 nand2_x0
xsubckt_1585_nxr2_x1 6785 1 0 6787 213 nxr2_x1
xsubckt_699_a2_x2 0 7644 1 739 64 a2_x2
xsubckt_703_oa22_x2 0 7640 1 7801 7804 8119 oa22_x2
xsubckt_2631_mx2_x2 0 5724 1 818 1704 1672 mx2_x2
xsubckt_2633_mx2_x2 0 5722 1 787 5723 5724 mx2_x2
xsubckt_2969_oa22_x2 0 5392 1 5450 5447 5449 oa22_x2
xsubckt_3168_mx2_x2 0 5196 1 787 5197 5198 mx2_x2
xsubckt_3801_nand3_x0 1 0 4573 4574 4753 7857 nand3_x0
xsubckt_3869_oa22_x2 0 4507 1 4567 4565 4564 oa22_x2
xsubckt_4880_ao22_x2 0 3962 1 8353 3965 49 ao22_x2
xsubckt_5136_nand2_x0 1 0 3751 3925 8256 nand2_x0
xsubckt_5450_nxr2_x1 3463 1 0 3465 8132 nxr2_x1
xsubckt_7081_mx2_x2 0 9594 1 8666 6259 1513 mx2_x2
xsubckt_7129_mx2_x2 0 9562 1 8650 8648 366 mx2_x2
xsubckt_7241_nand2_x0 1 0 8586 7976 384 nand2_x0
xsubckt_7470_mx2_x2 0 9339 1 8485 6124 888 mx2_x2
xsubckt_7472_mx2_x2 0 9337 1 8484 6108 885 mx2_x2
xsubckt_7863_mx2_x2 0 9630 1 6441 9398 727 mx2_x2
xsubckt_7865_mx2_x2 0 9613 1 6441 9407 716 mx2_x2
xsubckt_8098_sff1_x4 1 2111 0 10259 1165 sff1_x4
xsubckt_8904_sff1_x4 1 2123 0 9521 553 sff1_x4
xsubckt_9355_sff1_x4 1 2232 0 9088 989 sff1_x4
xcmpt_instr_jal_hfns_3 1 0 654 650 buf_x4
xcmpt_instr_jal_hfns_2 1 0 650 651 buf_x4
xcmpt_instr_jal_hfns_1 1 0 650 652 buf_x4
xcmpt_instr_jal_hfns_0 1 0 650 653 buf_x4
xsubckt_2246_mx2_x2 0 10431 1 6300 6152 1819 mx2_x2
xsubckt_1800_nor3_x0 1 0 6584 6586 6599 6602 nor3_x0
xsubckt_1177_nand2_x0 1 0 7187 629 1917 nand2_x0
xsubckt_353_o2_x2 0 7996 1 366 365 o2_x2
xsubckt_926_nand2_x0 1 0 7425 7427 7429 nand2_x0
xsubckt_1023_oa22_x2 0 7333 1 415 7810 7618 oa22_x2
xsubckt_2591_mx2_x2 0 5763 1 788 5764 5765 mx2_x2
xsubckt_2635_mx2_x2 0 5720 1 817 904 872 mx2_x2
xsubckt_2637_mx2_x2 0 5718 1 783 5719 5722 mx2_x2
xsubckt_2639_mx2_x2 0 5716 1 817 1032 1000 mx2_x2
xsubckt_2980_mx2_x2 0 5381 1 818 1056 1024 mx2_x2
xsubckt_4806_a4_x2 0 4017 1 4018 4023 4028 4143 a4_x2
xsubckt_5253_ao22_x2 0 3642 1 3643 3644 3649 ao22_x2
xsubckt_6201_mx2_x2 0 2816 1 852 1660 1628 mx2_x2
xsubckt_6203_mx2_x2 0 2814 1 8224 2815 2816 mx2_x2
xsubckt_6205_mx2_x2 0 2812 1 853 1436 1404 mx2_x2
xsubckt_7005_a2_x2 0 8700 1 8701 8725 a2_x2
xsubckt_7083_mx2_x2 0 9592 1 8666 6245 1511 mx2_x2
xsubckt_7474_mx2_x2 0 9335 1 8485 6089 883 mx2_x2
xsubckt_7476_mx2_x2 0 9333 1 8485 6071 881 mx2_x2
xsubckt_7478_mx2_x2 0 9331 1 8485 6054 879 mx2_x2
xsubckt_7867_mx2_x2 0 9611 1 6440 9405 714 mx2_x2
xsubckt_7869_mx2_x2 0 9609 1 6440 9402 712 mx2_x2
xsubckt_8455_sff1_x4 1 2057 0 9902 1950 sff1_x4
xsubckt_8890_sff1_x4 1 2050 0 9535 345 sff1_x4
xsubckt_8978_sff1_x4 1 2235 0 9447 1542 sff1_x4
xsubckt_2454_xr2_x1 5897 0 1 767 217 xr2_x1
xsubckt_530_nor2_x0 1 0 7811 330 328 nor2_x0
xsubckt_611_oa22_x2 0 7728 1 7801 7804 8135 oa22_x2
xsubckt_822_o2_x2 0 7524 1 763 88 o2_x2
xsubckt_1087_nand2_x0 1 0 7272 634 1958 nand2_x0
xsubckt_2593_mx2_x2 0 5761 1 796 1577 1545 mx2_x2
xsubckt_2595_mx2_x2 0 5759 1 788 5760 5761 mx2_x2
xsubckt_2597_mx2_x2 0 5757 1 796 1417 1385 mx2_x2
xsubckt_2984_mx2_x2 0 5377 1 796 1184 1088 mx2_x2
xsubckt_2988_mx2_x2 0 5373 1 796 1792 1760 mx2_x2
xsubckt_3621_nand3_x0 1 0 4750 4751 4930 7857 nand3_x0
xsubckt_4191_a3_x2 1 4219 0 551 552 553 a3_x2
xsubckt_5159_a3_x2 1 3730 0 42 152 8397 a3_x2
xsubckt_5207_a2_x2 0 3685 1 3909 716 a2_x2
xsubckt_5402_a2_x2 0 3504 1 3513 3523 a2_x2
xsubckt_6161_mx2_x2 0 2855 1 850 1245 1213 mx2_x2
xsubckt_6207_mx2_x2 0 2810 1 8210 2811 2814 mx2_x2
xsubckt_6209_mx2_x2 0 2808 1 8207 2809 2824 mx2_x2
xsubckt_6550_mx2_x2 0 2477 1 851 1041 1009 mx2_x2
xsubckt_6552_mx2_x2 0 2475 1 8210 2476 2479 mx2_x2
xsubckt_6554_mx2_x2 0 2473 1 851 1361 1329 mx2_x2
xsubckt_6918_a4_x2 0 8771 1 8806 8244 579 703 a4_x2
xsubckt_7061_nand2_x0 1 0 9603 8678 8680 nand2_x0
xsubckt_7089_mx2_x2 0 9586 1 8666 6188 1535 mx2_x2
xsubckt_7990_sff1_x4 1 2222 0 10367 1786 sff1_x4
xsubckt_8812_sff1_x4 1 2089 0 9610 713 sff1_x4
xsubckt_9263_sff1_x4 1 2223 0 9177 1429 sff1_x4
xsubckt_1957_nand2_x0 1 0 6456 7810 197 nand2_x0
xsubckt_1336_nand3_x0 1 0 7029 7039 456 8137 nand3_x0
xsubckt_566_nand2_x0 1 0 7771 634 1976 nand2_x0
xsubckt_862_o2_x2 0 7486 1 761 86 o2_x2
xsubckt_1160_nand2_x0 1 0 7203 630 1918 nand2_x0
xsubckt_2553_ao22_x2 0 5800 1 5849 5847 5844 ao22_x2
xsubckt_2599_mx2_x2 0 5755 1 8023 5756 5759 mx2_x2
xsubckt_2749_nand2_x0 1 0 5608 5609 781 nand2_x0
xsubckt_3390_a2_x2 0 4978 1 239 758 a2_x2
xsubckt_3441_nand3_x0 1 0 4927 4928 5107 7856 nand3_x0
xsubckt_4739_a3_x2 1 4067 0 4071 1962 8323 a3_x2
xsubckt_4886_a4_x2 0 3958 1 3966 1922 1920 1919 a4_x2
xsubckt_4914_a3_x2 1 3938 0 41 65 8399 a3_x2
xsubckt_4934_a3_x2 1 3923 0 41 90 8396 a3_x2
xsubckt_4954_a3_x2 1 3908 0 41 85 8396 a3_x2
xsubckt_5442_a2_x2 0 9808 1 3469 41 a2_x2
xsubckt_5462_a2_x2 0 9802 1 3455 41 a2_x2
xsubckt_6163_mx2_x2 0 2853 1 8225 2854 2855 mx2_x2
xsubckt_6165_mx2_x2 0 2851 1 856 1661 1629 mx2_x2
xsubckt_6167_mx2_x2 0 2849 1 8225 2850 2851 mx2_x2
xsubckt_6556_mx2_x2 0 2471 1 8225 2472 2473 mx2_x2
xsubckt_6558_mx2_x2 0 2469 1 857 1137 1105 mx2_x2
xsubckt_7912_sff1_x4 1 2172 0 10440 1798 sff1_x4
xsubckt_7986_sff1_x4 1 2225 0 10371 1790 sff1_x4
xsubckt_8363_sff1_x4 1 2218 0 9994 1479 sff1_x4
xsubckt_8808_sff1_x4 1 2086 0 9614 717 sff1_x4
xsubckt_8886_sff1_x4 1 2050 0 9539 349 sff1_x4
xsubckt_2262_oa22_x2 0 6130 1 6147 83 82 oa22_x2
xsubckt_1867_nand2_x0 1 0 2298 6522 6526 nand2_x0
xsubckt_1846_nxr2_x1 6541 1 0 6543 196 nxr2_x1
xsubckt_1572_a2_x2 0 6797 1 6798 247 a2_x2
xsubckt_2735_a2_x2 0 5622 1 220 739 a2_x2
xsubckt_2785_oa22_x2 0 5572 1 5573 5612 5957 oa22_x2
xsubckt_2912_nand2_x0 1 0 5448 247 766 nand2_x0
xsubckt_4143_nand3_x0 1 0 4237 4242 4246 770 nand3_x0
xsubckt_4779_a3_x2 1 9903 0 4037 4038 53 a3_x2
xsubckt_4799_a3_x2 1 4022 0 4023 4028 4143 a3_x2
xsubckt_4847_a2_x2 0 3986 1 1934 1933 a2_x2
xsubckt_4974_a3_x2 1 3893 0 53 79 8398 a3_x2
xsubckt_4994_a3_x2 1 3878 0 53 74 8399 a3_x2
xsubckt_5287_a2_x2 0 3611 1 3891 8278 a2_x2
xsubckt_6169_mx2_x2 0 2847 1 855 1437 1405 mx2_x2
xsubckt_6645_a2_x2 0 9683 1 2385 2419 a2_x2
xsubckt_7908_sff1_x4 1 2097 0 10444 1804 sff1_x4
xsubckt_8359_sff1_x4 1 2098 0 9998 1495 sff1_x4
xsubckt_8720_sff1_x4 1 2153 0 2308 2276 sff1_x4
xsubckt_9171_sff1_x4 1 2110 0 9269 1393 sff1_x4
xsubckt_9259_sff1_x4 1 2245 0 9181 1434 sff1_x4
xsubckt_1807_oa22_x2 0 6578 1 6602 6587 6588 oa22_x2
xsubckt_1305_o2_x2 0 7060 1 440 221 o2_x2
xsubckt_2795_a2_x2 0 5563 1 219 738 a2_x2
xsubckt_3261_nand3_x0 1 0 5104 5105 5284 7856 nand3_x0
xsubckt_4053_nand3_x0 1 0 4326 569 8289 71 nand3_x0
xsubckt_4229_nand4_x0 1 0 4210 4212 6304 6306 551 nand4_x0
xsubckt_4450_mx3_x2 1 0 10117 4176 6291 1696 6196 6200 mx3_x2
xsubckt_4867_a2_x2 0 9880 1 3972 45 a2_x2
xsubckt_5981_mx2_x2 0 3030 1 855 1220 1188 mx2_x2
xsubckt_5983_mx2_x2 0 3028 1 8218 3029 3030 mx2_x2
xsubckt_6646_oa22_x2 0 2384 1 45 1906 196 oa22_x2
xsubckt_8271_sff1_x4 1 2198 0 10086 1313 sff1_x4
xsubckt_8716_sff1_x4 1 2053 0 9674 557 sff1_x4
xsubckt_8794_sff1_x4 1 2079 0 9628 725 sff1_x4
xsubckt_2258_oa22_x2 0 6136 1 6137 6138 6139 oa22_x2
xsubckt_1231_nxr2_x1 7134 1 0 202 234 nxr2_x1
xsubckt_434_nor2_x0 1 0 7907 1908 1894 nor2_x0
xsubckt_3081_nand3_x0 1 0 5281 5282 5459 7857 nand3_x0
xsubckt_4321_mx2_x2 0 10233 1 4199 6089 1235 mx2_x2
xsubckt_4323_mx2_x2 0 10231 1 4199 6071 1233 mx2_x2
xsubckt_5376_nand2_x0 1 0 3528 3529 3530 nand2_x0
xsubckt_5588_ao22_x2 0 3368 1 3372 1999 44 ao22_x2
xsubckt_5746_oa22_x2 0 9711 1 7910 3259 3261 oa22_x2
xsubckt_5985_mx2_x2 0 3026 1 855 1636 1604 mx2_x2
xsubckt_5987_mx2_x2 0 3024 1 8218 3025 3026 mx2_x2
xsubckt_5989_mx2_x2 0 3022 1 855 1412 1380 mx2_x2
xsubckt_7019_oa22_x2 0 8689 1 8245 703 8299 oa22_x2
xsubckt_8267_sff1_x4 1 2217 0 10090 1287 sff1_x4
xsubckt_9167_sff1_x4 1 2223 0 9273 1397 sff1_x4
xcmpt_is_lui_auipc_jal_hfns_4 1 0 570 565 buf_x4
xcmpt_is_lui_auipc_jal_hfns_3 1 0 565 566 buf_x4
xcmpt_is_lui_auipc_jal_hfns_2 1 0 565 567 buf_x4
xcmpt_is_lui_auipc_jal_hfns_1 1 0 565 568 buf_x4
xcmpt_is_lui_auipc_jal_hfns_0 1 0 565 569 buf_x4
xsubckt_1814_o2_x2 0 6571 1 6572 6577 o2_x2
xsubckt_4325_mx2_x2 0 10229 1 4198 6054 1231 mx2_x2
xsubckt_4327_mx2_x2 0 10227 1 4198 6034 1229 mx2_x2
xsubckt_4329_mx2_x2 0 10225 1 4199 6018 1226 mx2_x2
xsubckt_5108_nand2_x0 1 0 3777 3931 8255 nand2_x0
xsubckt_5142_nor2_x0 1 0 3745 3746 7881 nor2_x0
xsubckt_7303_nand2_x0 1 0 8537 722 653 nand2_x0
xsubckt_8101_sff1_x4 1 2103 0 10256 1251 sff1_x4
xsubckt_8624_sff1_x4 1 2159 0 184 121 sff1_x4
xsubckt_9001_sff1_x4 1 2119 0 9424 1547 sff1_x4
xsubckt_9075_sff1_x4 1 2063 0 10467 1913 sff1_x4
xsubckt_1227_nxr2_x1 7138 1 0 201 233 nxr2_x1
xsubckt_986_nand2_x0 1 0 7368 7369 1893 nand2_x0
xsubckt_3403_mx2_x2 0 4965 1 798 1177 1081 mx2_x2
xsubckt_3861_nand3_x0 1 0 4514 4515 4694 7856 nand3_x0
xsubckt_3986_o2_x2 0 10388 1 4392 4451 o2_x2
xsubckt_4281_mx2_x2 0 10271 1 4204 6143 1178 mx2_x2
xsubckt_4283_mx2_x2 0 10269 1 4204 6124 1176 mx2_x2
xsubckt_4285_mx2_x2 0 10267 1 4204 6108 1173 mx2_x2
xsubckt_5219_oa22_x2 0 3674 1 3686 3684 3685 oa22_x2
xsubckt_6318_ao22_x2 0 2702 1 573 568 758 ao22_x2
xsubckt_8175_sff1_x4 1 2192 0 10182 1729 sff1_x4
xsubckt_8698_sff1_x4 1 2172 0 9692 206 sff1_x4
xsubckt_9432_sff1_x4 1 2123 0 9011 911 sff1_x4
xsubckt_1658_nxr2_x1 6717 1 0 6718 8039 nxr2_x1
xsubckt_808_nand2_x0 1 0 7537 7809 427 nand2_x0
xsubckt_896_nand2_x0 1 0 7453 1998 638 nand2_x0
xsubckt_1059_nand2_x0 1 0 7299 7300 7303 nand2_x0
xsubckt_2458_nand3_x0 1 0 5893 5894 5895 7905 nand3_x0
xsubckt_3407_mx2_x2 0 4961 1 797 1785 1753 mx2_x2
xsubckt_3497_oa22_x2 0 4872 1 4873 4912 5958 oa22_x2
xsubckt_4287_mx2_x2 0 10265 1 4204 6089 1171 mx2_x2
xsubckt_4289_mx2_x2 0 10263 1 4204 6071 1169 mx2_x2
xsubckt_5138_nor2_x0 1 0 3749 3750 3753 nor2_x0
xsubckt_5573_nor2_x0 1 0 3379 3382 2003 nor2_x0
xsubckt_8532_sff1_x4 1 2176 0 9825 148 sff1_x4
xsubckt_1929_nand2_x0 1 0 6470 441 330 nand2_x0
xsubckt_1570_nxr2_x1 6799 1 0 6800 8056 nxr2_x1
xsubckt_1486_nand3_x0 1 0 6877 6878 6879 6940 nand3_x0
xsubckt_210_inv_x0 1 0 109 8166 inv_x0
xsubckt_212_inv_x0 1 0 108 8164 inv_x0
xsubckt_214_inv_x0 1 0 107 8162 inv_x0
xsubckt_732_a2_x2 0 7609 1 7990 1979 a2_x2
xsubckt_772_a2_x2 0 7571 1 7990 2039 a2_x2
xsubckt_1174_oa22_x2 0 7190 1 7613 7478 7191 oa22_x2
xsubckt_3363_mx2_x2 0 5004 1 796 1146 1114 mx2_x2
xsubckt_3367_mx2_x2 0 5000 1 797 1306 1274 mx2_x2
xsubckt_3681_nand3_x0 1 0 4691 4692 4871 7857 nand3_x0
xsubckt_3758_mx2_x2 0 4616 1 797 978 946 mx2_x2
xsubckt_5127_oa22_x2 0 3759 1 3760 3766 8278 oa22_x2
xsubckt_7711_mx2_x2 0 9113 1 8449 6108 1013 mx2_x2
xsubckt_7713_mx2_x2 0 9111 1 8449 6089 1011 mx2_x2
xsubckt_7715_mx2_x2 0 9109 1 8449 6071 1009 mx2_x2
xsubckt_8083_sff1_x4 1 2232 0 10274 1181 sff1_x4
xsubckt_9340_sff1_x4 1 2053 0 10458 329 sff1_x4
xsubckt_9428_sff1_x4 1 2142 0 9015 915 sff1_x4
xsubckt_2441_mx2_x2 0 5910 1 820 1442 1410 mx2_x2
xsubckt_2050_mx2_x2 0 6398 1 830 6399 6402 mx2_x2
xsubckt_1839_nand2_x0 1 0 6548 7167 7972 nand2_x0
xsubckt_1476_nor4_x0 1 0 6887 456 445 467 468 nor4_x0
xsubckt_218_inv_x0 1 0 105 8158 inv_x0
xsubckt_216_inv_x0 1 0 106 8160 inv_x0
xsubckt_170_inv_x0 1 0 830 8216 inv_x0
xsubckt_792_a2_x2 0 7552 1 7991 2038 a2_x2
xsubckt_2830_mx2_x2 0 5528 1 820 1285 1253 mx2_x2
xsubckt_5175_nand3_x0 1 0 3715 3742 3915 3918 nand3_x0
xsubckt_5481_nor2_x0 1 0 9796 3442 3443 nor2_x0
xsubckt_7280_mx2_x2 0 9500 1 8832 8556 762 mx2_x2
xsubckt_7459_mx3_x2 1 0 9350 8487 6293 869 6226 6229 mx3_x2
xsubckt_7671_mx2_x2 0 9151 1 8454 6162 1052 mx2_x2
xsubckt_7673_mx2_x2 0 9149 1 8454 6143 1050 mx2_x2
xsubckt_7717_mx2_x2 0 9107 1 8448 6054 1007 mx2_x2
xsubckt_7719_mx2_x2 0 9105 1 8449 6035 1005 mx2_x2
xsubckt_8005_sff1_x4 1 2103 0 10352 1155 sff1_x4
xsubckt_8440_sff1_x4 1 2047 0 9917 1967 sff1_x4
xsubckt_8528_sff1_x4 1 2179 0 9829 152 sff1_x4
xsubckt_8963_sff1_x4 1 2145 0 9462 1586 sff1_x4
xsubckt_2443_mx2_x2 0 5908 1 8023 5909 5912 mx2_x2
xsubckt_2054_mx2_x2 0 6394 1 562 6395 710 mx2_x2
xsubckt_2052_mx2_x2 0 6396 1 823 6397 6412 mx2_x2
xsubckt_172_inv_x0 1 0 101 8204 inv_x0
xsubckt_174_inv_x0 1 0 98 8202 inv_x0
xsubckt_176_inv_x0 1 0 97 8200 inv_x0
xsubckt_758_oa22_x2 0 7584 1 7585 7614 8284 oa22_x2
xsubckt_965_nand3_x0 1 0 7388 7389 7390 1902 nand3_x0
xsubckt_1082_oa22_x2 0 7277 1 7613 7478 7278 oa22_x2
xsubckt_1107_a3_x2 1 7253 0 7254 7255 7256 a3_x2
xsubckt_3573_xr2_x1 4798 0 1 235 754 xr2_x1
xsubckt_5035_oa22_x2 0 3845 1 3852 3850 3851 oa22_x2
xsubckt_6011_mx2_x2 0 3001 1 835 3002 3003 mx2_x2
xsubckt_6013_mx2_x2 0 2999 1 827 3000 3007 mx2_x2
xsubckt_6400_mx2_x2 0 2623 1 835 2624 2625 mx2_x2
xsubckt_6402_mx2_x2 0 2621 1 864 1877 1525 mx2_x2
xsubckt_6404_mx2_x2 0 2619 1 8221 2620 2621 mx2_x2
xsubckt_6889_oa22_x2 0 9659 1 8819 8798 8792 oa22_x2
xsubckt_6927_nand3_x0 1 0 8764 8765 8767 8269 nand3_x0
xsubckt_7675_mx2_x2 0 9147 1 8453 6125 1048 mx2_x2
xsubckt_7677_mx2_x2 0 9145 1 8454 6108 1045 mx2_x2
xsubckt_7723_nand2_x0 1 0 8445 8457 4171 nand2_x0
xsubckt_8079_sff1_x4 1 2189 0 10278 1185 sff1_x4
xsubckt_8436_sff1_x4 1 2047 0 9921 1971 sff1_x4
xsubckt_8959_sff1_x4 1 2214 0 9466 1590 sff1_x4
xsubckt_9336_sff1_x4 1 2138 0 9104 1003 sff1_x4
xsubckt_2261_nand3_x0 1 0 6131 6132 541 8409 nand3_x0
xsubckt_1912_nand2_x0 1 0 437 6484 6485 nand2_x0
xsubckt_1822_nand2_x0 1 0 6564 6948 7159 nand2_x0
xsubckt_178_inv_x0 1 0 96 8198 inv_x0
xsubckt_633_mx2_x2 0 7707 1 217 427 410 mx2_x2
xsubckt_1004_oa22_x2 0 7351 1 416 7809 7618 oa22_x2
xsubckt_5272_a3_x2 1 3625 0 46 143 8399 a3_x2
xsubckt_5546_a3_x2 1 3398 0 3401 2012 2013 a3_x2
xsubckt_5741_a3_x2 1 3262 0 7913 46 505 a3_x2
xsubckt_6015_mx2_x2 0 2997 1 862 1313 1281 mx2_x2
xsubckt_6017_mx2_x2 0 2995 1 862 1249 1217 mx2_x2
xsubckt_6360_mx2_x2 0 2662 1 862 1846 1814 mx2_x2
xsubckt_6406_mx2_x2 0 2617 1 862 1045 1013 mx2_x2
xsubckt_6408_mx2_x2 0 2615 1 8214 2616 2619 mx2_x2
xsubckt_7679_mx2_x2 0 9143 1 8454 6088 1043 mx2_x2
xsubckt_7971_sff1_x4 1 2092 0 10386 227 sff1_x4
xsubckt_8871_sff1_x4 1 2076 0 9554 335 sff1_x4
xsubckt_2184_a2_x2 0 6249 1 6256 65 a2_x2
xsubckt_1389_nand2_x0 1 0 6976 193 8068 nand2_x0
xsubckt_843_xr2_x1 7504 0 1 762 87 xr2_x1
xsubckt_3502_a2_x2 0 4867 1 4868 4870 a2_x2
xsubckt_4872_a3_x2 1 3968 0 3971 1925 1924 a3_x2
xsubckt_5380_a2_x2 0 3524 1 3873 730 a2_x2
xsubckt_5385_nor2_x0 1 0 3519 3520 8276 nor2_x0
xsubckt_5586_a3_x2 1 3370 0 3375 1999 2000 a3_x2
xsubckt_6019_mx2_x2 0 2993 1 8222 2994 2995 mx2_x2
xsubckt_6362_mx2_x2 0 2660 1 861 1718 1686 mx2_x2
xsubckt_6364_mx2_x2 0 2658 1 836 2659 2660 mx2_x2
xsubckt_6366_mx2_x2 0 2656 1 861 1878 1526 mx2_x2
xsubckt_6755_mx2_x2 0 8899 1 861 906 874 mx2_x2
xsubckt_6757_mx2_x2 0 8897 1 8222 8898 8899 mx2_x2
xsubckt_6759_mx2_x2 0 8895 1 861 1770 1738 mx2_x2
xsubckt_6922_ao22_x2 0 8769 1 706 8277 624 ao22_x2
xsubckt_7257_a2_x2 0 8574 1 713 653 a2_x2
xsubckt_7277_a2_x2 0 8558 1 733 653 a2_x2
xsubckt_8344_sff1_x4 1 2223 0 10013 1336 sff1_x4
xsubckt_8867_sff1_x4 1 2076 0 9558 351 sff1_x4
xsubckt_9244_sff1_x4 1 2109 0 9196 1431 sff1_x4
xsubckt_1569_a2_x2 0 6800 1 6801 8416 a2_x2
xsubckt_1295_a2_x2 0 7070 1 191 218 a2_x2
xsubckt_500_oa22_x2 0 7836 1 7935 7841 7837 oa22_x2
xsubckt_3562_a2_x2 0 4808 1 4809 4811 a2_x2
xsubckt_5421_nand2_x0 1 0 3486 3496 3499 nand2_x0
xsubckt_5459_a2_x2 0 3457 1 3459 1980 a2_x2
xsubckt_5831_mx2_x2 0 3176 1 834 3177 3178 mx2_x2
xsubckt_5833_mx2_x2 0 3174 1 828 3175 3182 mx2_x2
xsubckt_6368_mx2_x2 0 2654 1 8222 2655 2656 mx2_x2
xsubckt_7967_sff1_x4 1 2092 0 10390 231 sff1_x4
xsubckt_8701_sff1_x4 1 2203 0 9689 203 sff1_x4
xsubckt_9152_sff1_x4 1 2218 0 9288 1383 sff1_x4
xsubckt_1552_nand2_x0 1 0 6816 6943 7070 nand2_x0
xsubckt_1304_nxr2_x1 7061 1 0 439 220 nxr2_x1
xsubckt_574_oa22_x2 0 7763 1 7764 7765 7767 oa22_x2
xsubckt_868_nand2_x0 1 0 7480 7809 424 nand2_x0
xsubckt_958_nand2_x0 1 0 7394 7395 7403 nand2_x0
xsubckt_2951_nand3_x0 1 0 5409 5434 5438 8011 nand3_x0
xsubckt_4306_mx3_x2 1 0 10248 4201 6290 1221 6226 6230 mx3_x2
xsubckt_4997_oa22_x2 0 9846 1 7885 3876 3878 oa22_x2
xsubckt_5331_nand2_x0 1 0 3570 3577 3581 nand2_x0
xsubckt_5791_mx2_x2 0 3215 1 839 1666 1634 mx2_x2
xsubckt_5835_mx2_x2 0 3172 1 839 1288 1256 mx2_x2
xsubckt_5837_mx2_x2 0 3170 1 839 1224 1192 mx2_x2
xsubckt_5839_mx2_x2 0 3168 1 8223 3169 3170 mx2_x2
xsubckt_7281_ao22_x2 0 8555 1 662 644 394 ao22_x2
xsubckt_8252_sff1_x4 1 2142 0 10105 1683 sff1_x4
xsubckt_8775_sff1_x4 1 2073 0 9647 616 sff1_x4
xsubckt_1735_nxr2_x1 6645 1 0 6648 235 nxr2_x1
xsubckt_1700_oa22_x2 0 6678 1 6692 6686 6687 oa22_x2
xsubckt_1664_o3_x2 0 6711 1 6712 6713 6939 o3_x2
xsubckt_1283_o2_x2 0 7082 1 213 246 o2_x2
xsubckt_2674_oa22_x2 0 5682 1 5733 5729 5732 oa22_x2
xsubckt_4131_mx2_x2 0 4249 1 805 1227 1195 mx2_x2
xsubckt_4308_mx3_x2 1 0 10246 4201 6290 1249 6205 6210 mx3_x2
xsubckt_4522_mx2_x2 0 10051 1 4161 6178 1662 mx2_x2
xsubckt_4866_nxr2_x1 3972 1 0 3974 8350 nxr2_x1
xsubckt_5057_mx2_x2 0 3824 1 8278 3825 3943 mx2_x2
xsubckt_5153_o2_x2 0 3735 1 3736 3738 o2_x2
xsubckt_5793_mx2_x2 0 3213 1 830 3214 3217 mx2_x2
xsubckt_5795_mx2_x2 0 3211 1 839 1794 1762 mx2_x2
xsubckt_5797_mx2_x2 0 3209 1 8226 3210 3211 mx2_x2
xsubckt_6104_oa22_x2 0 2910 1 3191 2913 2911 oa22_x2
xsubckt_9060_sff1_x4 1 2214 0 9370 1366 sff1_x4
xsubckt_9148_sff1_x4 1 2109 0 9292 1399 sff1_x4
xsubckt_2186_nxr2_x1 6247 1 0 6256 8360 nxr2_x1
xsubckt_1557_o2_x2 0 6811 1 6812 615 o2_x2
xsubckt_90_inv_x0 1 0 1963 8321 inv_x0
xsubckt_92_inv_x0 1 0 1967 8319 inv_x0
xsubckt_688_nand2_x0 1 0 7654 7990 1985 nand2_x0
xsubckt_1104_nand2_x0 1 0 7256 629 1922 nand2_x0
xsubckt_3570_o2_x2 0 4801 1 235 754 o2_x2
xsubckt_4133_mx2_x2 0 4247 1 8029 4248 4249 mx2_x2
xsubckt_4135_mx2_x2 0 4245 1 804 1355 1323 mx2_x2
xsubckt_4137_mx2_x2 0 4243 1 8029 4244 4245 mx2_x2
xsubckt_4480_mx2_x2 0 10090 1 4168 6244 1287 mx2_x2
xsubckt_4524_mx2_x2 0 10049 1 4162 6161 1660 mx2_x2
xsubckt_4526_mx2_x2 0 10047 1 4162 6142 1658 mx2_x2
xsubckt_4528_mx2_x2 0 10045 1 4162 6125 1656 mx2_x2
xsubckt_5061_nand2_x0 1 0 3821 3939 8278 nand2_x0
xsubckt_5467_o2_x2 0 3451 1 3453 8305 o2_x2
xsubckt_5727_oa22_x2 0 3275 1 7821 7866 7931 oa22_x2
xsubckt_5799_mx2_x2 0 3207 1 838 930 898 mx2_x2
xsubckt_6178_oa22_x2 0 2839 1 52 1906 209 oa22_x2
xsubckt_6571_o2_x2 0 2456 1 2457 7931 o2_x2
xsubckt_8160_sff1_x4 1 2132 0 10197 1455 sff1_x4
xsubckt_8248_sff1_x4 1 2224 0 10109 1688 sff1_x4
xsubckt_8683_sff1_x4 1 2086 0 9707 445 sff1_x4
xcmpt_decoder_trigger_hfns_4 1 0 704 699 buf_x4
xcmpt_decoder_trigger_hfns_3 1 0 699 700 buf_x4
xcmpt_decoder_trigger_hfns_2 1 0 699 701 buf_x4
xcmpt_decoder_trigger_hfns_1 1 0 699 702 buf_x4
xcmpt_decoder_trigger_hfns_0 1 0 699 703 buf_x4
xsubckt_1899_nand2_x0 1 0 433 6495 7802 nand2_x0
xsubckt_1643_nxr2_x1 6731 1 0 6732 8061 nxr2_x1
xsubckt_1531_nand3_x0 1 0 6835 6836 6837 6940 nand3_x0
xsubckt_94_inv_x0 1 0 1969 8317 inv_x0
xsubckt_96_inv_x0 1 0 1972 8315 inv_x0
xsubckt_98_inv_x0 1 0 1914 8313 inv_x0
xsubckt_3600_mx2_x2 0 4771 1 8030 4772 4773 mx2_x2
xsubckt_3602_mx2_x2 0 4769 1 803 1237 1205 mx2_x2
xsubckt_3604_mx2_x2 0 4767 1 8030 4768 4769 mx2_x2
xsubckt_6970_oa22_x2 0 8731 1 8750 8732 8733 oa22_x2
xsubckt_8605_sff1_x4 1 2044 0 9752 1988 sff1_x4
xsubckt_8679_sff1_x4 1 2057 0 321 704 sff1_x4
xsubckt_9056_sff1_x4 1 2203 0 9374 1371 sff1_x4
xsubckt_9491_sff1_x4 1 2209 0 8952 1844 sff1_x4
xsubckt_2504_oa22_x2 0 5848 1 5944 5897 5899 oa22_x2
xsubckt_3606_mx2_x2 0 4765 1 808 1365 1333 mx2_x2
xsubckt_3608_mx2_x2 0 4763 1 8031 4764 4765 mx2_x2
xsubckt_3951_mx2_x2 0 4426 1 810 1839 1807 mx2_x2
xsubckt_4486_mx2_x2 0 10084 1 4167 6189 1311 mx2_x2
xsubckt_4488_mx2_x2 0 10082 1 4167 6170 1309 mx2_x2
xsubckt_5310_nand3_x0 1 0 3590 42 140 8397 nand3_x0
xsubckt_6966_oa22_x2 0 8734 1 8753 8737 8735 oa22_x2
xsubckt_7185_ao22_x2 0 8625 1 6493 6494 436 ao22_x2
xsubckt_8156_sff1_x4 1 2145 0 10201 1459 sff1_x4
xsubckt_8513_sff1_x4 1 2153 0 9844 72 sff1_x4
xsubckt_8591_sff1_x4 1 2057 0 9766 2003 sff1_x4
xsubckt_9413_sff1_x4 1 2209 0 9030 901 sff1_x4
xsubckt_2229_nand4_x0 1 0 6173 6203 89 88 87 nand4_x0
xsubckt_1882_nand2_x0 1 0 6507 7176 7971 nand2_x0
xsubckt_1604_oa22_x2 0 6767 1 6769 6775 6939 oa22_x2
xsubckt_1351_nand3_x0 1 0 7014 7080 214 8110 nand3_x0
xsubckt_650_a2_x2 0 7691 1 741 66 a2_x2
xsubckt_670_a2_x2 0 7671 1 7672 7678 a2_x2
xsubckt_754_nor2_x0 1 0 7588 7589 7595 nor2_x0
xsubckt_3171_mx2_x2 0 5193 1 808 1853 1821 mx2_x2
xsubckt_3219_mx2_x2 0 5146 1 808 1052 1020 mx2_x2
xsubckt_3312_oa22_x2 0 5054 1 5055 5056 775 oa22_x2
xsubckt_3955_mx2_x2 0 4422 1 808 1423 1391 mx2_x2
xsubckt_4438_nand2_x0 1 0 4175 4182 4227 nand2_x0
xsubckt_5504_nxr2_x1 3426 1 0 3429 2027 nxr2_x1
xsubckt_6642_ao22_x2 0 2387 1 574 569 748 ao22_x2
xsubckt_7521_mx2_x2 0 9292 1 8475 6273 1399 mx2_x2
xsubckt_7523_mx2_x2 0 9290 1 8474 6259 1385 mx2_x2
xsubckt_8064_sff1_x4 1 2123 0 10293 1743 sff1_x4
xsubckt_8587_sff1_x4 1 2060 0 9770 2008 sff1_x4
xsubckt_9409_sff1_x4 1 2100 0 9034 905 sff1_x4
xsubckt_9487_sff1_x4 1 2222 0 8956 1849 sff1_x4
xsubckt_1155_oa22_x2 0 7208 1 407 7810 7618 oa22_x2
xsubckt_2640_mx2_x2 0 5715 1 791 5716 5717 mx2_x2
xsubckt_2854_nor2_x0 1 0 5505 218 737 nor2_x0
xsubckt_3032_xr2_x1 5330 0 1 245 764 xr2_x1
xsubckt_3175_mx2_x2 0 5189 1 806 1437 1405 mx2_x2
xsubckt_3179_mx2_x2 0 5185 1 806 1597 1565 mx2_x2
xsubckt_3959_mx2_x2 0 4418 1 806 1583 1551 mx2_x2
xsubckt_5062_a4_x2 0 3820 1 3939 3942 3945 3948 a4_x2
xsubckt_7132_mx2_x2 0 9561 1 8650 8646 365 mx2_x2
xsubckt_7136_mx2_x2 0 9559 1 8645 362 467 mx2_x2
xsubckt_7258_nor2_x0 1 0 8573 8574 8575 nor2_x0
xsubckt_7335_nand2_x0 1 0 8511 8512 8514 nand2_x0
xsubckt_7525_mx2_x2 0 9288 1 8475 6244 1383 mx2_x2
xsubckt_7870_mx2_x2 0 9608 1 6440 9401 711 mx2_x2
xsubckt_7872_mx2_x2 0 9606 1 6440 9399 709 mx2_x2
xsubckt_8421_sff1_x4 1 2060 0 9936 2 sff1_x4
xsubckt_8509_sff1_x4 1 2156 0 9848 76 sff1_x4
xsubckt_8944_sff1_x4 1 2251 0 9481 1576 sff1_x4
xsubckt_9321_sff1_x4 1 2212 0 9119 1020 sff1_x4
xsubckt_9395_sff1_x4 1 2209 0 9048 948 sff1_x4
xsubckt_2253_mx2_x2 0 10430 1 6300 6143 1818 mx2_x2
xsubckt_1420_nand4_x0 1 0 6939 6945 6950 7974 8009 nand4_x0
xsubckt_2642_mx2_x2 0 5713 1 810 1864 1512 mx2_x2
xsubckt_2644_mx2_x2 0 5711 1 784 5712 5715 mx2_x2
xsubckt_2646_mx2_x2 0 5709 1 810 1224 1192 mx2_x2
xsubckt_4775_nand3_x0 1 0 4040 4042 4054 4065 nand3_x0
xsubckt_5130_a3_x2 1 3757 0 45 154 8398 a3_x2
xsubckt_5539_oa22_x2 0 3402 1 3407 2016 2015 oa22_x2
xsubckt_6601_mx2_x2 0 2427 1 840 1424 1392 mx2_x2
xsubckt_6603_mx2_x2 0 2425 1 8215 2426 2429 mx2_x2
xsubckt_7090_mx2_x2 0 9585 1 8665 6179 1534 mx2_x2
xsubckt_7092_mx2_x2 0 9583 1 8666 6162 1532 mx2_x2
xsubckt_7094_mx2_x2 0 9581 1 8666 6142 1530 mx2_x2
xsubckt_7138_mx2_x2 0 9557 1 8645 340 445 mx2_x2
xsubckt_7481_mx2_x2 0 9328 1 8485 6027 875 mx2_x2
xsubckt_7485_mx2_x2 0 9326 1 8480 6283 1123 mx2_x2
xsubckt_8495_sff1_x4 1 2179 0 9862 91 sff1_x4
xsubckt_9317_sff1_x4 1 2198 0 9123 1024 sff1_x4
xsubckt_2259_mx2_x2 0 10429 1 6299 6134 1817 mx2_x2
xsubckt_2248_a3_x2 1 6148 0 6149 541 8408 a3_x2
xsubckt_544_nor3_x0 1 0 7795 1897 1894 1902 nor3_x0
xsubckt_1063_oa22_x2 0 7295 1 7614 7478 7296 oa22_x2
xsubckt_1113_a2_x2 0 7248 1 747 72 a2_x2
xsubckt_1133_a2_x2 0 7229 1 746 71 a2_x2
xsubckt_2463_a3_x2 1 5888 0 5889 5890 5893 a3_x2
xsubckt_2509_xr2_x1 5843 0 1 237 756 xr2_x1
xsubckt_2648_mx2_x2 0 5707 1 8033 5708 5709 mx2_x2
xsubckt_2743_nand3_x0 1 0 5614 5615 5741 6392 nand3_x0
xsubckt_2833_nand3_x0 1 0 5525 5550 5554 8011 nand3_x0
xsubckt_2991_mx2_x2 0 5370 1 811 928 896 mx2_x2
xsubckt_2993_mx2_x2 0 5368 1 8033 5369 5370 mx2_x2
xsubckt_2995_mx2_x2 0 5366 1 811 1504 1472 mx2_x2
xsubckt_3216_oa22_x2 0 5149 1 5152 5157 7907 oa22_x2
xsubckt_4710_a3_x2 1 4089 0 4091 4141 1969 a3_x2
xsubckt_5229_a3_x2 1 3665 0 44 147 8397 a3_x2
xsubckt_5320_nxr2_x1 3580 1 0 3886 730 nxr2_x1
xsubckt_5408_nxr2_x1 3498 1 0 3868 8268 nxr2_x1
xsubckt_6216_mx2_x2 0 2802 1 842 1851 1819 mx2_x2
xsubckt_6218_mx2_x2 0 2800 1 842 1723 1691 mx2_x2
xsubckt_6561_mx2_x2 0 2466 1 842 1649 1617 mx2_x2
xsubckt_6605_mx2_x2 0 2423 1 8207 2424 2439 mx2_x2
xsubckt_7096_mx2_x2 0 9579 1 8666 6124 1528 mx2_x2
xsubckt_7098_mx2_x2 0 9577 1 8666 6107 1525 mx2_x2
xsubckt_7487_mx2_x2 0 9324 1 8480 6272 1111 mx2_x2
xsubckt_7489_mx2_x2 0 9322 1 8480 6258 1097 mx2_x2
xsubckt_8417_sff1_x4 1 2108 0 9940 1614 sff1_x4
xsubckt_8852_sff1_x4 1 2109 0 9573 1521 sff1_x4
xsubckt_2356_a2_x2 0 6004 1 6005 6012 a2_x2
xsubckt_1594_a3_x2 1 6776 0 6777 6778 6779 a3_x2
xsubckt_449_mx2_x2 0 7889 1 7911 7890 7907 mx2_x2
xsubckt_651_xr2_x1 7690 0 1 741 66 xr2_x1
xsubckt_913_nand2_x0 1 0 7437 7991 2032 nand2_x0
xsubckt_2856_xr2_x1 5503 0 1 218 737 xr2_x1
xsubckt_2997_mx2_x2 0 5364 1 8033 5365 5366 mx2_x2
xsubckt_2999_mx2_x2 0 5362 1 812 1664 1632 mx2_x2
xsubckt_4770_a3_x2 1 4044 0 4048 1953 8330 a3_x2
xsubckt_5646_ao22_x2 0 3327 1 3329 3330 7905 ao22_x2
xsubckt_5814_mx3_x2 1 0 9708 7933 7840 456 6395 756 mx3_x2
xsubckt_5816_mx3_x2 1 0 9706 7933 7840 442 6317 742 mx3_x2
xsubckt_6170_mx2_x2 0 2846 1 8219 2847 2848 mx2_x2
xsubckt_6172_mx2_x2 0 2844 1 827 2845 2852 mx2_x2
xsubckt_6563_mx2_x2 0 2464 1 8219 2465 2466 mx2_x2
xsubckt_6565_mx2_x2 0 2462 1 844 1425 1393 mx2_x2
xsubckt_6567_mx2_x2 0 2460 1 8212 2461 2464 mx2_x2
xsubckt_6903_ao22_x2 0 8782 1 706 8279 622 ao22_x2
xsubckt_7314_nand3_x0 1 0 8528 8529 8244 702 nand3_x0
xsubckt_7952_sff1_x4 1 2166 0 10405 247 sff1_x4
xsubckt_9225_sff1_x4 1 2212 0 9215 1084 sff1_x4
xsubckt_1642_a2_x2 0 6732 1 6733 8415 a2_x2
xsubckt_2845_a2_x2 0 5513 1 5514 5516 a2_x2
xsubckt_4061_nand2_x0 1 0 4318 4319 8020 nand2_x0
xsubckt_4151_nand2_x0 1 0 4229 4230 4234 nand2_x0
xsubckt_4643_a2_x2 0 4144 1 700 1912 a2_x2
xsubckt_5197_ao22_x2 0 3694 1 3695 3696 3701 ao22_x2
xsubckt_5357_a2_x2 0 3545 1 3548 653 a2_x2
xsubckt_5552_a2_x2 0 9773 1 3394 55 a2_x2
xsubckt_5572_a2_x2 0 3380 1 3382 2003 a2_x2
xsubckt_5592_a2_x2 0 9761 1 3366 55 a2_x2
xsubckt_5723_nor2_x0 1 0 3279 1913 1912 nor2_x0
xsubckt_6569_mx2_x2 0 2458 1 8207 2459 2474 mx2_x2
xsubckt_6910_a2_x2 0 9653 1 8777 55 a2_x2
xsubckt_7224_nand3_x0 1 0 8597 8598 8604 8609 nand3_x0
xsubckt_7948_sff1_x4 1 2089 0 10409 221 sff1_x4
xsubckt_8325_sff1_x4 1 2106 0 10032 1347 sff1_x4
xsubckt_8760_sff1_x4 1 2073 0 9662 648 sff1_x4
xsubckt_8848_sff1_x4 1 2216 0 9577 1525 sff1_x4
xsubckt_9299_sff1_x4 1 2116 0 9141 1041 sff1_x4
xsubckt_643_nand2_x0 1 0 7697 2011 637 nand2_x0
xsubckt_733_nand2_x0 1 0 7608 634 1915 nand2_x0
xsubckt_1152_xr2_x1 7211 0 1 744 69 xr2_x1
xsubckt_2916_nand2_x0 1 0 5444 5447 5450 nand2_x0
xsubckt_4147_nand3_x0 1 0 4233 4342 4397 6392 nand3_x0
xsubckt_5031_ao22_x2 0 3848 1 3850 3852 7853 ao22_x2
xsubckt_5254_mx2_x2 0 3641 1 8276 3642 3901 mx2_x2
xsubckt_5647_mx2_x2 0 3326 1 7859 225 229 mx2_x2
xsubckt_5990_mx2_x2 0 3021 1 8220 3022 3023 mx2_x2
xsubckt_8399_sff1_x4 1 2235 0 9958 1633 sff1_x4
xsubckt_8756_sff1_x4 1 2073 0 9666 660 sff1_x4
xsubckt_9133_sff1_x4 1 2225 0 9307 1112 sff1_x4
xsubckt_1794_nxr2_x1 6590 1 0 6591 8048 nxr2_x1
xsubckt_474_nor2_x0 1 0 7863 61 60 nor2_x0
xsubckt_360_nor3_x0 1 0 7988 627 626 614 nor3_x0
xsubckt_553_nand2_x0 1 0 7783 1898 249 nand2_x0
xsubckt_2736_nand2_x0 1 0 5621 220 739 nand2_x0
xsubckt_3555_oa22_x2 0 4815 1 4816 4817 8017 oa22_x2
xsubckt_3618_nand2_x0 1 0 4753 6008 8083 nand2_x0
xsubckt_5992_mx2_x2 0 3019 1 826 3020 3027 mx2_x2
xsubckt_6608_oa22_x2 0 2420 1 3191 2423 2421 oa22_x2
xsubckt_8233_sff1_x4 1 2100 0 10124 1673 sff1_x4
xsubckt_9129_sff1_x4 1 2212 0 9311 1116 sff1_x4
xsubckt_1709_o2_x2 0 6669 1 6670 6939 o2_x2
xsubckt_400_a3_x2 1 7945 0 7946 7949 7977 a3_x2
xsubckt_2556_nand2_x0 1 0 5797 226 745 nand2_x0
xsubckt_3438_nand2_x0 1 0 4930 6008 8088 nand2_x0
xsubckt_4336_mx2_x2 0 10223 1 4191 6278 1474 mx2_x2
xsubckt_5263_oa22_x2 0 3633 1 3648 3646 3647 oa22_x2
xsubckt_8141_sff1_x4 1 2235 0 10216 1445 sff1_x4
xsubckt_8229_sff1_x4 1 2103 0 10128 1699 sff1_x4
xsubckt_8664_sff1_x4 1 2182 0 9725 524 sff1_x4
xsubckt_9041_sff1_x4 1 2126 0 9389 1378 sff1_x4
xcmpt_abc_30082_new_n3740_hfns_3 1 0 7887 7883 buf_x4
xcmpt_abc_30082_new_n3740_hfns_2 1 0 7883 7884 buf_x4
xcmpt_abc_30082_new_n3740_hfns_1 1 0 7883 7885 buf_x4
xcmpt_abc_30082_new_n3740_hfns_0 1 0 7883 7886 buf_x4
xsubckt_1769_o2_x2 0 6613 1 6614 6939 o2_x2
xsubckt_1755_oa22_x2 0 6626 1 6628 6635 6939 oa22_x2
xsubckt_459_nand3_x0 1 0 7873 7909 7910 627 nand3_x0
xsubckt_420_a3_x2 1 7924 0 366 365 504 a3_x2
xsubckt_3410_mx2_x2 0 4958 1 814 921 889 mx2_x2
xsubckt_3601_nand2_x0 1 0 4770 4771 8023 nand2_x0
xsubckt_4290_mx2_x2 0 10262 1 4204 6061 1168 mx2_x2
xsubckt_4292_mx2_x2 0 10260 1 4204 6043 1166 mx2_x2
xsubckt_4338_mx2_x2 0 10221 1 4190 6265 1452 mx2_x2
xsubckt_4755_nxr2_x1 4055 1 0 4058 8326 nxr2_x1
xsubckt_5132_nxr2_x1 3755 1 0 3768 3925 nxr2_x1
xsubckt_6951_oa22_x2 0 8745 1 8750 8746 8747 oa22_x2
xsubckt_7217_nand2_x0 1 0 8602 7976 375 nand2_x0
xsubckt_9037_sff1_x4 1 2079 0 9393 377 sff1_x4
xsubckt_9472_sff1_x4 1 2096 0 8971 1836 sff1_x4
xsubckt_3258_nand2_x0 1 0 5107 6008 8094 nand2_x0
xsubckt_3412_mx2_x2 0 4956 1 8036 4957 4958 mx2_x2
xsubckt_3414_mx2_x2 0 4954 1 815 1497 1465 mx2_x2
xsubckt_3416_mx2_x2 0 4952 1 8035 4953 4954 mx2_x2
xsubckt_3511_nand2_x0 1 0 4859 236 755 nand2_x0
xsubckt_4294_mx2_x2 0 10258 1 4204 6026 1163 mx2_x2
xsubckt_4298_mx2_x2 0 10256 1 4199 6283 1251 mx2_x2
xsubckt_5563_nxr2_x1 3386 1 0 3389 8117 nxr2_x1
xsubckt_6958_nor2_x0 1 0 8740 8764 8818 nor2_x0
xsubckt_8137_sff1_x4 1 2106 0 10220 1449 sff1_x4
xsubckt_8572_sff1_x4 1 2050 0 9785 2024 sff1_x4
xsubckt_221_inv_x0 1 0 2268 8155 inv_x0
xsubckt_627_a2_x2 0 7713 1 742 67 a2_x2
xsubckt_647_a2_x2 0 7693 1 7694 7700 a2_x2
xsubckt_802_a2_x2 0 7543 1 764 89 a2_x2
xsubckt_842_a2_x2 0 7505 1 762 87 a2_x2
xsubckt_2715_nand3_x0 1 0 5641 5666 5670 8012 nand3_x0
xsubckt_2893_nand3_x0 1 0 5466 5476 5480 770 nand3_x0
xsubckt_3078_nand2_x0 1 0 5284 6008 8098 nand2_x0
xsubckt_3418_mx2_x2 0 4950 1 815 1657 1625 mx2_x2
xsubckt_3421_nand2_x0 1 0 4947 4948 8024 nand2_x0
xsubckt_3763_mx2_x2 0 4611 1 815 1170 1074 mx2_x2
xsubckt_3816_oa22_x2 0 4559 1 4562 4567 7907 oa22_x2
xsubckt_4663_nxr2_x1 4125 1 0 4128 8310 nxr2_x1
xsubckt_5167_oa22_x2 0 3722 1 3724 3727 8295 oa22_x2
xsubckt_5535_nor2_x0 1 0 3405 3407 2016 nor2_x0
xsubckt_7331_mx2_x2 0 9490 1 8832 8515 742 mx2_x2
xsubckt_7460_mx3_x2 1 0 9349 8487 6294 868 6216 6220 mx3_x2
xsubckt_7462_mx3_x2 1 0 9347 8487 6294 896 6197 6201 mx3_x2
xsubckt_7720_mx2_x2 0 9104 1 8449 6027 1003 mx2_x2
xsubckt_9380_sff1_x4 1 2193 0 9063 934 sff1_x4
xsubckt_9468_sff1_x4 1 2136 0 8975 1866 sff1_x4
xfeed_109 1 0 decap_w0
xfeed_108 1 0 decap_w0
xfeed_107 1 0 decap_w0
xfeed_106 1 0 tie
xfeed_105 1 0 decap_w0
xfeed_104 1 0 decap_w0
xfeed_103 1 0 decap_w0
xfeed_102 1 0 decap_w0
xfeed_101 1 0 decap_w0
xfeed_100 1 0 decap_w0
xsubckt_2105_mx2_x2 0 6342 1 8212 6343 6346 mx2_x2
xsubckt_2103_mx2_x2 0 6344 1 850 1129 1097 mx2_x2
xsubckt_2101_mx2_x2 0 6346 1 834 6347 6348 mx2_x2
xsubckt_1743_nand3_x0 1 0 6637 6638 6639 6640 nand3_x0
xsubckt_227_inv_x0 1 0 2264 8149 inv_x0
xsubckt_225_inv_x0 1 0 2266 8151 inv_x0
xsubckt_223_inv_x0 1 0 2267 8153 inv_x0
xsubckt_973_nand2_x0 1 0 7380 634 1964 nand2_x0
xsubckt_1046_nand2_x0 1 0 7311 7991 2024 nand2_x0
xsubckt_2670_ao22_x2 0 5685 1 5958 5692 5686 ao22_x2
xsubckt_3241_nand2_x0 1 0 5124 5125 8024 nand2_x0
xsubckt_3767_mx2_x2 0 4607 1 817 1778 1746 mx2_x2
xsubckt_5001_oa22_x2 0 9845 1 7886 3873 3875 oa22_x2
xsubckt_7680_mx2_x2 0 9142 1 8454 6081 1042 mx2_x2
xsubckt_7724_mx2_x2 0 9102 1 8444 6283 995 mx2_x2
xsubckt_7726_mx2_x2 0 9100 1 8443 6272 983 mx2_x2
xsubckt_7728_mx2_x2 0 9098 1 8444 6259 969 mx2_x2
xsubckt_8045_sff1_x4 1 2172 0 10312 1733 sff1_x4
xsubckt_8480_sff1_x4 1 2044 0 9877 1923 sff1_x4
xsubckt_8568_sff1_x4 1 2050 0 9789 2028 sff1_x4
xsubckt_9302_sff1_x4 1 2116 0 9138 1038 sff1_x4
xsubckt_2109_mx2_x2 0 6338 1 849 1577 1545 mx2_x2
xsubckt_2107_mx2_x2 0 6340 1 849 1481 1449 mx2_x2
xsubckt_2063_mx2_x2 0 6383 1 849 1228 1196 mx2_x2
xsubckt_2061_mx2_x2 0 6385 1 849 1356 1324 mx2_x2
xsubckt_1528_nxr2_x1 6838 1 0 6840 220 nxr2_x1
xsubckt_229_inv_x0 1 0 2263 8147 inv_x0
xsubckt_181_inv_x0 1 0 2259 8195 inv_x0
xsubckt_183_inv_x0 1 0 2258 8193 inv_x0
xsubckt_705_nand2_x0 1 0 7638 7639 7798 nand2_x0
xsubckt_3151_nand2_x0 1 0 5213 243 762 nand2_x0
xsubckt_3858_nand2_x0 1 0 4517 6008 8073 nand2_x0
xsubckt_4101_oa22_x2 0 4279 1 4333 4332 4331 oa22_x2
xsubckt_5302_a3_x2 1 3597 0 3624 3888 3891 a3_x2
xsubckt_6020_mx2_x2 0 2992 1 8212 2993 2996 mx2_x2
xsubckt_6174_ao22_x2 0 2842 1 574 569 762 ao22_x2
xsubckt_6411_mx2_x2 0 2612 1 849 1301 1269 mx2_x2
xsubckt_6802_mx2_x2 0 8855 1 8856 8857 559 mx2_x2
xsubckt_7682_mx2_x2 0 9140 1 8454 6062 1040 mx2_x2
xsubckt_7684_mx2_x2 0 9138 1 8454 6044 1038 mx2_x2
xsubckt_8402_sff1_x4 1 2245 0 9955 1630 sff1_x4
xsubckt_8925_sff1_x4 1 2079 0 9500 762 sff1_x4
xsubckt_8999_sff1_x4 1 2108 0 9426 1550 sff1_x4
xsubckt_9376_sff1_x4 1 2103 0 9067 940 sff1_x4
xfeed_119 1 0 decap_w0
xfeed_118 1 0 decap_w0
xfeed_117 1 0 decap_w0
xfeed_116 1 0 tie
xfeed_115 1 0 decap_w0
xfeed_114 1 0 decap_w0
xfeed_113 1 0 tie
xfeed_112 1 0 decap_w0
xfeed_111 1 0 decap_w0
xfeed_110 1 0 tie
xsubckt_2361_a3_x2 1 5999 0 6000 7894 51 a3_x2
xsubckt_2265_nand3_x0 1 0 6127 6128 6130 6288 nand3_x0
xsubckt_2198_mx3_x2 1 0 10439 6302 6288 1797 6226 6230 mx3_x2
xsubckt_2067_mx2_x2 0 6379 1 852 1420 1388 mx2_x2
xsubckt_2065_mx2_x2 0 6381 1 8224 6382 6383 mx2_x2
xsubckt_1916_nand2_x0 1 0 6480 7810 214 nand2_x0
xsubckt_1473_nand3_x0 1 0 6889 6890 6891 6892 nand3_x0
xsubckt_185_inv_x0 1 0 2257 8191 inv_x0
xsubckt_187_inv_x0 1 0 2286 8189 inv_x0
xsubckt_189_inv_x0 1 0 2285 8187 inv_x0
xsubckt_615_nand2_x0 1 0 7724 7725 7727 nand2_x0
xsubckt_632_oa22_x2 0 7708 1 7806 7939 8232 oa22_x2
xsubckt_793_nand2_x0 1 0 7551 634 1974 nand2_x0
xsubckt_1044_oa22_x2 0 7313 1 7614 7478 7314 oa22_x2
xsubckt_3061_nand2_x0 1 0 5301 5302 8021 nand2_x0
xsubckt_3923_ao22_x2 0 4453 1 4502 4501 4454 ao22_x2
xsubckt_4029_nand3_x0 1 0 4349 4359 4363 771 nand3_x0
xsubckt_5187_a3_x2 1 3704 0 52 150 8399 a3_x2
xsubckt_5342_a3_x2 1 3560 0 3561 3562 8295 a3_x2
xsubckt_6022_mx2_x2 0 2990 1 853 1601 1569 mx2_x2
xsubckt_6024_mx2_x2 0 2988 1 853 1505 1473 mx2_x2
xsubckt_6413_mx2_x2 0 2610 1 848 1237 1205 mx2_x2
xsubckt_6415_mx2_x2 0 2608 1 8226 2609 2610 mx2_x2
xsubckt_6417_mx2_x2 0 2606 1 848 1653 1621 mx2_x2
xsubckt_6760_mx2_x2 0 8894 1 833 8895 8896 mx2_x2
xsubckt_6808_mx2_x2 0 8850 1 8852 8851 557 mx2_x2
xsubckt_7013_a2_x2 0 8694 1 376 387 a2_x2
xsubckt_7686_mx2_x2 0 9136 1 8454 6026 1035 mx2_x2
xsubckt_8476_sff1_x4 1 2044 0 9881 1927 sff1_x4
xsubckt_8833_sff1_x4 1 2132 0 9592 1511 sff1_x4
xsubckt_9210_sff1_x4 1 2103 0 9230 1091 sff1_x4
xsubckt_2069_mx2_x2 0 6377 1 834 6378 6379 mx2_x2
xsubckt_1000_xr2_x1 7355 0 1 753 78 xr2_x1
xsubckt_1071_a2_x2 0 7287 1 7288 7294 a2_x2
xsubckt_1091_a2_x2 0 7268 1 7269 7277 a2_x2
xsubckt_2796_nand2_x0 1 0 5562 219 738 nand2_x0
xsubckt_3143_a2_x2 0 5220 1 5221 5226 a2_x2
xsubckt_3310_nand3_x0 1 0 5056 5081 5085 8011 nand3_x0
xsubckt_3678_nand2_x0 1 0 4694 6008 8080 nand2_x0
xsubckt_4541_a2_x2 0 4159 1 4183 4194 a2_x2
xsubckt_4902_a3_x2 1 3947 0 50 70 8398 a3_x2
xsubckt_4922_a3_x2 1 3932 0 50 63 8398 a3_x2
xsubckt_4942_a3_x2 1 3917 0 50 88 8398 a3_x2
xsubckt_5636_a3_x2 1 3335 0 3339 1982 1983 a3_x2
xsubckt_6026_mx2_x2 0 2986 1 8224 2987 2988 mx2_x2
xsubckt_6028_mx2_x2 0 2984 1 826 2985 2992 mx2_x2
xsubckt_6371_mx2_x2 0 2651 1 833 2652 2653 mx2_x2
xsubckt_6373_mx2_x2 0 2649 1 826 2650 2657 mx2_x2
xsubckt_6419_mx2_x2 0 2604 1 8224 2605 2606 mx2_x2
xsubckt_6762_mx2_x2 0 8892 1 851 1866 1514 mx2_x2
xsubckt_6764_mx2_x2 0 8890 1 8224 8891 8892 mx2_x2
xsubckt_6766_mx2_x2 0 8888 1 851 1034 1002 mx2_x2
xsubckt_7347_a2_x2 0 8502 1 4165 4171 a2_x2
xsubckt_7933_sff1_x4 1 2119 0 10419 1806 sff1_x4
xsubckt_8310_sff1_x4 1 2242 0 10047 1658 sff1_x4
xsubckt_9206_sff1_x4 1 2136 0 9234 1198 sff1_x4
xsubckt_9284_sff1_x4 1 2235 0 9156 1057 sff1_x4
xfeed_129 1 0 decap_w0
xfeed_128 1 0 decap_w0
xfeed_127 1 0 tie
xfeed_126 1 0 decap_w0
xfeed_125 1 0 tie
xfeed_124 1 0 tie
xfeed_123 1 0 decap_w0
xfeed_122 1 0 decap_w0
xfeed_121 1 0 tie
xfeed_120 1 0 tie
xsubckt_1475_oa22_x2 0 6888 1 6905 6895 6896 oa22_x2
xsubckt_2732_oa22_x2 0 5625 1 5682 5679 5681 oa22_x2
xsubckt_3130_nand3_x0 1 0 5233 5258 5262 8013 nand3_x0
xsubckt_3498_nand2_x0 1 0 4871 6007 8087 nand2_x0
xsubckt_3751_nand2_x0 1 0 4623 232 751 nand2_x0
xsubckt_3841_nand2_x0 1 0 4534 4535 8023 nand2_x0
xsubckt_4815_a2_x2 0 4010 1 1942 1941 a2_x2
xsubckt_4962_a3_x2 1 3902 0 41 83 8399 a3_x2
xsubckt_4982_a3_x2 1 3887 0 41 77 8399 a3_x2
xsubckt_5470_a2_x2 0 9799 1 3450 41 a2_x2
xsubckt_5490_a2_x2 0 9793 1 3436 41 a2_x2
xsubckt_5840_mx2_x2 0 3167 1 8213 3168 3171 mx2_x2
xsubckt_6375_mx2_x2 0 2647 1 857 1302 1270 mx2_x2
xsubckt_6377_mx2_x2 0 2645 1 857 1238 1206 mx2_x2
xsubckt_6379_mx2_x2 0 2643 1 8225 2644 2645 mx2_x2
xsubckt_6768_mx2_x2 0 8886 1 8213 8887 8890 mx2_x2
xsubckt_6879_a3_x2 1 8798 0 8245 571 702 a3_x2
xsubckt_6907_a2_x2 0 8779 1 8807 8261 a2_x2
xsubckt_7620_nand2_x0 1 0 8461 4171 4195 nand2_x0
xsubckt_8306_sff1_x4 1 2245 0 10051 1662 sff1_x4
xsubckt_8384_sff1_x4 1 2132 0 9973 1487 sff1_x4
xsubckt_8741_sff1_x4 1 2176 0 2304 2272 sff1_x4
xsubckt_8829_sff1_x4 1 2126 0 9596 1527 sff1_x4
xsubckt_2334_nand4_x0 1 0 6038 6066 73 72 71 nand4_x0
xsubckt_2283_oa22_x2 0 6103 1 6120 79 78 oa22_x2
xsubckt_2955_nand3_x0 1 0 5405 5410 5414 771 nand3_x0
xsubckt_3661_nand2_x0 1 0 4711 4712 8024 nand2_x0
xsubckt_3926_a2_x2 0 4451 1 5993 229 a2_x2
xsubckt_5589_a2_x2 0 9762 1 3368 3369 a2_x2
xsubckt_5842_mx2_x2 0 3165 1 856 1576 1544 mx2_x2
xsubckt_5844_mx2_x2 0 3163 1 856 1480 1448 mx2_x2
xsubckt_5846_mx2_x2 0 3161 1 8225 3162 3163 mx2_x2
xsubckt_6899_a3_x2 1 8785 0 8244 579 702 a3_x2
xsubckt_6967_a2_x2 0 9639 1 8734 40 a2_x2
xsubckt_7929_sff1_x4 1 2142 0 10423 1810 sff1_x4
xsubckt_8292_sff1_x4 1 2119 0 10065 1290 sff1_x4
xsubckt_9114_sff1_x4 1 2103 0 9326 1123 sff1_x4
xsubckt_9192_sff1_x4 1 2238 0 9248 1213 sff1_x4
xfeed_139 1 0 decap_w0
xfeed_138 1 0 decap_w0
xfeed_137 1 0 decap_w0
xfeed_136 1 0 decap_w0
xfeed_135 1 0 decap_w0
xfeed_134 1 0 decap_w0
xfeed_133 1 0 tie
xfeed_132 1 0 tie
xfeed_131 1 0 decap_w0
xfeed_130 1 0 decap_w0
xsubckt_2279_oa22_x2 0 6109 1 6110 6111 6112 oa22_x2
xsubckt_1805_nand3_x0 1 0 6579 6580 6581 6582 nand3_x0
xsubckt_2511_nand2_x0 1 0 5841 5842 7905 nand2_x0
xsubckt_4271_mx3_x2 1 0 10281 4206 6289 1158 6236 6240 mx3_x2
xsubckt_4871_oa22_x2 0 3969 1 3971 1925 1924 oa22_x2
xsubckt_4920_mx2_x2 0 3933 1 6445 6240 127 mx2_x2
xsubckt_5243_o2_x2 0 9824 1 3652 3665 o2_x2
xsubckt_5255_nor2_x0 1 0 3640 3641 7880 nor2_x0
xsubckt_5848_mx2_x2 0 3159 1 827 3160 3167 mx2_x2
xsubckt_8214_sff1_x4 1 2248 0 10143 1274 sff1_x4
xsubckt_8737_sff1_x4 1 2182 0 2309 2277 sff1_x4
xsubckt_9188_sff1_x4 1 2194 0 9252 1217 sff1_x4
xsubckt_1893_nand3_x0 1 0 6497 6498 6499 6500 nand3_x0
xsubckt_1198_o2_x2 0 7167 1 196 228 o2_x2
xsubckt_945_nand2_x0 1 0 7407 7408 7411 nand2_x0
xsubckt_3013_oa22_x2 0 5348 1 5349 5350 775 oa22_x2
xsubckt_3391_nand2_x0 1 0 4977 239 758 nand2_x0
xsubckt_3481_nand2_x0 1 0 4888 4889 8025 nand2_x0
xsubckt_3910_nand3_x0 1 0 4466 4476 4480 771 nand3_x0
xsubckt_4273_mx3_x2 1 0 10279 4206 6289 1156 6215 6219 mx3_x2
xsubckt_4275_mx3_x2 1 0 10277 4206 6289 1184 6196 6201 mx3_x2
xsubckt_4531_mx2_x2 0 10042 1 4161 6098 1652 mx2_x2
xsubckt_4533_mx2_x2 0 10040 1 4161 6081 1650 mx2_x2
xsubckt_4535_mx2_x2 0 10038 1 4161 6061 1648 mx2_x2
xsubckt_4924_mx2_x2 0 3930 1 6444 6230 126 mx2_x2
xsubckt_4928_mx2_x2 0 3927 1 6444 6219 125 mx2_x2
xsubckt_5279_nxr2_x1 3618 1 0 3895 730 nxr2_x1
xsubckt_8288_sff1_x4 1 2132 0 10069 1295 sff1_x4
xsubckt_9022_sff1_x4 1 2079 0 9408 393 sff1_x4
xfeed_149 1 0 tie
xfeed_148 1 0 decap_w0
xfeed_147 1 0 decap_w0
xfeed_146 1 0 decap_w0
xfeed_145 1 0 decap_w0
xfeed_144 1 0 decap_w0
xfeed_143 1 0 decap_w0
xfeed_142 1 0 decap_w0
xfeed_141 1 0 tie
xfeed_140 1 0 decap_w0
xsubckt_1862_o2_x2 0 6526 1 6527 6939 o2_x2
xsubckt_801_oa22_x2 0 7544 1 7563 7562 7561 oa22_x2
xsubckt_855_nand2_x0 1 0 7492 2000 638 nand2_x0
xsubckt_3444_oa22_x2 0 4924 1 4925 4972 5995 oa22_x2
xsubckt_3730_nand3_x0 1 0 4643 4668 4672 8011 nand3_x0
xsubckt_4491_mx2_x2 0 10079 1 4167 6143 1306 mx2_x2
xsubckt_4537_mx2_x2 0 10036 1 4162 6044 1646 mx2_x2
xsubckt_4539_mx2_x2 0 10034 1 4162 6027 1643 mx2_x2
xsubckt_4876_nand4_x0 1 0 3965 3971 1925 1924 1923 nand4_x0
xsubckt_5404_nand3_x0 1 0 3502 3504 3537 3547 nand3_x0
xsubckt_6981_nand4_x0 1 0 8723 8725 8768 8245 703 nand4_x0
xsubckt_8122_sff1_x4 1 2219 0 10235 1237 sff1_x4
xsubckt_8645_sff1_x4 1 2185 0 9744 526 sff1_x4
xsubckt_9096_sff1_x4 1 2212 0 9344 893 sff1_x4
xsubckt_2327_nand3_x0 1 0 6047 6066 73 72 nand3_x0
xsubckt_765_nand2_x0 1 0 7578 7580 7582 nand2_x0
xsubckt_2858_nand2_x0 1 0 5501 5502 7905 nand2_x0
xsubckt_3220_mx2_x2 0 5145 1 789 5146 5147 mx2_x2
xsubckt_3222_mx2_x2 0 5143 1 799 1884 1532 mx2_x2
xsubckt_3224_mx2_x2 0 5141 1 8033 5142 5143 mx2_x2
xsubckt_3550_nand3_x0 1 0 4820 4845 4849 8013 nand3_x0
xsubckt_4089_nand3_x0 1 0 4290 4310 4314 8013 nand3_x0
xsubckt_4493_mx2_x2 0 10077 1 4168 6124 1304 mx2_x2
xsubckt_4495_mx2_x2 0 10075 1 4168 6108 1301 mx2_x2
xsubckt_4497_mx2_x2 0 10073 1 4168 6089 1299 mx2_x2
xsubckt_4736_nxr2_x1 4069 1 0 4071 8322 nxr2_x1
xsubckt_7701_mx3_x2 1 0 9123 8451 6291 1024 6197 6201 mx3_x2
xsubckt_8118_sff1_x4 1 2248 0 10239 1242 sff1_x4
xsubckt_8196_sff1_x4 1 2109 0 10161 1706 sff1_x4
xsubckt_9018_sff1_x4 1 2066 0 9412 397 sff1_x4
xsubckt_9453_sff1_x4 1 2203 0 8990 1883 sff1_x4
xfeed_159 1 0 decap_w0
xfeed_158 1 0 decap_w0
xfeed_157 1 0 tie
xfeed_156 1 0 tie
xfeed_155 1 0 decap_w0
xfeed_154 1 0 decap_w0
xfeed_153 1 0 decap_w0
xfeed_152 1 0 tie
xfeed_151 1 0 decap_w0
xfeed_150 1 0 decap_w0
xsubckt_1355_nand3_x0 1 0 7010 7090 212 8106 nand3_x0
xsubckt_525_a2_x2 0 7814 1 7815 7831 a2_x2
xsubckt_551_ao22_x2 0 7785 1 7786 7790 7795 ao22_x2
xsubckt_692_a3_x2 1 7650 0 7651 7652 7653 a3_x2
xsubckt_720_a2_x2 0 7624 1 738 63 a2_x2
xsubckt_3180_mx2_x2 0 5184 1 8034 5185 5186 mx2_x2
xsubckt_3226_mx2_x2 0 5139 1 797 1724 1692 mx2_x2
xsubckt_3228_mx2_x2 0 5137 1 788 5138 5139 mx2_x2
xsubckt_3875_oa22_x2 0 4501 1 4503 4508 7907 oa22_x2
xsubckt_3960_mx2_x2 0 4417 1 8034 4418 4419 mx2_x2
xsubckt_3962_mx2_x2 0 4415 1 797 1231 1199 mx2_x2
xsubckt_3964_mx2_x2 0 4413 1 8034 4414 4415 mx2_x2
xsubckt_4499_mx2_x2 0 10071 1 4168 6070 1297 mx2_x2
xsubckt_5109_nxr2_x1 3776 1 0 3931 723 nxr2_x1
xsubckt_5516_nor2_x0 1 0 3418 3421 2023 nor2_x0
xsubckt_5544_nxr2_x1 3399 1 0 3401 8139 nxr2_x1
xsubckt_7305_oa22_x2 0 8535 1 702 8244 737 oa22_x2
xsubckt_7663_mx3_x2 1 0 9159 8456 6292 1030 6235 6239 mx3_x2
xsubckt_8030_sff1_x4 1 2137 0 10327 1137 sff1_x4
xsubckt_8553_sff1_x4 1 2060 0 9804 1996 sff1_x4
xsubckt_8910_sff1_x4 1 2079 0 9515 746 sff1_x4
xsubckt_9449_sff1_x4 1 2242 0 8994 1887 sff1_x4
xsubckt_2302_mx2_x2 0 6078 1 545 106 2270 mx2_x2
xsubckt_2057_nand3_x0 1 0 6388 7859 8281 1899 nand3_x0
xsubckt_1202_a4_x2 0 7163 1 7164 7168 7173 7177 a4_x2
xsubckt_585_a2_x2 0 7753 1 756 81 a2_x2
xsubckt_819_a2_x2 0 7526 1 7527 7535 a2_x2
xsubckt_859_a2_x2 0 7488 1 7489 7497 a2_x2
xsubckt_3182_mx2_x2 0 5182 1 821 1245 1213 mx2_x2
xsubckt_3184_mx2_x2 0 5180 1 8034 5181 5182 mx2_x2
xsubckt_3186_mx2_x2 0 5178 1 796 1373 1341 mx2_x2
xsubckt_3370_nand3_x0 1 0 4997 5022 5026 8012 nand3_x0
xsubckt_3579_mx2_x2 0 4792 1 796 1045 1013 mx2_x2
xsubckt_3966_mx2_x2 0 4411 1 796 1359 1327 mx2_x2
xsubckt_3968_mx2_x2 0 4409 1 8034 4410 4411 mx2_x2
xsubckt_7141_mx2_x2 0 9554 1 8645 335 440 mx2_x2
xsubckt_7143_mx2_x2 0 9552 1 8643 438 333 mx2_x2
xsubckt_7532_mx2_x2 0 9281 1 8474 6179 1406 mx2_x2
xsubckt_7534_mx2_x2 0 9279 1 8474 6162 1404 mx2_x2
xsubckt_7536_mx2_x2 0 9277 1 8475 6142 1402 mx2_x2
xsubckt_7665_mx3_x2 1 0 9157 8456 6292 1028 6216 6220 mx3_x2
xsubckt_7667_mx3_x2 1 0 9155 8456 6292 1056 6197 6201 mx3_x2
xsubckt_8026_sff1_x4 1 2219 0 10331 1141 sff1_x4
xsubckt_8549_sff1_x4 1 2060 0 9808 2040 sff1_x4
xsubckt_8984_sff1_x4 1 2245 0 9441 1566 sff1_x4
xsubckt_9361_sff1_x4 1 2216 0 9082 982 sff1_x4
xfeed_169 1 0 tie
xfeed_168 1 0 decap_w0
xfeed_167 1 0 decap_w0
xfeed_166 1 0 decap_w0
xfeed_165 1 0 decap_w0
xfeed_164 1 0 tie
xfeed_163 1 0 decap_w0
xfeed_162 1 0 decap_w0
xfeed_161 1 0 decap_w0
xfeed_160 1 0 decap_w0
xcmpt_abc_30082_new_n11080_hfns_2 1 0 8435 8432 buf_x4
xcmpt_abc_30082_new_n11080_hfns_1 1 0 8432 8433 buf_x4
xcmpt_abc_30082_new_n11080_hfns_0 1 0 8432 8434 buf_x4
xsubckt_2260_mx2_x2 0 6132 1 546 113 2277 mx2_x2
xsubckt_1587_nxr2_x1 6783 1 0 6786 246 nxr2_x1
xsubckt_1509_nxr2_x1 6856 1 0 6858 440 nxr2_x1
xsubckt_465_o3_x2 0 318 1 657 621 620 o3_x2
xsubckt_660_o3_x2 0 7681 1 404 330 328 o3_x2
xsubckt_2498_nand2_x0 1 0 5854 5879 8011 nand2_x0
xsubckt_2651_mx2_x2 0 5704 1 789 5705 5706 mx2_x2
xsubckt_2653_mx2_x2 0 5702 1 820 1576 1544 mx2_x2
xsubckt_2841_nand2_x0 1 0 5517 6008 8106 nand2_x0
xsubckt_3012_nand3_x0 1 0 5349 5359 5363 772 nand3_x0
xsubckt_3188_mx2_x2 0 5176 1 8035 5177 5178 mx2_x2
xsubckt_3190_nand3_x0 1 0 5174 5199 5203 8011 nand3_x0
xsubckt_3392_xr2_x1 4976 0 1 239 758 xr2_x1
xsubckt_5045_a3_x2 1 3836 0 54 130 8397 a3_x2
xsubckt_6678_ao22_x2 0 2352 1 574 569 747 ao22_x2
xsubckt_7145_mx2_x2 0 9550 1 8643 466 361 mx2_x2
xsubckt_7147_mx2_x2 0 9548 1 8643 464 359 mx2_x2
xsubckt_7149_mx2_x2 0 9546 1 8643 462 357 mx2_x2
xsubckt_7490_mx2_x2 0 9321 1 8480 6252 1096 mx2_x2
xsubckt_7538_mx2_x2 0 9275 1 8475 6125 1400 mx2_x2
xsubckt_8461_sff1_x4 1 2060 0 9896 1944 sff1_x4
xsubckt_8906_sff1_x4 1 2066 0 9519 61 sff1_x4
xsubckt_9357_sff1_x4 1 2203 0 9086 987 sff1_x4
xspare_feed_209 1 0 decap_w0
xspare_feed_208 1 0 decap_w0
xspare_feed_207 1 0 decap_w0
xspare_feed_206 1 0 decap_w0
xspare_feed_205 1 0 decap_w0
xspare_feed_204 1 0 decap_w0
xspare_feed_203 1 0 decap_w0
xspare_feed_202 1 0 decap_w0
xspare_feed_201 1 0 decap_w0
xspare_feed_200 1 0 decap_w0
xsubckt_2318_a3_x2 1 6058 0 6059 541 8409 a3_x2
xsubckt_2268_mx2_x2 0 6122 1 545 111 2275 mx2_x2
xsubckt_378_o2_x2 0 7967 1 648 647 o2_x2
xsubckt_654_nand3_x0 1 0 7687 7688 7689 1903 nand3_x0
xsubckt_1025_oa22_x2 0 7331 1 7614 7478 7332 oa22_x2
xsubckt_2655_mx2_x2 0 5700 1 790 5701 5702 mx2_x2
xsubckt_2657_mx2_x2 0 5698 1 809 1416 1384 mx2_x2
xsubckt_2659_mx2_x2 0 5696 1 8023 5697 5700 mx2_x2
xsubckt_2837_nand3_x0 1 0 5521 5526 5530 772 nand3_x0
xsubckt_4331_a3_x2 1 4195 0 551 552 8006 a3_x2
xsubckt_4772_a4_x2 0 4043 1 701 1953 1952 1912 a4_x2
xsubckt_5339_a3_x2 1 3563 0 3588 3879 3882 a3_x2
xsubckt_5448_nxr2_x1 3464 1 0 3468 8136 nxr2_x1
xsubckt_6221_mx2_x2 0 2797 1 8214 2798 2801 mx2_x2
xsubckt_6223_mx2_x2 0 2795 1 863 1179 1083 mx2_x2
xsubckt_6225_mx2_x2 0 2793 1 863 987 955 mx2_x2
xsubckt_6612_mx2_x2 0 2417 1 863 1839 1807 mx2_x2
xsubckt_6614_mx2_x2 0 2415 1 864 1711 1679 mx2_x2
xsubckt_6616_mx2_x2 0 2413 1 835 2414 2415 mx2_x2
xsubckt_7498_mx2_x2 0 9313 1 8480 6179 1118 mx2_x2
xsubckt_8457_sff1_x4 1 2057 0 9900 1948 sff1_x4
xsubckt_8892_sff1_x4 1 2050 0 9533 343 sff1_x4
xfeed_179 1 0 tie
xfeed_178 1 0 decap_w0
xfeed_177 1 0 tie
xfeed_176 1 0 decap_w0
xfeed_175 1 0 decap_w0
xfeed_174 1 0 decap_w0
xfeed_173 1 0 tie
xfeed_172 1 0 tie
xfeed_171 1 0 tie
xfeed_170 1 0 tie
xcmpt_abc_30082_new_n10944_hfns_2 1 0 8455 8452 buf_x4
xcmpt_abc_30082_new_n10944_hfns_1 1 0 8452 8453 buf_x4
xcmpt_abc_30082_new_n10944_hfns_0 1 0 8452 8454 buf_x4
xcmpt_abc_30082_new_n5631_hfns_2 1 0 6028 6025 buf_x4
xcmpt_abc_30082_new_n5631_hfns_1 1 0 6025 6026 buf_x4
xcmpt_abc_30082_new_n5631_hfns_0 1 0 6025 6027 buf_x4
xsubckt_2406_a2_x2 0 5944 1 768 249 a2_x2
xsubckt_2152_a2_x2 0 6306 1 6307 7884 a2_x2
xsubckt_1791_a4_x2 0 6593 1 6634 8045 8046 8047 a4_x2
xsubckt_1624_a3_x2 1 6748 0 6749 6750 6751 a3_x2
xsubckt_1263_a2_x2 0 7102 1 209 242 a2_x2
xsubckt_1243_a2_x2 0 7122 1 205 238 a2_x2
xsubckt_1099_oa22_x2 0 7261 1 411 7810 7618 oa22_x2
xsubckt_3335_a2_x2 0 5032 1 5033 5040 a2_x2
xsubckt_3510_a2_x2 0 4860 1 236 755 a2_x2
xsubckt_3970_nand3_x0 1 0 4407 4432 4436 8012 nand3_x0
xsubckt_4645_a3_x2 1 4138 0 701 1977 1912 a3_x2
xsubckt_4712_ao22_x2 0 4087 1 4090 4139 8317 ao22_x2
xsubckt_6181_mx2_x2 0 2836 1 8222 2837 2838 mx2_x2
xsubckt_6227_mx2_x2 0 2791 1 836 2792 2793 mx2_x2
xsubckt_6229_mx2_x2 0 2789 1 826 2790 2797 mx2_x2
xsubckt_6618_mx2_x2 0 2411 1 862 1871 1519 mx2_x2
xsubckt_7232_nand2_x0 1 0 8592 7976 381 nand2_x0
xsubckt_7992_sff1_x4 1 2222 0 10365 1784 sff1_x4
xsubckt_8814_sff1_x4 1 2066 0 9608 711 sff1_x4
xsubckt_9265_sff1_x4 1 2145 0 9175 1427 sff1_x4
xspare_feed_219 1 0 decap_w0
xspare_feed_218 1 0 decap_w0
xspare_feed_217 1 0 decap_w0
xspare_feed_216 1 0 decap_w0
xspare_feed_215 1 0 decap_w0
xspare_feed_214 1 0 decap_w0
xspare_feed_213 1 0 decap_w0
xspare_feed_212 1 0 decap_w0
xspare_feed_211 1 0 decap_w0
xspare_feed_210 1 0 decap_w0
xsubckt_1752_a2_x2 0 6629 1 6630 234 a2_x2
xsubckt_1456_oa22_x2 0 2308 1 6940 6910 6906 oa22_x2
xsubckt_827_nand2_x0 1 0 7519 7685 328 nand2_x0
xsubckt_887_o2_x2 0 7462 1 7463 7465 o2_x2
xsubckt_1078_nand2_x0 1 0 7281 7283 7285 nand2_x0
xsubckt_4065_nand2_x0 1 0 4314 4315 780 nand2_x0
xsubckt_4685_a3_x2 1 9925 0 4109 4110 55 a3_x2
xsubckt_4733_a2_x2 0 4072 1 1964 1963 a2_x2
xsubckt_5438_mx3_x2 1 0 3470 703 653 3861 3471 3475 mx3_x2
xsubckt_6183_mx2_x2 0 2834 1 840 1788 1756 mx2_x2
xsubckt_6185_mx2_x2 0 2832 1 8215 2833 2836 mx2_x2
xsubckt_6187_mx2_x2 0 2830 1 840 1180 1084 mx2_x2
xsubckt_6576_mx2_x2 0 2452 1 840 1840 1808 mx2_x2
xsubckt_6578_mx2_x2 0 2450 1 840 1712 1680 mx2_x2
xsubckt_6992_a3_x2 1 8712 0 8713 8714 8794 a3_x2
xsubckt_7914_sff1_x4 1 2192 0 10438 1796 sff1_x4
xsubckt_7988_sff1_x4 1 2203 0 10369 1788 sff1_x4
xsubckt_8365_sff1_x4 1 2235 0 9992 1477 sff1_x4
xsubckt_8888_sff1_x4 1 2050 0 9537 347 sff1_x4
xfeed_189 1 0 decap_w0
xfeed_188 1 0 decap_w0
xfeed_187 1 0 decap_w0
xfeed_186 1 0 tie
xfeed_185 1 0 decap_w0
xfeed_184 1 0 decap_w0
xfeed_183 1 0 decap_w0
xfeed_182 1 0 tie
xfeed_181 1 0 decap_w0
xfeed_180 1 0 decap_w0
xsubckt_440_nor2_x0 1 0 7898 646 645 nor2_x0
xsubckt_3790_nand3_x0 1 0 4584 4609 4613 8013 nand3_x0
xsubckt_4773_a2_x2 0 4042 1 4043 4049 a2_x2
xsubckt_4891_nxr2_x1 3954 1 0 3958 8355 nxr2_x1
xsubckt_4903_mx3_x2 1 0 3946 6448 547 8367 8203 8204 mx3_x2
xsubckt_5101_o2_x2 0 9834 1 3784 3797 o2_x2
xsubckt_5240_nor2_x0 1 0 3654 3655 3656 nor2_x0
xsubckt_5394_mx3_x2 1 0 3511 702 652 3871 3512 3515 mx3_x2
xsubckt_5652_mx2_x2 0 3321 1 806 1770 1738 mx2_x2
xsubckt_5654_mx2_x2 0 3319 1 806 1834 1802 mx2_x2
xsubckt_6189_mx2_x2 0 2828 1 839 988 956 mx2_x2
xsubckt_6865_a2_x2 0 8807 1 395 394 a2_x2
xsubckt_6939_ao22_x2 0 8755 1 707 8279 615 ao22_x2
xsubckt_7316_ao22_x2 0 9493 1 8530 8528 8527 ao22_x2
xsubckt_8722_sff1_x4 1 2179 0 2294 2262 sff1_x4
xsubckt_9173_sff1_x4 1 2132 0 9267 1391 sff1_x4
xcmpt_abc_30082_new_n5597_hfns_2 1 0 6072 6069 buf_x4
xcmpt_abc_30082_new_n5597_hfns_1 1 0 6069 6070 buf_x4
xcmpt_abc_30082_new_n5597_hfns_0 1 0 6069 6071 buf_x4
xspare_feed_229 1 0 decap_w0
xspare_feed_228 1 0 decap_w0
xspare_feed_227 1 0 decap_w0
xspare_feed_226 1 0 decap_w0
xspare_feed_225 1 0 decap_w0
xspare_feed_224 1 0 decap_w0
xspare_feed_223 1 0 decap_w0
xspare_feed_222 1 0 decap_w0
xspare_feed_221 1 0 decap_w0
xspare_feed_220 1 0 decap_w0
xsubckt_1399_nxr2_x1 6966 1 0 468 249 nxr2_x1
xsubckt_1056_o2_x2 0 7302 1 750 75 o2_x2
xsubckt_3033_nxr2_x1 5329 1 0 245 764 nxr2_x1
xsubckt_3072_oa22_x2 0 5290 1 5291 5292 775 oa22_x2
xsubckt_4694_ao22_x2 0 4101 1 1973 4106 52 ao22_x2
xsubckt_4813_nxr2_x1 4011 1 0 4013 8339 nxr2_x1
xsubckt_4907_mx3_x2 1 0 3943 6448 546 8368 8201 8202 mx3_x2
xsubckt_5020_nand2_x0 1 0 3858 3859 3951 nand2_x0
xsubckt_5181_o2_x2 0 3709 1 3710 3712 o2_x2
xsubckt_5415_o2_x2 0 9812 1 3492 3509 o2_x2
xsubckt_5656_mx2_x2 0 3317 1 789 3318 3319 mx2_x2
xsubckt_5658_mx2_x2 0 3315 1 805 970 938 mx2_x2
xsubckt_7655_nand4_x0 1 0 8455 6306 6310 6312 551 nand4_x0
xsubckt_8273_sff1_x4 1 2248 0 10084 1311 sff1_x4
xsubckt_8718_sff1_x4 1 2079 0 2320 2288 sff1_x4
xsubckt_8796_sff1_x4 1 2079 0 9626 723 sff1_x4
xfeed_199 1 0 tie
xfeed_198 1 0 decap_w0
xfeed_197 1 0 tie
xfeed_196 1 0 decap_w0
xfeed_195 1 0 decap_w0
xfeed_194 1 0 tie
xfeed_193 1 0 decap_w0
xfeed_192 1 0 decap_w0
xfeed_191 1 0 tie
xfeed_190 1 0 tie
xsubckt_1858_nand2_x0 1 0 6530 6531 227 nand2_x0
xsubckt_453_nand4_x0 1 0 7878 1894 643 52 8404 nand4_x0
xsubckt_1169_xr2_x1 7195 0 1 743 68 xr2_x1
xsubckt_4341_mx2_x2 0 10218 1 4191 6244 1447 mx2_x2
xsubckt_8269_sff1_x4 1 2235 0 10088 1285 sff1_x4
xsubckt_8630_sff1_x4 1 2159 0 178 115 sff1_x4
xsubckt_9081_sff1_x4 1 2063 0 10461 1907 sff1_x4
xsubckt_9169_sff1_x4 1 2145 0 9271 1395 sff1_x4
xcmpt_abc_30082_new_n3404_hfns_3 1 0 8296 8292 buf_x4
xcmpt_abc_30082_new_n3404_hfns_2 1 0 8292 8293 buf_x4
xcmpt_abc_30082_new_n3404_hfns_1 1 0 8292 8294 buf_x4
xcmpt_abc_30082_new_n3404_hfns_0 1 0 8292 8295 buf_x4
xspare_feed_239 1 0 decap_w0
xspare_feed_238 1 0 decap_w0
xspare_feed_237 1 0 decap_w0
xspare_feed_236 1 0 decap_w0
xspare_feed_235 1 0 decap_w0
xspare_feed_234 1 0 decap_w0
xspare_feed_233 1 0 decap_w0
xspare_feed_232 1 0 decap_w0
xspare_feed_231 1 0 decap_w0
xspare_feed_230 1 0 decap_w0
xsubckt_1931_nand2_x0 1 0 6468 7810 211 nand2_x0
xsubckt_1559_ao22_x2 0 6809 1 615 6812 8055 ao22_x2
xsubckt_630_nand2_x0 1 0 7710 7712 7714 nand2_x0
xsubckt_806_nand3_x0 1 0 7539 7540 7541 1903 nand3_x0
xsubckt_2617_oa22_x2 0 5737 1 7905 5744 5738 oa22_x2
xsubckt_3605_nand2_x0 1 0 4766 4767 783 nand2_x0
xsubckt_4347_mx2_x2 0 10212 1 4191 6189 1471 mx2_x2
xsubckt_4349_mx2_x2 0 10210 1 4191 6170 1469 mx2_x2
xsubckt_6946_nand3_x0 1 0 8749 578 8245 701 nand3_x0
xsubckt_8103_sff1_x4 1 2132 0 10254 1239 sff1_x4
xsubckt_8181_sff1_x4 1 2203 0 10176 1723 sff1_x4
xsubckt_8626_sff1_x4 1 2159 0 182 119 sff1_x4
xsubckt_9003_sff1_x4 1 2066 0 10452 822 sff1_x4
xcmpt_is_jalr_addi_slti_sltiu_xori_ori_andi_hfns_2 1 0 575 572 buf_x4
xcmpt_is_jalr_addi_slti_sltiu_xori_ori_andi_hfns_1 1 0 572 573 buf_x4
xcmpt_is_jalr_addi_slti_sltiu_xori_ori_andi_hfns_0 1 0 572 574 buf_x4
xsubckt_1498_nand2_x0 1 0 6866 6868 6872 nand2_x0
xsubckt_2723_nand2_x0 1 0 5633 6007 8110 nand2_x0
xsubckt_3423_mx2_x2 0 4945 1 804 1145 1113 mx2_x2
xsubckt_3515_nand2_x0 1 0 4855 4858 4861 nand2_x0
xsubckt_3624_ao22_x2 0 4747 1 4796 4795 4748 ao22_x2
xsubckt_6856_nand3_x0 1 0 8814 395 8259 393 nand3_x0
xsubckt_8177_sff1_x4 1 2222 0 10180 1727 sff1_x4
xsubckt_9077_sff1_x4 1 2063 0 10465 1911 sff1_x4
xsubckt_9434_sff1_x4 1 2112 0 9009 909 sff1_x4
xspare_feed_246 1 0 decap_w0
xspare_feed_245 1 0 decap_w0
xspare_feed_244 1 0 decap_w0
xspare_feed_243 1 0 decap_w0
xspare_feed_242 1 0 decap_w0
xspare_feed_241 1 0 decap_w0
xspare_feed_240 1 0 decap_w0
xsubckt_2719_nand3_x0 1 0 5637 5642 5646 770 nand3_x0
xsubckt_3038_mx2_x2 0 5324 1 810 991 959 mx2_x2
xsubckt_3425_nand2_x0 1 0 4943 4944 782 nand2_x0
xsubckt_3427_mx2_x2 0 4941 1 810 1305 1273 mx2_x2
xsubckt_3770_mx2_x2 0 4604 1 803 914 882 mx2_x2
xsubckt_3772_mx2_x2 0 4602 1 8031 4603 4604 mx2_x2
xsubckt_3818_mx2_x2 0 4557 1 803 977 945 mx2_x2
xsubckt_5080_nxr2_x1 3803 1 0 3937 725 nxr2_x1
xsubckt_5575_nor2_x0 1 0 9766 3378 3379 nor2_x0
xsubckt_6464_oa22_x2 0 2560 1 3191 2563 2561 oa22_x2
xsubckt_7128_ao22_x2 0 8648 1 8649 8655 3286 ao22_x2
xsubckt_7283_nor2_x0 1 0 8553 8554 8555 nor2_x0
xsubckt_7382_nand2_x0 1 0 8496 4165 4182 nand2_x0
xsubckt_8011_sff1_x4 1 2217 0 10346 1127 sff1_x4
xsubckt_8534_sff1_x4 1 2176 0 9823 146 sff1_x4
xspare_feed_249 1 0 decap_w0
xspare_feed_248 1 0 decap_w0
xspare_feed_247 1 0 decap_w0
xsubckt_2453_nand2_x0 1 0 5898 767 216 nand2_x0
xsubckt_2112_mx2_x2 0 6335 1 830 6336 6339 mx2_x2
xsubckt_2110_mx2_x2 0 6337 1 864 1641 1609 mx2_x2
xsubckt_234_inv_x0 1 0 2041 8142 inv_x0
xsubckt_232_inv_x0 1 0 323 8144 inv_x0
xsubckt_230_inv_x0 1 0 325 8146 inv_x0
xsubckt_2956_oa22_x2 0 5404 1 5405 5406 8017 oa22_x2
xsubckt_3245_nand2_x0 1 0 5120 5121 780 nand2_x0
xsubckt_3774_mx2_x2 0 4600 1 808 1490 1458 mx2_x2
xsubckt_3776_mx2_x2 0 4598 1 8031 4599 4600 mx2_x2
xsubckt_3778_mx2_x2 0 4596 1 808 1650 1618 mx2_x2
xsubckt_5076_nxr2_x1 3807 1 0 3820 3937 nxr2_x1
xsubckt_6792_nor3_x0 1 0 8863 6953 6954 8420 nor3_x0
xsubckt_6909_oa22_x2 0 8777 1 8785 8779 8780 oa22_x2
xsubckt_7084_mx3_x2 1 0 9591 8668 6288 1510 6236 6240 mx3_x2
xsubckt_7114_nand2_x0 1 0 8660 8661 7969 nand2_x0
xsubckt_7292_nand2_x0 1 0 8546 374 564 nand2_x0
xsubckt_8085_sff1_x4 1 2203 0 10272 1179 sff1_x4
xsubckt_9342_sff1_x4 1 2116 0 9101 994 sff1_x4
xspare_feed_253 1 0 decap_w0
xspare_feed_252 1 0 decap_w0
xspare_feed_251 1 0 decap_w0
xspare_feed_250 1 0 decap_w0
xsubckt_2449_nand3_x0 1 0 5902 5903 5904 776 nand3_x0
xsubckt_2363_nand2_x0 1 0 5997 7911 1894 nand2_x0
xsubckt_2118_mx2_x2 0 6329 1 843 905 873 mx2_x2
xsubckt_2116_mx2_x2 0 6331 1 8225 6332 6333 mx2_x2
xsubckt_2114_mx2_x2 0 6333 1 843 1769 1737 mx2_x2
xsubckt_2070_mx2_x2 0 6376 1 843 1580 1548 mx2_x2
xsubckt_238_inv_x0 1 0 421 8138 inv_x0
xsubckt_236_inv_x0 1 0 422 8140 inv_x0
xsubckt_190_inv_x0 1 0 120 8186 inv_x0
xsubckt_637_o3_x2 0 7703 1 405 330 328 o3_x2
xsubckt_709_nand2_x0 1 0 7634 630 1944 nand2_x0
xsubckt_3155_nand2_x0 1 0 5209 5212 5215 nand2_x0
xsubckt_4141_oa22_x2 0 4239 1 4240 4241 775 oa22_x2
xsubckt_5433_nxr2_x1 3475 1 0 3489 3861 nxr2_x1
xsubckt_7010_nand4_x0 1 0 8696 8697 8712 8715 8724 nand4_x0
xsubckt_7086_mx3_x2 1 0 9589 8668 6288 1508 6215 6219 mx3_x2
xsubckt_7088_mx3_x2 1 0 9587 8668 6288 1536 6196 6200 mx3_x2
xsubckt_7346_mx2_x2 0 9487 1 8832 8503 767 mx2_x2
xsubckt_7691_mx2_x2 0 9133 1 8448 6277 1026 mx2_x2
xsubckt_7737_mx2_x2 0 9089 1 8443 6179 990 mx2_x2
xsubckt_7739_mx2_x2 0 9087 1 8443 6162 988 mx2_x2
xsubckt_8007_sff1_x4 1 2142 0 10350 1143 sff1_x4
xsubckt_8442_sff1_x4 1 2047 0 9915 1964 sff1_x4
xsubckt_8965_sff1_x4 1 2132 0 9460 1584 sff1_x4
xfeed_309 1 0 decap_w0
xfeed_308 1 0 decap_w0
xfeed_307 1 0 tie
xfeed_306 1 0 decap_w0
xfeed_305 1 0 tie
xfeed_304 1 0 decap_w0
xfeed_303 1 0 tie
xfeed_302 1 0 decap_w0
xfeed_301 1 0 decap_w0
xfeed_300 1 0 decap_w0
xspare_feed_259 1 0 decap_w0
xspare_feed_258 1 0 decap_w0
xspare_feed_257 1 0 decap_w0
xspare_feed_256 1 0 decap_w0
xspare_feed_255 1 0 decap_w0
xspare_feed_254 1 0 decap_w0
xsubckt_2074_mx2_x2 0 6372 1 828 6373 6380 mx2_x2
xsubckt_2072_mx2_x2 0 6374 1 834 6375 6376 mx2_x2
xsubckt_1730_nand3_x0 1 0 6650 6677 8042 8043 nand3_x0
xsubckt_1299_a4_x2 0 7066 1 7067 7071 7076 7080 a4_x2
xsubckt_192_inv_x0 1 0 119 8184 inv_x0
xsubckt_194_inv_x0 1 0 118 8182 inv_x0
xsubckt_196_inv_x0 1 0 117 8180 inv_x0
xsubckt_619_nand2_x0 1 0 7720 2012 637 nand2_x0
xsubckt_1123_nand2_x0 1 0 7238 630 1920 nand2_x0
xsubckt_2465_mx2_x2 0 10414 1 5995 5887 216 mx2_x2
xsubckt_2467_mx2_x2 0 5885 1 811 1847 1815 mx2_x2
xsubckt_2612_nand3_x0 1 0 5742 5743 5892 6392 nand3_x0
xsubckt_3065_nand2_x0 1 0 5297 5298 784 nand2_x0
xsubckt_4102_a2_x2 0 4278 1 225 744 a2_x2
xsubckt_4110_nand2_x0 1 0 4270 4271 784 nand2_x0
xsubckt_4690_a4_x2 0 4105 1 4107 4117 4143 1973 a4_x2
xsubckt_4729_a4_x2 0 4074 1 4078 4088 4143 1964 a4_x2
xsubckt_5257_a3_x2 1 3639 0 45 145 8398 a3_x2
xsubckt_5432_a3_x2 1 3476 0 45 8398 131 a3_x2
xsubckt_5452_a3_x2 1 3462 0 3465 1996 2007 a3_x2
xsubckt_5479_nor2_x0 1 0 3443 3446 2036 nor2_x0
xsubckt_6420_mx2_x2 0 2603 1 840 1493 1461 mx2_x2
xsubckt_6422_mx2_x2 0 2601 1 8226 2602 2603 mx2_x2
xsubckt_6424_mx2_x2 0 2599 1 826 2600 2607 mx2_x2
xsubckt_6811_mx2_x2 0 8848 1 8852 8849 558 mx2_x2
xsubckt_6813_mx2_x2 0 9421 1 7917 430 398 mx2_x2
xsubckt_6815_mx2_x2 0 8847 1 7917 8234 8235 mx2_x2
xsubckt_7055_a3_x2 1 8682 0 8842 8843 8844 a3_x2
xsubckt_7693_mx2_x2 0 9131 1 8449 6266 1004 mx2_x2
xsubckt_7695_mx2_x2 0 9129 1 8449 6252 1000 mx2_x2
xsubckt_8438_sff1_x4 1 2047 0 9919 1969 sff1_x4
xsubckt_9250_sff1_x4 1 2235 0 9190 1413 sff1_x4
xsubckt_9338_sff1_x4 1 2063 0 10460 331 sff1_x4
xcmpt_abc_30082_new_n10365_hfns_0 1 0 8664 8666 buf_x4
xspare_feed_260 1 0 decap_w0
xsubckt_2276_a3_x2 1 6112 0 6113 541 8409 a3_x2
xsubckt_2210_nxr2_x1 6198 1 0 6212 8365 nxr2_x1
xsubckt_2078_mx2_x2 0 6368 1 844 1836 1804 mx2_x2
xsubckt_2076_mx2_x2 0 6370 1 844 1708 1676 mx2_x2
xsubckt_529_nand2_x0 1 0 10461 7812 7813 nand2_x0
xsubckt_198_inv_x0 1 0 116 8178 inv_x0
xsubckt_1006_oa22_x2 0 7349 1 7614 7478 7350 oa22_x2
xsubckt_2469_mx2_x2 0 5883 1 790 5884 5885 mx2_x2
xsubckt_3314_nand3_x0 1 0 5052 5057 5061 772 nand3_x0
xsubckt_3633_nxr2_x1 4739 1 0 234 753 nxr2_x1
xsubckt_3672_oa22_x2 0 4700 1 4701 4702 776 oa22_x2
xsubckt_4771_ao22_x2 0 9904 1 4044 4045 44 ao22_x2
xsubckt_5051_a2_x2 0 3830 1 3942 727 a2_x2
xsubckt_6035_mx2_x2 0 2978 1 844 928 896 mx2_x2
xsubckt_6037_mx2_x2 0 2976 1 8219 2977 2978 mx2_x2
xsubckt_6380_mx2_x2 0 2642 1 8212 2643 2646 mx2_x2
xsubckt_6771_mx2_x2 0 8883 1 842 1290 1258 mx2_x2
xsubckt_6773_mx2_x2 0 8881 1 842 1226 1194 mx2_x2
xsubckt_6817_mx2_x2 0 8846 1 7917 8236 8237 mx2_x2
xsubckt_7301_ao22_x2 0 9496 1 8542 8540 8539 ao22_x2
xsubckt_7973_sff1_x4 1 2097 0 10384 1795 sff1_x4
xsubckt_8350_sff1_x4 1 2137 0 10007 1329 sff1_x4
xsubckt_8873_sff1_x4 1 2076 0 9552 333 sff1_x4
xfeed_319 1 0 decap_w0
xfeed_318 1 0 decap_w0
xfeed_317 1 0 decap_w0
xfeed_316 1 0 decap_w0
xfeed_315 1 0 tie
xfeed_314 1 0 decap_w0
xfeed_313 1 0 decap_w0
xfeed_312 1 0 decap_w0
xfeed_311 1 0 tie
xfeed_310 1 0 tie
xcmpt_abc_30082_new_n10365_hfns_2 1 0 8667 8664 buf_x4
xcmpt_abc_30082_new_n10365_hfns_1 1 0 8664 8665 buf_x4
xspare_feed_269 1 0 decap_w0
xspare_feed_268 1 0 decap_w0
xspare_feed_267 1 0 decap_w0
xspare_feed_266 1 0 decap_w0
xspare_feed_265 1 0 decap_w0
xspare_feed_264 1 0 decap_w0
xspare_feed_263 1 0 decap_w0
xspare_feed_262 1 0 decap_w0
xspare_feed_261 1 0 decap_w0
xsubckt_2169_a2_x2 0 6270 1 81 70 a2_x2
xsubckt_1833_nxr2_x1 6553 1 0 6557 229 nxr2_x1
xsubckt_1435_a2_x2 0 6925 1 6926 8416 a2_x2
xsubckt_580_oa22_x2 0 7758 1 7801 7804 8138 oa22_x2
xsubckt_780_nand2_x0 1 0 185 7564 7577 nand2_x0
xsubckt_980_o2_x2 0 7374 1 754 79 o2_x2
xsubckt_2677_xr2_x1 5679 0 1 221 740 xr2_x1
xsubckt_3742_a2_x2 0 4631 1 4632 4634 a2_x2
xsubckt_3845_nand2_x0 1 0 4530 4531 783 nand2_x0
xsubckt_4106_nand3_x0 1 0 4274 567 8290 69 nand3_x0
xsubckt_5113_mx2_x2 0 3772 1 8278 3773 3931 mx2_x2
xsubckt_5619_a2_x2 0 9753 1 3347 43 a2_x2
xsubckt_6039_mx2_x2 0 2974 1 854 1792 1760 mx2_x2
xsubckt_6382_mx2_x2 0 2640 1 854 1590 1558 mx2_x2
xsubckt_6384_mx2_x2 0 2638 1 854 1494 1462 mx2_x2
xsubckt_6386_mx2_x2 0 2636 1 8219 2637 2638 mx2_x2
xsubckt_6775_mx2_x2 0 8879 1 8219 8880 8881 mx2_x2
xsubckt_6777_mx2_x2 0 8877 1 854 1642 1610 mx2_x2
xsubckt_6779_mx2_x2 0 8875 1 8219 8876 8877 mx2_x2
xsubckt_8346_sff1_x4 1 2217 0 10011 1333 sff1_x4
xsubckt_8869_sff1_x4 1 2070 0 9556 337 sff1_x4
xsubckt_9246_sff1_x4 1 2136 0 9194 1417 sff1_x4
xsubckt_2206_nxr2_x1 6207 1 0 6222 8364 nxr2_x1
xsubckt_1903_nand2_x0 1 0 6491 192 327 nand2_x0
xsubckt_1749_a2_x2 0 6632 1 6633 8415 a2_x2
xsubckt_1690_a2_x2 0 6687 1 6688 239 a2_x2
xsubckt_502_oa22_x2 0 7834 1 7945 7952 8272 oa22_x2
xsubckt_690_nand2_x0 1 0 7652 2009 638 nand2_x0
xsubckt_776_nand3_x0 1 0 7567 7568 7569 7570 nand3_x0
xsubckt_3134_nand3_x0 1 0 5229 5234 5238 770 nand3_x0
xsubckt_3665_nand2_x0 1 0 4707 4708 783 nand2_x0
xsubckt_3755_nand2_x0 1 0 4619 4622 4625 nand2_x0
xsubckt_4925_oa22_x2 0 9864 1 7884 3930 3932 oa22_x2
xsubckt_6388_mx2_x2 0 2634 1 826 2635 2642 mx2_x2
xsubckt_7969_sff1_x4 1 2092 0 10388 229 sff1_x4
xsubckt_8703_sff1_x4 1 2086 0 9687 201 sff1_x4
xsubckt_8781_sff1_x4 1 2070 0 9641 613 sff1_x4
xfeed_329 1 0 tie
xfeed_328 1 0 decap_w0
xfeed_327 1 0 decap_w0
xfeed_326 1 0 decap_w0
xfeed_325 1 0 decap_w0
xfeed_324 1 0 decap_w0
xfeed_323 1 0 decap_w0
xfeed_322 1 0 decap_w0
xfeed_321 1 0 decap_w0
xfeed_320 1 0 decap_w0
xspare_feed_279 1 0 decap_w0
xspare_feed_278 1 0 decap_w0
xspare_feed_277 1 0 decap_w0
xspare_feed_276 1 0 decap_w0
xspare_feed_275 1 0 decap_w0
xspare_feed_274 1 0 decap_w0
xspare_feed_273 1 0 decap_w0
xspare_feed_272 1 0 decap_w0
xspare_feed_271 1 0 decap_w0
xspare_feed_270 1 0 decap_w0
xsubckt_1829_nxr2_x1 6557 1 0 6558 8050 nxr2_x1
xsubckt_1228_o2_x2 0 7137 1 202 234 o2_x2
xsubckt_1208_o2_x2 0 7157 1 198 230 o2_x2
xsubckt_576_oa22_x2 0 186 1 7776 7774 7762 oa22_x2
xsubckt_4730_nor3_x0 1 0 9915 4074 4075 8305 nor3_x0
xsubckt_5210_oa22_x2 0 3682 1 3684 3686 8295 oa22_x2
xsubckt_5245_nxr2_x1 3650 1 0 3663 3901 nxr2_x1
xsubckt_5249_nand2_x0 1 0 3646 3901 8263 nand2_x0
xsubckt_5295_nor2_x0 1 0 3603 3604 3606 nor2_x0
xsubckt_5733_oa22_x2 0 3269 1 3270 7834 8287 oa22_x2
xsubckt_5855_mx2_x2 0 3153 1 865 903 871 mx2_x2
xsubckt_5857_mx2_x2 0 3151 1 8220 3152 3153 mx2_x2
xsubckt_5859_mx2_x2 0 3149 1 865 1767 1735 mx2_x2
xsubckt_6067_o2_x2 0 2946 1 2947 7930 o2_x2
xsubckt_8254_sff1_x4 1 2109 0 10103 1681 sff1_x4
xsubckt_8777_sff1_x4 1 2070 0 9645 615 sff1_x4
xsubckt_9154_sff1_x4 1 2235 0 9286 1381 sff1_x4
xsubckt_2352_o2_x2 0 6014 1 618 619 o2_x2
xsubckt_1649_o3_x2 0 6725 1 6726 6727 6939 o3_x2
xsubckt_596_nand3_x0 1 0 7742 7743 7744 7745 nand3_x0
xsubckt_2602_oa22_x2 0 5752 1 5950 5753 5784 oa22_x2
xsubckt_2606_o2_x2 0 5748 1 223 742 o2_x2
xsubckt_2626_o2_x2 0 5729 1 222 741 o2_x2
xsubckt_2779_nand3_x0 1 0 5578 5596 5600 8013 nand3_x0
xsubckt_3395_nand2_x0 1 0 4973 4976 4979 nand2_x0
xsubckt_3485_nand2_x0 1 0 4884 4885 780 nand2_x0
xsubckt_3576_oa22_x2 0 4795 1 4798 4803 7907 oa22_x2
xsubckt_4263_nand4_x0 1 0 4205 6306 6309 8007 555 nand4_x0
xsubckt_4540_mx2_x2 0 10033 1 4162 6017 1642 mx2_x2
xsubckt_4780_nxr2_x1 4036 1 0 4039 8332 nxr2_x1
xsubckt_6106_oa22_x2 0 2909 1 54 1906 211 oa22_x2
xsubckt_6751_o2_x2 0 8902 1 8903 7931 o2_x2
xsubckt_7264_nand2_x0 1 0 8568 8569 8577 nand2_x0
xsubckt_8611_sff1_x4 1 2044 0 9746 1981 sff1_x4
xsubckt_9062_sff1_x4 1 2238 0 9368 1364 sff1_x4
xfeed_339 1 0 decap_w0
xfeed_338 1 0 decap_w0
xfeed_337 1 0 decap_w0
xfeed_336 1 0 decap_w0
xfeed_335 1 0 decap_w0
xfeed_334 1 0 decap_w0
xfeed_333 1 0 decap_w0
xfeed_332 1 0 tie
xfeed_331 1 0 tie
xfeed_330 1 0 decap_w0
xspare_feed_289 1 0 decap_w0
xspare_feed_288 1 0 decap_w0
xspare_feed_287 1 0 decap_w0
xspare_feed_286 1 0 decap_w0
xspare_feed_285 1 0 decap_w0
xspare_feed_284 1 0 decap_w0
xspare_feed_283 1 0 decap_w0
xspare_feed_282 1 0 decap_w0
xspare_feed_281 1 0 decap_w0
xspare_feed_280 1 0 decap_w0
xsubckt_1776_oa22_x2 0 6607 1 6629 6615 6616 oa22_x2
xsubckt_1453_nand2_x0 1 0 6908 7046 7971 nand2_x0
xsubckt_3734_nand3_x0 1 0 4639 4644 4648 772 nand3_x0
xsubckt_4153_mx2_x2 0 10385 1 5994 4228 225 mx2_x2
xsubckt_4157_mx2_x2 0 10384 1 4224 6282 1795 mx2_x2
xsubckt_4544_mx2_x2 0 10031 1 4156 6277 1346 mx2_x2
xsubckt_4546_mx2_x2 0 10029 1 4156 6265 1324 mx2_x2
xsubckt_4548_mx2_x2 0 10027 1 4156 6252 1320 mx2_x2
xsubckt_5206_oa22_x2 0 3686 1 3700 3698 3699 oa22_x2
xsubckt_7174_nand2_x0 1 0 8634 8635 8637 nand2_x0
xsubckt_8162_sff1_x4 1 2113 0 10195 1453 sff1_x4
xsubckt_8685_sff1_x4 1 2169 0 9705 441 sff1_x4
xsubckt_2245_nand2_x0 1 0 6153 6154 6158 nand2_x0
xsubckt_1363_nand2_x0 1 0 7002 207 8097 nand2_x0
xsubckt_841_oa22_x2 0 7506 1 7525 7524 7523 oa22_x2
xsubckt_3231_mx2_x2 0 5134 1 815 1852 1820 mx2_x2
xsubckt_4159_mx2_x2 0 10382 1 4224 6272 1783 mx2_x2
xsubckt_5199_nor2_x0 1 0 3692 3693 7881 nor2_x0
xsubckt_5318_nand3_x0 1 0 3582 3594 3604 3606 nand3_x0
xsubckt_6972_oa22_x2 0 8730 1 8244 701 8418 oa22_x2
xsubckt_6979_nor2_x0 1 0 8725 382 381 nor2_x0
xsubckt_8607_sff1_x4 1 2044 0 9750 1986 sff1_x4
xsubckt_9058_sff1_x4 1 2238 0 9372 1369 sff1_x4
xsubckt_9493_sff1_x4 1 2145 0 8950 1842 sff1_x4
xfeed_349 1 0 decap_w0
xfeed_348 1 0 decap_w0
xfeed_347 1 0 decap_w0
xfeed_346 1 0 decap_w0
xfeed_345 1 0 decap_w0
xfeed_344 1 0 decap_w0
xfeed_343 1 0 decap_w0
xfeed_342 1 0 decap_w0
xfeed_341 1 0 decap_w0
xfeed_340 1 0 decap_w0
xspare_feed_299 1 0 decap_w0
xspare_feed_298 1 0 decap_w0
xspare_feed_297 1 0 decap_w0
xspare_feed_296 1 0 decap_w0
xspare_feed_295 1 0 decap_w0
xspare_feed_294 1 0 decap_w0
xspare_feed_293 1 0 decap_w0
xspare_feed_292 1 0 decap_w0
xspare_feed_291 1 0 decap_w0
xspare_feed_290 1 0 decap_w0
xsubckt_1684_oa22_x2 0 6693 1 6715 6702 6703 oa22_x2
xsubckt_1183_nand2_x0 1 0 7181 7182 7190 nand2_x0
xsubckt_932_nand2_x0 1 0 7419 7991 2031 nand2_x0
xsubckt_1005_nand2_x0 1 0 7350 7351 1895 nand2_x0
xsubckt_3200_nand2_x0 1 0 5164 6012 8105 nand2_x0
xsubckt_3235_mx2_x2 0 5130 1 815 1436 1404 mx2_x2
xsubckt_3554_nand3_x0 1 0 4816 4821 4825 770 nand3_x0
xsubckt_3580_mx2_x2 0 4791 1 791 4792 4793 mx2_x2
xsubckt_5052_nand2_x0 1 0 3829 3943 8252 nand2_x0
xsubckt_5584_nxr2_x1 3371 1 0 3375 8104 nxr2_x1
xsubckt_7000_a4_x2 0 8704 1 8705 8258 394 8261 a4_x2
xsubckt_7187_ao22_x2 0 9525 1 8624 8625 8626 ao22_x2
xsubckt_8070_sff1_x4 1 2106 0 10287 1186 sff1_x4
xsubckt_8158_sff1_x4 1 2116 0 10199 1457 sff1_x4
xsubckt_8515_sff1_x4 1 2153 0 9842 69 sff1_x4
xsubckt_8593_sff1_x4 1 2057 0 9764 2001 sff1_x4
xsubckt_9415_sff1_x4 1 2192 0 9028 929 sff1_x4
xsubckt_695_a2_x2 0 7647 1 7648 7656 a2_x2
xsubckt_870_a2_x2 0 7478 1 7479 7618 a2_x2
xsubckt_2700_mx2_x2 0 5656 1 817 1415 1383 mx2_x2
xsubckt_2704_mx2_x2 0 5652 1 817 1575 1543 mx2_x2
xsubckt_3239_mx2_x2 0 5126 1 817 1596 1564 mx2_x2
xsubckt_3374_nand3_x0 1 0 4993 4998 5002 771 nand3_x0
xsubckt_3582_mx2_x2 0 4789 1 817 1877 1525 mx2_x2
xsubckt_3584_mx2_x2 0 4787 1 8036 4788 4789 mx2_x2
xsubckt_3586_mx2_x2 0 4785 1 816 1717 1685 mx2_x2
xsubckt_5506_nxr2_x1 3425 1 0 3427 8089 nxr2_x1
xsubckt_7150_mx2_x2 0 9545 1 8643 461 356 mx2_x2
xsubckt_7541_mx2_x2 0 9272 1 8474 6098 1396 mx2_x2
xsubckt_7543_mx2_x2 0 9270 1 8474 6081 1394 mx2_x2
xsubckt_8589_sff1_x4 1 2060 0 9768 2005 sff1_x4
xsubckt_8950_sff1_x4 1 2229 0 9475 1600 sff1_x4
xsubckt_9489_sff1_x4 1 2215 0 8954 1846 sff1_x4
xfeed_359 1 0 decap_w0
xfeed_358 1 0 decap_w0
xfeed_357 1 0 tie
xfeed_356 1 0 decap_w0
xfeed_355 1 0 decap_w0
xfeed_354 1 0 decap_w0
xfeed_353 1 0 decap_w0
xfeed_352 1 0 decap_w0
xfeed_351 1 0 decap_w0
xfeed_350 1 0 tie
xsubckt_2359_nor4_x0 1 0 6001 1897 1908 1893 1905 nor4_x0
xsubckt_2317_mx2_x2 0 6059 1 546 104 2268 mx2_x2
xsubckt_1963_nand2_x0 1 0 6453 7809 194 nand2_x0
xsubckt_1879_ao22_x2 0 6510 1 6513 6519 6940 ao22_x2
xsubckt_662_nand2_x0 1 0 7679 7680 7682 nand2_x0
xsubckt_1157_oa22_x2 0 7206 1 7614 7478 7207 oa22_x2
xsubckt_2660_mx2_x2 0 5695 1 776 5696 5703 mx2_x2
xsubckt_2708_mx2_x2 0 5648 1 819 1127 1095 mx2_x2
xsubckt_3194_nand3_x0 1 0 5170 5175 5179 772 nand3_x0
xsubckt_3588_mx2_x2 0 4783 1 790 4784 4785 mx2_x2
xsubckt_5022_oa22_x2 0 9840 1 3857 3858 3860 oa22_x2
xsubckt_7017_ao22_x2 0 8690 1 8691 8693 8695 ao22_x2
xsubckt_7063_nand3_x0 1 0 8676 8245 703 8297 nand3_x0
xsubckt_7152_mx2_x2 0 9543 1 8643 459 354 mx2_x2
xsubckt_7154_mx2_x2 0 9541 1 8643 457 352 mx2_x2
xsubckt_7156_mx2_x2 0 9539 1 8643 454 349 mx2_x2
xsubckt_7253_oa22_x2 0 8577 1 8607 8687 8269 oa22_x2
xsubckt_7545_mx2_x2 0 9268 1 8475 6062 1392 mx2_x2
xsubckt_7547_mx2_x2 0 9266 1 8475 6044 1390 mx2_x2
xsubckt_7549_mx2_x2 0 9264 1 8475 6027 1387 mx2_x2
xsubckt_8066_sff1_x4 1 2112 0 10291 1741 sff1_x4
xsubckt_8423_sff1_x4 1 2057 0 9934 1976 sff1_x4
xsubckt_8946_sff1_x4 1 2235 0 9479 1574 sff1_x4
xsubckt_9323_sff1_x4 1 2242 0 9117 1018 sff1_x4
xsubckt_2275_mx2_x2 0 6113 1 546 110 2274 mx2_x2
xsubckt_2174_a3_x2 1 6263 0 81 70 67 a3_x2
xsubckt_1407_nor3_x0 1 0 6958 6963 6969 8038 nor3_x0
xsubckt_572_nand2_x0 1 0 7765 767 92 nand2_x0
xsubckt_5409_a3_x2 1 3497 0 3498 3500 3502 a3_x2
xsubckt_6230_mx2_x2 0 2788 1 848 1371 1339 mx2_x2
xsubckt_6232_mx2_x2 0 2786 1 8226 2787 2788 mx2_x2
xsubckt_6621_mx2_x2 0 2408 1 849 975 943 mx2_x2
xsubckt_6623_mx2_x2 0 2406 1 832 2407 2408 mx2_x2
xsubckt_7158_mx2_x2 0 9537 1 8643 452 347 mx2_x2
xsubckt_8497_sff1_x4 1 2159 0 9860 89 sff1_x4
xsubckt_9319_sff1_x4 1 2245 0 9121 1022 sff1_x4
xsubckt_9397_sff1_x4 1 2145 0 9046 946 sff1_x4
xfeed_369 1 0 decap_w0
xfeed_368 1 0 decap_w0
xfeed_367 1 0 tie
xfeed_366 1 0 decap_w0
xfeed_365 1 0 decap_w0
xfeed_364 1 0 tie
xfeed_363 1 0 decap_w0
xfeed_362 1 0 decap_w0
xfeed_361 1 0 decap_w0
xfeed_360 1 0 decap_w0
xsubckt_482_nand2_x0 1 0 7852 700 653 nand2_x0
xsubckt_568_nand3_x0 1 0 7769 7770 7771 7772 nand3_x0
xsubckt_3800_nand2_x0 1 0 4574 6012 8087 nand2_x0
xsubckt_4030_oa22_x2 0 4348 1 4349 4350 776 oa22_x2
xsubckt_4040_a2_x2 0 4338 1 4339 4341 a2_x2
xsubckt_4910_a3_x2 1 3941 0 51 66 8398 a3_x2
xsubckt_4930_a3_x2 1 3926 0 52 91 8399 a3_x2
xsubckt_5028_a2_x2 0 3851 1 3948 710 a2_x2
xsubckt_6234_mx2_x2 0 2784 1 852 1147 1115 mx2_x2
xsubckt_6236_mx2_x2 0 2782 1 8211 2783 2786 mx2_x2
xsubckt_6238_mx2_x2 0 2780 1 853 1595 1563 mx2_x2
xsubckt_6581_mx2_x2 0 2447 1 8211 2448 2451 mx2_x2
xsubckt_6625_mx2_x2 0 2404 1 827 2405 2412 mx2_x2
xsubckt_6627_mx2_x2 0 2402 1 853 1295 1263 mx2_x2
xsubckt_6629_mx2_x2 0 2400 1 853 1231 1199 mx2_x2
xsubckt_8331_sff1_x4 1 2217 0 10026 1319 sff1_x4
xsubckt_8419_sff1_x4 1 2119 0 9938 1611 sff1_x4
xsubckt_8854_sff1_x4 1 2123 0 9571 1519 sff1_x4
xsubckt_9231_sff1_x4 1 2216 0 9209 1077 sff1_x4
xspare_feed_400 1 0 decap_w0
xcmpt_abc_30082_new_n5642_hfns_2 1 0 6013 6010 buf_x4
xcmpt_abc_30082_new_n5642_hfns_1 1 0 6010 6011 buf_x4
xcmpt_abc_30082_new_n5642_hfns_0 1 0 6010 6012 buf_x4
xsubckt_1515_nand2_x0 1 0 6850 6947 7058 nand2_x0
xsubckt_1425_nand2_x0 1 0 6934 6935 6938 nand2_x0
xsubckt_1393_a2_x2 0 6972 1 6973 6981 a2_x2
xsubckt_1210_xr2_x1 7155 0 1 198 230 xr2_x1
xsubckt_649_oa22_x2 0 7692 1 7714 7712 7713 oa22_x2
xsubckt_2516_a2_x2 0 5836 1 5837 5838 a2_x2
xsubckt_3620_nand2_x0 1 0 4751 6011 8092 nand2_x0
xsubckt_3974_nand3_x0 1 0 4403 4408 4412 771 nand3_x0
xsubckt_4823_a2_x2 0 4004 1 1940 1939 a2_x2
xsubckt_4950_a3_x2 1 3911 0 51 86 8397 a3_x2
xsubckt_4970_a3_x2 1 3896 0 51 80 8397 a3_x2
xsubckt_4990_a3_x2 1 3881 0 51 75 8397 a3_x2
xsubckt_5701_mx2_x2 0 9734 1 3282 497 534 mx2_x2
xsubckt_5703_mx2_x2 0 9732 1 3282 495 532 mx2_x2
xsubckt_5705_mx2_x2 0 9730 1 3282 493 530 mx2_x2
xsubckt_6190_mx2_x2 0 2827 1 851 1052 1020 mx2_x2
xsubckt_6192_mx2_x2 0 2825 1 8210 2826 2829 mx2_x2
xsubckt_6194_mx2_x2 0 2823 1 851 1372 1340 mx2_x2
xsubckt_6583_mx2_x2 0 2445 1 852 1168 1072 mx2_x2
xsubckt_6585_mx2_x2 0 2443 1 852 976 944 mx2_x2
xsubckt_7954_sff1_x4 1 2163 0 10403 245 sff1_x4
xsubckt_9227_sff1_x4 1 2222 0 9213 1082 sff1_x4
xfeed_379 1 0 tie
xfeed_378 1 0 decap_w0
xfeed_377 1 0 decap_w0
xfeed_376 1 0 decap_w0
xfeed_375 1 0 decap_w0
xfeed_374 1 0 decap_w0
xfeed_373 1 0 tie
xfeed_372 1 0 decap_w0
xfeed_371 1 0 decap_w0
xfeed_370 1 0 decap_w0
xspare_feed_409 1 0 decap_w0
xspare_feed_408 1 0 tie
xspare_feed_407 1 0 tie
xspare_feed_406 1 0 decap_w0
xspare_feed_405 1 0 tie
xspare_feed_404 1 0 tie
xspare_feed_403 1 0 decap_w0
xspare_feed_402 1 0 tie
xspare_feed_401 1 0 tie
xcmpt_abc_30082_new_n5257_hfns_2 1 0 6446 6443 buf_x4
xcmpt_abc_30082_new_n5257_hfns_1 1 0 6443 6444 buf_x4
xcmpt_abc_30082_new_n5257_hfns_0 1 0 6443 6445 buf_x4
xsubckt_1888_nxr2_x1 6502 1 0 6503 7178 nxr2_x1
xsubckt_1853_oa22_x2 0 2299 1 6535 6537 6547 oa22_x2
xsubckt_1687_a2_x2 0 6690 1 6691 8415 a2_x2
xsubckt_1335_nand2_x0 1 0 7030 445 8134 nand2_x0
xsubckt_675_xr2_x1 7667 0 1 740 65 xr2_x1
xsubckt_3440_nand2_x0 1 0 4928 6012 8097 nand2_x0
xsubckt_3616_nand3_x0 1 0 4755 4756 4759 5950 nand3_x0
xsubckt_3794_nand3_x0 1 0 4580 4585 4589 772 nand3_x0
xsubckt_4069_nand2_x0 1 0 4310 4311 8025 nand2_x0
xsubckt_5280_nor2_x0 1 0 3617 3618 3621 nor2_x0
xsubckt_5560_ao22_x2 0 3388 1 8126 3392 8122 ao22_x2
xsubckt_5661_mx2_x2 0 3312 1 796 1162 1066 mx2_x2
xsubckt_5707_mx2_x2 0 9728 1 3283 491 528 mx2_x2
xsubckt_5709_mx2_x2 0 9726 1 3283 488 525 mx2_x2
xsubckt_6196_mx2_x2 0 2821 1 8225 2822 2823 mx2_x2
xsubckt_6198_mx2_x2 0 2819 1 857 1148 1116 mx2_x2
xsubckt_6587_mx2_x2 0 2441 1 834 2442 2443 mx2_x2
xsubckt_6589_mx2_x2 0 2439 1 828 2440 2447 mx2_x2
xsubckt_6681_a2_x2 0 9682 1 2350 2384 a2_x2
xsubckt_8327_sff1_x4 1 2132 0 10030 1335 sff1_x4
xsubckt_8762_sff1_x4 1 2073 0 9660 643 sff1_x4
xsubckt_557_oa22_x2 0 7780 1 7806 7939 8238 oa22_x2
xsubckt_3436_nand3_x0 1 0 4932 4933 4936 5950 nand3_x0
xsubckt_4001_mx2_x2 0 4377 1 795 1166 1070 mx2_x2
xsubckt_5663_mx2_x2 0 3310 1 789 3311 3312 mx2_x2
xsubckt_5665_mx2_x2 0 3308 1 775 3309 3316 mx2_x2
xsubckt_5667_mx2_x2 0 3306 1 795 1130 1098 mx2_x2
xsubckt_8758_sff1_x4 1 2079 0 9664 659 sff1_x4
xsubckt_9135_sff1_x4 1 2219 0 9305 1109 sff1_x4
xfeed_389 1 0 decap_w0
xfeed_388 1 0 tie
xfeed_387 1 0 tie
xfeed_386 1 0 decap_w0
xfeed_385 1 0 decap_w0
xfeed_384 1 0 tie
xfeed_383 1 0 decap_w0
xfeed_382 1 0 decap_w0
xfeed_381 1 0 tie
xfeed_380 1 0 decap_w0
xspare_feed_419 1 0 tie
xspare_feed_418 1 0 decap_w0
xspare_feed_417 1 0 tie
xspare_feed_416 1 0 tie
xspare_feed_415 1 0 decap_w0
xspare_feed_414 1 0 tie
xspare_feed_413 1 0 tie
xspare_feed_412 1 0 decap_w0
xspare_feed_411 1 0 tie
xspare_feed_410 1 0 tie
xsubckt_1525_ao22_x2 0 6841 1 615 6845 8065 ao22_x2
xsubckt_1186_o2_x2 0 7179 1 193 224 o2_x2
xsubckt_814_nand2_x0 1 0 7531 630 1938 nand2_x0
xsubckt_992_nand2_x0 1 0 7362 633 1963 nand2_x0
xsubckt_1065_nand2_x0 1 0 7293 7991 2023 nand2_x0
xsubckt_3260_nand2_x0 1 0 5105 6012 8102 nand2_x0
xsubckt_3557_oa22_x2 0 4813 1 4814 4853 5958 oa22_x2
xsubckt_4005_mx2_x2 0 4373 1 795 1774 1742 mx2_x2
xsubckt_4052_nand2_x0 1 0 4327 4328 4329 nand2_x0
xsubckt_4350_mx2_x2 0 10209 1 4191 6162 1468 mx2_x2
xsubckt_4481_mx3_x2 1 0 10089 4170 6289 1286 6235 6239 mx3_x2
xsubckt_4483_mx3_x2 1 0 10087 4170 6288 1284 6215 6219 mx3_x2
xsubckt_5110_nor2_x0 1 0 3775 3776 3779 nor2_x0
xsubckt_5271_o2_x2 0 9822 1 3626 3639 o2_x2
xsubckt_5669_mx2_x2 0 3304 1 795 1290 1258 mx2_x2
xsubckt_7215_nand3_x0 1 0 8603 8604 8609 8610 nand3_x0
xsubckt_8235_sff1_x4 1 2205 0 10122 1671 sff1_x4
xsubckt_8670_sff1_x4 1 2182 0 9719 518 sff1_x4
xcmpt_abc_30082_new_n3413_hfns_4 1 0 8280 8275 buf_x4
xcmpt_abc_30082_new_n3413_hfns_3 1 0 8275 8276 buf_x4
xcmpt_abc_30082_new_n3413_hfns_2 1 0 8275 8277 buf_x4
xcmpt_abc_30082_new_n3413_hfns_1 1 0 8275 8278 buf_x4
xcmpt_abc_30082_new_n3413_hfns_0 1 0 8275 8279 buf_x4
xsubckt_1850_o2_x2 0 6537 1 6538 6546 o2_x2
xsubckt_1718_nxr2_x1 6661 1 0 6662 8043 nxr2_x1
xsubckt_634_nand2_x0 1 0 7706 7707 7798 nand2_x0
xsubckt_724_nand2_x0 1 0 7620 7810 401 nand2_x0
xsubckt_2907_nand2_x0 1 0 10406 5453 5510 nand2_x0
xsubckt_3080_nand2_x0 1 0 5282 6012 8109 nand2_x0
xsubckt_3256_nand3_x0 1 0 5109 5110 5113 5950 nand3_x0
xsubckt_3914_oa22_x2 0 4462 1 4463 4464 8017 oa22_x2
xsubckt_4009_mx2_x2 0 4369 1 794 1838 1806 mx2_x2
xsubckt_4352_mx2_x2 0 10207 1 4191 6142 1466 mx2_x2
xsubckt_4354_mx2_x2 0 10205 1 4191 6125 1464 mx2_x2
xsubckt_4356_mx2_x2 0 10203 1 4191 6108 1461 mx2_x2
xsubckt_4485_mx3_x2 1 0 10085 4170 6289 1312 6197 6201 mx3_x2
xsubckt_7172_ao22_x2 0 9528 1 8640 8639 8636 ao22_x2
xsubckt_8666_sff1_x4 1 2182 0 9723 522 sff1_x4
xsubckt_9043_sff1_x4 1 2106 0 9387 1356 sff1_x4
xfeed_399 1 0 decap_w0
xfeed_398 1 0 tie
xfeed_397 1 0 decap_w0
xfeed_396 1 0 decap_w0
xfeed_395 1 0 decap_w0
xfeed_394 1 0 decap_w0
xfeed_393 1 0 decap_w0
xfeed_392 1 0 tie
xfeed_391 1 0 decap_w0
xfeed_390 1 0 tie
xspare_feed_429 1 0 tie
xspare_feed_428 1 0 tie
xspare_feed_427 1 0 decap_w0
xspare_feed_426 1 0 tie
xspare_feed_425 1 0 tie
xspare_feed_424 1 0 decap_w0
xspare_feed_423 1 0 tie
xspare_feed_422 1 0 tie
xspare_feed_421 1 0 decap_w0
xspare_feed_420 1 0 tie
xsubckt_3076_nand3_x0 1 0 5286 5287 5290 5950 nand3_x0
xsubckt_3609_nand2_x0 1 0 4762 4763 8025 nand2_x0
xsubckt_3823_mx2_x2 0 4552 1 794 1169 1073 mx2_x2
xsubckt_4358_mx2_x2 0 10201 1 4190 6089 1459 mx2_x2
xsubckt_8143_sff1_x4 1 2198 0 10214 1473 sff1_x4
xsubckt_8500_sff1_x4 1 2159 0 9857 86 sff1_x4
xsubckt_9039_sff1_x4 1 2073 0 9391 374 sff1_x4
xsubckt_9400_sff1_x4 1 2123 0 9043 943 sff1_x4
xcmpt_abc_30082_new_n3768_hfns_2 1 0 7858 7855 buf_x4
xcmpt_abc_30082_new_n3768_hfns_1 1 0 7855 7856 buf_x4
xcmpt_abc_30082_new_n3768_hfns_0 1 0 7855 7857 buf_x4
xcmpt_abc_30082_new_n7727_hfns_2 1 0 4175 4172 buf_x4
xcmpt_abc_30082_new_n7727_hfns_1 1 0 4172 4173 buf_x4
xcmpt_abc_30082_new_n7727_hfns_0 1 0 4172 4174 buf_x4
xsubckt_3043_mx2_x2 0 5319 1 793 1183 1087 mx2_x2
xsubckt_3334_nxr2_x1 5033 1 0 240 759 nxr2_x1
xsubckt_3429_nand2_x0 1 0 4939 4940 8022 nand2_x0
xsubckt_3827_mx2_x2 0 4548 1 793 1777 1745 mx2_x2
xsubckt_3860_nand2_x0 1 0 4515 6012 8084 nand2_x0
xsubckt_5530_oa22_x2 0 3408 1 2020 3414 2019 oa22_x2
xsubckt_6430_oa22_x2 0 2594 1 45 1906 202 oa22_x2
xsubckt_7168_ao22_x2 0 8639 1 3285 3288 325 ao22_x2
xsubckt_7208_nand2_x0 1 0 8610 7976 374 nand2_x0
xsubckt_7526_mx3_x2 1 0 9287 8477 6291 1382 6235 6239 mx3_x2
xsubckt_8051_sff1_x4 1 2232 0 10306 1757 sff1_x4
xsubckt_8139_sff1_x4 1 2218 0 10218 1447 sff1_x4
xsubckt_8574_sff1_x4 1 2050 0 9783 2022 sff1_x4
xsubckt_9474_sff1_x4 1 2225 0 8969 1832 sff1_x4
xspare_feed_439 1 0 decap_w0
xspare_feed_438 1 0 tie
xspare_feed_437 1 0 tie
xspare_feed_436 1 0 decap_w0
xspare_feed_435 1 0 tie
xspare_feed_434 1 0 tie
xspare_feed_433 1 0 decap_w0
xspare_feed_432 1 0 tie
xspare_feed_431 1 0 tie
xspare_feed_430 1 0 decap_w0
xsubckt_1665_nand2_x0 1 0 6710 6948 7111 nand2_x0
xsubckt_1558_nor3_x0 1 0 6810 6812 8055 615 nor3_x0
xsubckt_241_inv_x0 1 0 420 8135 inv_x0
xsubckt_730_oa22_x2 0 7611 1 7614 7616 8284 oa22_x2
xsubckt_974_a3_x2 1 7379 0 7380 7381 7382 a3_x2
xsubckt_2457_nand2_x0 1 0 5894 5896 5943 nand2_x0
xsubckt_2710_nand2_x0 1 0 5646 5647 780 nand2_x0
xsubckt_3047_mx2_x2 0 5315 1 799 1791 1759 mx2_x2
xsubckt_3249_nand2_x0 1 0 5116 5117 8022 nand2_x0
xsubckt_3783_mx2_x2 0 4591 1 799 1138 1106 mx2_x2
xsubckt_3856_nand3_x0 1 0 4519 4520 4523 5950 nand3_x0
xsubckt_4031_nand3_x0 1 0 4347 4367 4371 8013 nand3_x0
xsubckt_5537_nor2_x0 1 0 9778 3404 3405 nor2_x0
xsubckt_7351_mx2_x2 0 9484 1 8500 6273 1591 mx2_x2
xsubckt_7528_mx3_x2 1 0 9285 8477 6292 1380 6216 6220 mx3_x2
xsubckt_7740_mx2_x2 0 9086 1 8444 6152 987 mx2_x2
xsubckt_7742_mx2_x2 0 9084 1 8444 6135 985 mx2_x2
xsubckt_8931_sff1_x4 1 2089 0 9494 738 sff1_x4
xsubckt_9382_sff1_x4 1 2193 0 9061 932 sff1_x4
xsubckt_2125_mx2_x2 0 6322 1 860 1865 1513 mx2_x2
xsubckt_2123_mx2_x2 0 6324 1 833 6325 6326 mx2_x2
xsubckt_2121_mx2_x2 0 6326 1 860 969 937 mx2_x2
xsubckt_1485_nand2_x0 1 0 6878 6880 6888 nand2_x0
xsubckt_247_inv_x0 1 0 2010 8129 inv_x0
xsubckt_245_inv_x0 1 0 418 8131 inv_x0
xsubckt_243_inv_x0 1 0 2011 8133 inv_x0
xsubckt_2620_nand2_x0 1 0 5735 5993 222 nand2_x0
xsubckt_3398_mx2_x2 0 4970 1 797 985 953 mx2_x2
xsubckt_3680_nand2_x0 1 0 4692 6012 8091 nand2_x0
xsubckt_3787_mx2_x2 0 4587 1 798 1298 1266 mx2_x2
xsubckt_3991_xr2_x1 4387 0 1 228 747 xr2_x1
xsubckt_4700_a4_x2 0 4097 1 4098 4107 4117 4142 a4_x2
xsubckt_5038_nxr2_x1 3842 1 0 3946 709 nxr2_x1
xsubckt_6102_ao22_x2 0 2912 1 573 568 764 ao22_x2
xsubckt_7014_nand4_x0 1 0 8693 8694 8719 8244 701 nand4_x0
xsubckt_7353_mx2_x2 0 9482 1 8500 6258 1577 mx2_x2
xsubckt_7355_mx2_x2 0 9480 1 8500 6245 1575 mx2_x2
xsubckt_7744_mx2_x2 0 9082 1 8444 6116 982 mx2_x2
xsubckt_7746_mx2_x2 0 9080 1 8444 6097 980 mx2_x2
xsubckt_7748_mx2_x2 0 9078 1 8443 6081 978 mx2_x2
xsubckt_8047_sff1_x4 1 2229 0 10310 1761 sff1_x4
xsubckt_8482_sff1_x4 1 2044 0 9875 1920 sff1_x4
xsubckt_9304_sff1_x4 1 2138 0 9136 1035 sff1_x4
xspare_feed_449 1 0 tie
xspare_feed_448 1 0 decap_w0
xspare_feed_447 1 0 tie
xspare_feed_446 1 0 tie
xspare_feed_445 1 0 decap_w0
xspare_feed_444 1 0 tie
xspare_feed_443 1 0 tie
xspare_feed_442 1 0 decap_w0
xspare_feed_441 1 0 tie
xspare_feed_440 1 0 tie
xcmpt_abc_30082_new_n10807_hfns_1 1 0 8473 8474 buf_x4
xcmpt_abc_30082_new_n10807_hfns_0 1 0 8473 8475 buf_x4
xsubckt_2326_a3_x2 1 6048 0 6066 73 72 a3_x2
xsubckt_2277_nand2_x0 1 0 6111 6120 79 nand2_x0
xsubckt_2129_mx2_x2 0 6318 1 823 6319 6334 mx2_x2
xsubckt_2127_mx2_x2 0 6320 1 830 6321 6324 mx2_x2
xsubckt_2081_mx2_x2 0 6365 1 830 6366 6369 mx2_x2
xsubckt_1442_nxr2_x1 6918 1 0 6919 6929 nxr2_x1
xsubckt_1203_nand4_x0 1 0 7162 7164 7168 7173 7177 nand4_x0
xsubckt_433_nand3_x0 1 0 7908 7909 7910 7988 nand3_x0
xsubckt_249_inv_x0 1 0 222 8127 inv_x0
xsubckt_704_mx2_x2 0 7639 1 216 424 406 mx2_x2
xsubckt_1163_a3_x2 1 7200 0 7201 7202 7203 a3_x2
xsubckt_2470_mx2_x2 0 5882 1 821 1719 1687 mx2_x2
xsubckt_2472_mx2_x2 0 5880 1 788 5881 5882 mx2_x2
xsubckt_2474_mx2_x2 0 5878 1 821 1175 1079 mx2_x2
xsubckt_2861_mx2_x2 0 5498 1 821 1028 996 mx2_x2
xsubckt_2865_mx2_x2 0 5494 1 821 1156 1060 mx2_x2
xsubckt_3069_nand2_x0 1 0 5293 5294 8020 nand2_x0
xsubckt_3676_nand3_x0 1 0 4696 4697 4700 5950 nand3_x0
xsubckt_4720_a4_x2 0 4081 1 4085 4088 4143 1967 a4_x2
xsubckt_5494_a4_x2 0 3433 1 3439 2031 2032 2033 a4_x2
xsubckt_5502_a3_x2 1 9789 0 3428 3429 55 a3_x2
xsubckt_6431_mx2_x2 0 2593 1 860 916 884 mx2_x2
xsubckt_6820_mx2_x2 0 8844 1 7918 8228 8229 mx2_x2
xsubckt_6822_mx2_x2 0 8843 1 7918 8232 8233 mx2_x2
xsubckt_6857_oa22_x2 0 8813 1 8826 8815 8816 oa22_x2
xsubckt_8404_sff1_x4 1 2212 0 9953 1628 sff1_x4
xsubckt_8927_sff1_x4 1 2079 0 9498 764 sff1_x4
xsubckt_9290_sff1_x4 1 2203 0 9150 1051 sff1_x4
xsubckt_9378_sff1_x4 1 2242 0 9065 936 sff1_x4
xcmpt_abc_30082_new_n10807_hfns_2 1 0 8476 8473 buf_x4
xsubckt_2097_nand2_x0 1 0 6350 7861 57 nand2_x0
xsubckt_2087_mx2_x2 0 6359 1 835 6360 6361 mx2_x2
xsubckt_2085_mx2_x2 0 6361 1 863 1164 1068 mx2_x2
xsubckt_2083_mx2_x2 0 6363 1 863 1036 1004 mx2_x2
xsubckt_964_nand2_x0 1 0 7389 7391 7393 nand2_x0
xsubckt_2476_mx2_x2 0 5876 1 789 5877 5878 mx2_x2
xsubckt_2478_mx2_x2 0 5874 1 820 983 951 mx2_x2
xsubckt_2869_mx2_x2 0 5490 1 820 1764 1732 mx2_x2
xsubckt_3323_a2_x2 0 5043 1 5044 5049 a2_x2
xsubckt_3496_nand3_x0 1 0 4873 4874 4877 5950 nand3_x0
xsubckt_4114_nand2_x0 1 0 4266 4267 8023 nand2_x0
xsubckt_4839_a4_x2 0 3992 1 1938 1937 1936 1935 a4_x2
xsubckt_5381_nxr2_x1 3523 1 0 3874 730 nxr2_x1
xsubckt_5434_oa22_x2 0 3474 1 3499 3496 3484 oa22_x2
xsubckt_5469_nxr2_x1 3450 1 0 3453 8111 nxr2_x1
xsubckt_6040_mx2_x2 0 2973 1 835 2974 2975 mx2_x2
xsubckt_6042_mx2_x2 0 2971 1 858 1888 1536 mx2_x2
xsubckt_6044_mx2_x2 0 2969 1 8221 2970 2971 mx2_x2
xsubckt_6433_mx2_x2 0 2591 1 8221 2592 2593 mx2_x2
xsubckt_6435_mx2_x2 0 2589 1 858 1780 1748 mx2_x2
xsubckt_6437_mx2_x2 0 2587 1 8215 2588 2591 mx2_x2
xsubckt_6780_mx2_x2 0 8874 1 858 1482 1450 mx2_x2
xsubckt_6824_mx2_x2 0 8842 1 7917 8230 8231 mx2_x2
xsubckt_6828_mx2_x2 0 9672 1 6441 8840 644 mx2_x2
xsubckt_7011_nand2_x0 1 0 9633 8696 8698 nand2_x0
xsubckt_8390_sff1_x4 1 2110 0 9967 1634 sff1_x4
xsubckt_8478_sff1_x4 1 2044 0 9879 1925 sff1_x4
xsubckt_8835_sff1_x4 1 2189 0 9590 1509 sff1_x4
xsubckt_9212_sff1_x4 1 2126 0 9228 1079 sff1_x4
xfeed_509 1 0 decap_w0
xfeed_508 1 0 decap_w0
xfeed_507 1 0 decap_w0
xfeed_506 1 0 tie
xfeed_505 1 0 decap_w0
xfeed_504 1 0 decap_w0
xfeed_503 1 0 decap_w0
xfeed_502 1 0 tie
xfeed_501 1 0 decap_w0
xfeed_500 1 0 decap_w0
xspare_feed_459 1 0 tie
xspare_feed_458 1 0 tie
xspare_feed_457 1 0 decap_w0
xspare_feed_456 1 0 tie
xspare_feed_455 1 0 tie
xspare_feed_454 1 0 decap_w0
xspare_feed_453 1 0 tie
xspare_feed_452 1 0 tie
xspare_feed_451 1 0 decap_w0
xspare_feed_450 1 0 tie
xcmpt_abc_30082_new_n5450_hfns_2 1 0 6284 6281 buf_x4
xcmpt_abc_30082_new_n5450_hfns_1 1 0 6281 6282 buf_x4
xcmpt_abc_30082_new_n5450_hfns_0 1 0 6281 6283 buf_x4
xsubckt_2346_nand3_x0 1 0 6022 6039 69 68 nand3_x0
xsubckt_2089_mx2_x2 0 6357 1 826 6358 6365 mx2_x2
xsubckt_2020_o3_x2 0 6428 1 711 710 709 o3_x2
xsubckt_1947_mx2_x2 0 455 1 7807 204 442 mx2_x2
xsubckt_1945_mx2_x2 0 458 1 7807 206 456 mx2_x2
xsubckt_1943_mx2_x2 0 460 1 7807 208 468 mx2_x2
xsubckt_1873_nxr2_x1 6516 1 0 6517 8053 nxr2_x1
xsubckt_1720_a2_x2 0 6659 1 6660 236 a2_x2
xsubckt_1554_nand3_x0 1 0 6814 6815 6816 6817 nand3_x0
xsubckt_1291_a2_x2 0 7074 1 192 219 a2_x2
xsubckt_874_nand2_x0 1 0 7474 242 1899 nand2_x0
xsubckt_1020_xr2_x1 7336 0 1 752 77 xr2_x1
xsubckt_2967_nand2_x0 1 0 5394 5995 246 nand2_x0
xsubckt_3383_a2_x2 0 4984 1 4985 4990 a2_x2
xsubckt_3849_nand2_x0 1 0 4526 4527 8024 nand2_x0
xsubckt_4097_a2_x2 0 4282 1 4283 4285 a2_x2
xsubckt_4693_a3_x2 1 4102 0 4103 4117 1975 a3_x2
xsubckt_4701_a2_x2 0 4096 1 4097 1971 a2_x2
xsubckt_5303_nxr2_x1 3596 1 0 3610 3888 nxr2_x1
xsubckt_5435_a2_x2 0 3473 1 3474 3485 a2_x2
xsubckt_5900_mx2_x2 0 3109 1 8222 3110 3111 mx2_x2
xsubckt_5902_mx2_x2 0 3107 1 862 1030 998 mx2_x2
xsubckt_5904_mx2_x2 0 3105 1 8214 3106 3109 mx2_x2
xsubckt_6046_mx2_x2 0 2967 1 862 1056 1024 mx2_x2
xsubckt_6048_mx2_x2 0 2965 1 8214 2966 2969 mx2_x2
xsubckt_6439_mx2_x2 0 2585 1 863 1172 1076 mx2_x2
xsubckt_6782_mx2_x2 0 8872 1 8222 8873 8874 mx2_x2
xsubckt_6784_mx2_x2 0 8870 1 827 8871 8878 mx2_x2
xsubckt_7722_a2_x2 0 8446 1 8457 4171 a2_x2
xsubckt_7935_sff1_x4 1 2138 0 10417 1803 sff1_x4
xsubckt_8312_sff1_x4 1 2251 0 10045 1656 sff1_x4
xsubckt_9208_sff1_x4 1 2139 0 9232 1195 sff1_x4
xsubckt_9286_sff1_x4 1 2242 0 9154 1055 sff1_x4
xcmpt_abc_30082_new_n5456_hfns_2 1 0 6274 6271 buf_x4
xcmpt_abc_30082_new_n5456_hfns_1 1 0 6271 6272 buf_x4
xcmpt_abc_30082_new_n5456_hfns_0 1 0 6271 6273 buf_x4
xsubckt_1949_mx2_x2 0 453 1 7807 202 440 mx2_x2
xsubckt_1907_nand2_x0 1 0 438 6488 6489 nand2_x0
xsubckt_1817_nand2_x0 1 0 6568 6948 7155 nand2_x0
xsubckt_1374_nand3_x0 1 0 6991 7138 202 8088 nand3_x0
xsubckt_1110_nand2_x0 1 0 7250 7251 7259 nand2_x0
xsubckt_3669_nand2_x0 1 0 4703 4704 8025 nand2_x0
xsubckt_4761_a2_x2 0 9907 1 4051 55 a2_x2
xsubckt_4781_a2_x2 0 9902 1 4036 55 a2_x2
xsubckt_4965_oa22_x2 0 9854 1 7886 3900 3902 oa22_x2
xsubckt_5860_mx2_x2 0 3148 1 836 3149 3150 mx2_x2
xsubckt_5906_mx2_x2 0 3103 1 840 1350 1318 mx2_x2
xsubckt_5908_mx2_x2 0 3101 1 8223 3102 3103 mx2_x2
xsubckt_6395_mx2_x2 0 2628 1 840 917 885 mx2_x2
xsubckt_6397_mx2_x2 0 2626 1 8223 2627 2628 mx2_x2
xsubckt_6399_mx2_x2 0 2624 1 861 1781 1749 mx2_x2
xsubckt_6853_a2_x2 0 9667 1 8817 55 a2_x2
xsubckt_8308_sff1_x4 1 2212 0 10049 1660 sff1_x4
xsubckt_8386_sff1_x4 1 2111 0 9971 1485 sff1_x4
xsubckt_8743_sff1_x4 1 2156 0 2302 2270 sff1_x4
xsubckt_9120_sff1_x4 1 2217 0 9320 1095 sff1_x4
xfeed_519 1 0 decap_w0
xfeed_518 1 0 decap_w0
xfeed_517 1 0 tie
xfeed_516 1 0 tie
xfeed_515 1 0 tie
xfeed_514 1 0 decap_w0
xfeed_513 1 0 decap_w0
xfeed_512 1 0 decap_w0
xfeed_511 1 0 decap_w0
xfeed_510 1 0 decap_w0
xspare_feed_469 1 0 decap_w0
xspare_feed_468 1 0 tie
xspare_feed_467 1 0 tie
xspare_feed_466 1 0 decap_w0
xspare_feed_465 1 0 tie
xspare_feed_464 1 0 tie
xspare_feed_463 1 0 decap_w0
xspare_feed_462 1 0 tie
xspare_feed_461 1 0 tie
xspare_feed_460 1 0 decap_w0
xsubckt_1727_nand2_x0 1 0 6652 7127 7972 nand2_x0
xsubckt_2787_nand2_x0 1 0 5570 5571 5572 nand2_x0
xsubckt_2963_a2_x2 0 5397 1 5398 5400 a2_x2
xsubckt_3384_ao22_x2 0 4983 1 5032 5031 4984 ao22_x2
xsubckt_4200_mx2_x2 0 10347 1 4215 6252 1128 mx2_x2
xsubckt_5862_mx2_x2 0 3146 1 839 1863 1511 mx2_x2
xsubckt_5864_mx2_x2 0 3144 1 8223 3145 3146 mx2_x2
xsubckt_5866_mx2_x2 0 3142 1 840 1031 999 mx2_x2
xsubckt_8220_sff1_x4 1 2139 0 10137 1267 sff1_x4
xsubckt_8294_sff1_x4 1 2116 0 10063 1666 sff1_x4
xsubckt_9116_sff1_x4 1 2132 0 9324 1111 sff1_x4
xsubckt_9194_sff1_x4 1 2203 0 9246 1211 sff1_x4
xsubckt_395_nor4_x0 1 0 7950 660 659 619 655 nor4_x0
xsubckt_737_ao22_x2 0 7604 1 7605 7609 7795 ao22_x2
xsubckt_2950_nand2_x0 1 0 5410 5411 8022 nand2_x0
xsubckt_3489_nand2_x0 1 0 4880 4881 8022 nand2_x0
xsubckt_3625_o2_x2 0 4746 1 4747 5994 o2_x2
xsubckt_3918_nand3_x0 1 0 4458 4459 4633 6392 nand3_x0
xsubckt_3934_nxr2_x1 4443 1 0 229 748 nxr2_x1
xsubckt_4940_mx2_x2 0 3918 1 6444 6194 152 mx2_x2
xsubckt_5228_o2_x2 0 9825 1 3666 3678 o2_x2
xsubckt_5580_nand4_x0 1 0 3374 3382 2001 2002 2003 nand4_x0
xsubckt_5594_nand2_x0 1 0 3364 3367 1997 nand2_x0
xsubckt_5868_mx2_x2 0 3140 1 8212 3141 3144 mx2_x2
xsubckt_8216_sff1_x4 1 2223 0 10141 1272 sff1_x4
xsubckt_8651_sff1_x4 1 2194 0 9738 508 sff1_x4
xsubckt_8739_sff1_x4 1 2176 0 2306 2274 sff1_x4
xfeed_529 1 0 decap_w0
xfeed_528 1 0 decap_w0
xfeed_527 1 0 tie
xfeed_526 1 0 tie
xfeed_525 1 0 decap_w0
xfeed_524 1 0 decap_w0
xfeed_523 1 0 decap_w0
xfeed_522 1 0 decap_w0
xfeed_521 1 0 decap_w0
xfeed_520 1 0 decap_w0
xspare_feed_479 1 0 tie
xspare_feed_478 1 0 decap_w0
xspare_feed_477 1 0 tie
xspare_feed_476 1 0 tie
xspare_feed_475 1 0 decap_w0
xspare_feed_474 1 0 tie
xspare_feed_473 1 0 tie
xspare_feed_472 1 0 decap_w0
xspare_feed_471 1 0 tie
xspare_feed_470 1 0 tie
xsubckt_1547_nand2_x0 1 0 6820 6942 7074 nand2_x0
xsubckt_4160_mx2_x2 0 10381 1 4224 6266 1772 mx2_x2
xsubckt_4162_mx2_x2 0 10379 1 4224 6251 1768 mx2_x2
xsubckt_4208_mx2_x2 0 10339 1 4215 6178 1150 mx2_x2
xsubckt_4555_mx2_x2 0 10020 1 4157 6188 1343 mx2_x2
xsubckt_4944_mx2_x2 0 3915 1 6444 6186 151 mx2_x2
xsubckt_5326_nand2_x0 1 0 3574 3575 701 nand2_x0
xsubckt_6868_ao22_x2 0 9664 1 8805 8808 52 ao22_x2
xsubckt_9024_sff1_x4 1 2083 0 9406 391 sff1_x4
xsubckt_2314_ao22_x2 0 6064 1 74 6075 6288 ao22_x2
xsubckt_2159_nand2_x0 1 0 6296 541 8409 nand2_x0
xsubckt_1710_nand2_x0 1 0 6668 6948 7120 nand2_x0
xsubckt_363_a3_x2 1 7985 0 7986 7988 7991 a3_x2
xsubckt_3_inv_x0 1 0 655 8419 inv_x0
xsubckt_1_inv_x0 1 0 503 8421 inv_x0
xsubckt_2557_nor2_x0 1 0 5796 226 745 nor2_x0
xsubckt_2680_nand2_x0 1 0 5676 5678 5683 nand2_x0
xsubckt_2971_o2_x2 0 5390 1 246 765 o2_x2
xsubckt_4557_mx2_x2 0 10018 1 4157 6170 1341 mx2_x2
xsubckt_4559_mx2_x2 0 10016 1 4157 6152 1339 mx2_x2
xsubckt_4948_mx2_x2 0 3912 1 6445 6176 150 mx2_x2
xsubckt_6881_o2_x2 0 9662 1 8797 8799 o2_x2
xsubckt_8124_sff1_x4 1 2139 0 10233 1235 sff1_x4
xsubckt_8647_sff1_x4 1 2185 0 9742 512 sff1_x4
xsubckt_9098_sff1_x4 1 2166 0 9342 891 sff1_x4
xfeed_539 1 0 tie
xfeed_538 1 0 decap_w0
xfeed_537 1 0 tie
xfeed_536 1 0 decap_w0
xfeed_535 1 0 decap_w0
xfeed_534 1 0 decap_w0
xfeed_533 1 0 decap_w0
xfeed_532 1 0 decap_w0
xfeed_531 1 0 decap_w0
xfeed_530 1 0 decap_w0
xspare_feed_489 1 0 tie
xspare_feed_488 1 0 tie
xspare_feed_487 1 0 decap_w0
xspare_feed_486 1 0 tie
xspare_feed_485 1 0 tie
xspare_feed_484 1 0 decap_w0
xspare_feed_483 1 0 tie
xspare_feed_482 1 0 tie
xspare_feed_481 1 0 decap_w0
xspare_feed_480 1 0 tie
xsubckt_2412_nand2_x0 1 0 5938 5939 5945 nand2_x0
xsubckt_1530_nand2_x0 1 0 6836 6838 6846 nand2_x0
xsubckt_1414_ao22_x2 0 6951 1 6953 6954 576 ao22_x2
xsubckt_451_a2_x2 0 7887 1 50 1912 a2_x2
xsubckt_9_inv_x0 1 0 559 8410 inv_x0
xsubckt_7_inv_x0 1 0 558 8412 inv_x0
xsubckt_5_inv_x0 1 0 615 8417 inv_x0
xsubckt_900_a2_x2 0 7449 1 7450 7456 a2_x2
xsubckt_3240_mx2_x2 0 5125 1 8030 5126 5127 mx2_x2
xsubckt_3242_mx2_x2 0 5123 1 804 1244 1212 mx2_x2
xsubckt_3244_mx2_x2 0 5121 1 8030 5122 5123 mx2_x2
xsubckt_3393_nxr2_x1 4975 1 0 239 758 nxr2_x1
xsubckt_5189_nxr2_x1 3702 1 0 3716 3913 nxr2_x1
xsubckt_6934_oa22_x2 0 9647 1 8759 8760 8761 oa22_x2
xsubckt_7201_mx2_x2 0 8615 1 8282 6392 7857 mx2_x2
xsubckt_8198_sff1_x4 1 2126 0 10159 1282 sff1_x4
xsubckt_9455_sff1_x4 1 2232 0 8988 1881 sff1_x4
xsubckt_1009_nand2_x0 1 0 7346 630 1927 nand2_x0
xsubckt_1097_nand2_x0 1 0 7263 7264 7267 nand2_x0
xsubckt_2711_mx2_x2 0 5645 1 810 1351 1319 mx2_x2
xsubckt_3246_mx2_x2 0 5119 1 810 1372 1340 mx2_x2
xsubckt_3248_mx2_x2 0 5117 1 8031 5118 5119 mx2_x2
xsubckt_3591_mx2_x2 0 4780 1 810 1845 1813 mx2_x2
xsubckt_3639_mx2_x2 0 4733 1 810 1044 1012 mx2_x2
xsubckt_3999_nand2_x0 1 0 4379 4380 782 nand2_x0
xsubckt_5518_nor2_x0 1 0 9784 3417 3418 nor2_x0
xsubckt_7071_nand2_x0 1 0 9600 8671 8672 nand2_x0
xsubckt_7203_mx2_x2 0 8614 1 562 3194 8247 mx2_x2
xsubckt_7550_mx2_x2 0 9263 1 8475 6017 1386 mx2_x2
xsubckt_8032_sff1_x4 1 2132 0 10325 1135 sff1_x4
xsubckt_8555_sff1_x4 1 2057 0 9802 1980 sff1_x4
xsubckt_8912_sff1_x4 1 2079 0 9513 748 sff1_x4
xsubckt_8990_sff1_x4 1 2251 0 9435 1560 sff1_x4
xfeed_549 1 0 tie
xfeed_548 1 0 decap_w0
xfeed_547 1 0 decap_w0
xfeed_546 1 0 decap_w0
xfeed_545 1 0 tie
xfeed_544 1 0 decap_w0
xfeed_543 1 0 decap_w0
xfeed_542 1 0 tie
xfeed_541 1 0 tie
xfeed_540 1 0 decap_w0
xspare_feed_499 1 0 decap_w0
xspare_feed_498 1 0 tie
xspare_feed_497 1 0 tie
xspare_feed_496 1 0 decap_w0
xspare_feed_495 1 0 tie
xspare_feed_494 1 0 tie
xspare_feed_493 1 0 decap_w0
xspare_feed_492 1 0 tie
xspare_feed_491 1 0 tie
xspare_feed_490 1 0 decap_w0
xsubckt_2322_mx2_x2 0 10420 1 6300 6054 1807 mx2_x2
xsubckt_2156_a4_x2 0 6302 1 6303 6305 6313 7885 a4_x2
xsubckt_1436_nand3_x0 1 0 6924 6926 6927 8416 nand3_x0
xsubckt_1350_nand2_x0 1 0 7015 213 8109 nand2_x0
xsubckt_391_o3_x2 0 7954 1 615 625 613 o3_x2
xsubckt_351_o3_x2 0 7998 1 506 504 505 o3_x2
xsubckt_666_nand2_x0 1 0 7675 2010 637 nand2_x0
xsubckt_756_nand2_x0 1 0 7586 7809 400 nand2_x0
xsubckt_2713_mx2_x2 0 5643 1 8031 5644 5645 mx2_x2
xsubckt_2849_nand2_x0 1 0 5510 5994 218 nand2_x0
xsubckt_3595_mx2_x2 0 4776 1 808 1429 1397 mx2_x2
xsubckt_3599_mx2_x2 0 4772 1 808 1589 1557 mx2_x2
xsubckt_4228_a4_x2 0 4211 1 4212 6304 6306 551 a4_x2
xsubckt_4777_nand4_x0 1 0 4038 4042 4054 4065 1951 nand4_x0
xsubckt_5312_a4_x2 0 3588 1 3624 3885 3888 3891 a4_x2
xsubckt_5349_ao22_x2 0 3553 1 3584 3558 3555 ao22_x2
xsubckt_6606_ao22_x2 0 2422 1 574 568 749 ao22_x2
xsubckt_7161_mx2_x2 0 9534 1 8643 449 344 mx2_x2
xsubckt_7163_mx2_x2 0 9532 1 8643 447 342 mx2_x2
xsubckt_7554_mx2_x2 0 9261 1 8469 6278 1218 mx2_x2
xsubckt_7556_mx2_x2 0 9259 1 8469 6266 1196 mx2_x2
xsubckt_8028_sff1_x4 1 2145 0 10329 1139 sff1_x4
xsubckt_8986_sff1_x4 1 2212 0 9439 1564 sff1_x4
xsubckt_9363_sff1_x4 1 2229 0 9080 980 sff1_x4
xsubckt_2280_mx2_x2 0 10426 1 6300 6108 1813 mx2_x2
xsubckt_2204_a3_x2 1 6212 0 6232 62 91 a3_x2
xsubckt_707_oa22_x2 0 7636 1 7637 7640 8284 oa22_x2
xsubckt_984_ao22_x2 0 7370 1 7372 7375 1903 ao22_x2
xsubckt_1170_nand2_x0 1 0 7194 7195 7196 nand2_x0
xsubckt_3984_ao22_x2 0 4393 1 4442 4441 4394 ao22_x2
xsubckt_6630_mx2_x2 0 2399 1 843 1135 1103 mx2_x2
xsubckt_7165_mx2_x2 0 9530 1 8643 444 339 mx2_x2
xsubckt_7230_nand3_x0 1 0 8593 8594 8604 8609 nand3_x0
xsubckt_7558_mx2_x2 0 9257 1 8470 6251 1192 mx2_x2
xsubckt_8463_sff1_x4 1 2057 0 9894 1941 sff1_x4
xsubckt_8820_sff1_x4 1 2066 0 9603 562 sff1_x4
xsubckt_8908_sff1_x4 1 2083 0 9517 743 sff1_x4
xsubckt_9359_sff1_x4 1 2232 0 9084 985 sff1_x4
xfeed_559 1 0 decap_w0
xfeed_558 1 0 decap_w0
xfeed_557 1 0 decap_w0
xfeed_556 1 0 decap_w0
xfeed_555 1 0 tie
xfeed_554 1 0 tie
xfeed_553 1 0 decap_w0
xfeed_552 1 0 tie
xfeed_551 1 0 tie
xfeed_550 1 0 tie
xsubckt_2288_mx2_x2 0 10425 1 6300 6097 1812 mx2_x2
xsubckt_2284_a3_x2 1 6102 0 6120 79 78 a3_x2
xsubckt_1787_nand2_x0 1 0 6596 6943 7152 nand2_x0
xsubckt_1609_a3_x2 1 6762 0 6763 6764 6765 a3_x2
xsubckt_693_oa22_x2 0 7649 1 7650 7654 7793 oa22_x2
xsubckt_2561_ao22_x2 0 5792 1 5794 5800 7905 ao22_x2
xsubckt_2565_nand4_x0 1 0 5788 6007 7859 220 1899 nand4_x0
xsubckt_2922_nand2_x0 1 0 5438 5439 784 nand2_x0
xsubckt_3892_nand2_x0 1 0 4484 4485 8024 nand2_x0
xsubckt_4150_a2_x2 0 4230 1 4231 4233 a2_x2
xsubckt_4757_a4_x2 0 4054 1 1960 1959 1958 1957 a4_x2
xsubckt_5118_a2_x2 0 3768 1 3782 3927 a2_x2
xsubckt_5519_a3_x2 1 3416 0 3421 2022 2023 a3_x2
xsubckt_5642_nand4_x0 1 0 3331 3332 5998 6015 7902 nand4_x0
xsubckt_6241_mx2_x2 0 2777 1 841 1435 1403 mx2_x2
xsubckt_6243_mx2_x2 0 2775 1 8215 2776 2779 mx2_x2
xsubckt_6245_mx2_x2 0 2773 1 8207 2774 2789 mx2_x2
xsubckt_6632_mx2_x2 0 2397 1 8215 2398 2401 mx2_x2
xsubckt_6634_mx2_x2 0 2395 1 842 1583 1551 mx2_x2
xsubckt_6636_mx2_x2 0 2393 1 842 1487 1455 mx2_x2
xsubckt_7111_a2_x2 0 8662 1 8683 8841 a2_x2
xsubckt_7920_sff1_x4 1 2206 0 10432 1820 sff1_x4
xsubckt_8371_sff1_x4 1 2238 0 9986 1501 sff1_x4
xsubckt_8459_sff1_x4 1 2060 0 9898 1946 sff1_x4
xsubckt_8894_sff1_x4 1 2050 0 9531 341 sff1_x4
xsubckt_9271_sff1_x4 1 2113 0 9169 1421 sff1_x4
xcmpt_abc_30082_new_n5653_hfns_3 1 0 5996 5992 buf_x4
xcmpt_abc_30082_new_n5653_hfns_2 1 0 5992 5993 buf_x4
xcmpt_abc_30082_new_n5653_hfns_1 1 0 5992 5994 buf_x4
xcmpt_abc_30082_new_n5653_hfns_0 1 0 5992 5995 buf_x4
xsubckt_1697_nand2_x0 1 0 6680 7118 7972 nand2_x0
xsubckt_1629_a3_x2 1 6744 0 6745 6746 6747 a3_x2
xsubckt_1519_nand2_x0 1 0 2292 6847 6851 nand2_x0
xsubckt_1408_mx2_x2 0 6957 1 6970 659 560 mx2_x2
xsubckt_1268_a2_x2 0 7097 1 210 243 a2_x2
xsubckt_1248_a2_x2 0 7117 1 206 239 a2_x2
xsubckt_2742_nand2_x0 1 0 5615 6007 8109 nand2_x0
xsubckt_2832_nand2_x0 1 0 5526 5527 8022 nand2_x0
xsubckt_2918_nand3_x0 1 0 5442 568 8290 91 nand3_x0
xsubckt_4190_a2_x2 0 4220 1 552 553 a2_x2
xsubckt_4865_a3_x2 1 9881 0 3973 3975 45 a3_x2
xsubckt_5373_a2_x2 0 3531 1 3540 3873 a2_x2
xsubckt_5710_mx2_x2 0 9725 1 3283 487 524 mx2_x2
xsubckt_5712_mx2_x2 0 9723 1 3283 485 522 mx2_x2
xsubckt_6590_mx2_x2 0 2438 1 842 1360 1328 mx2_x2
xsubckt_6592_mx2_x2 0 2436 1 8219 2437 2438 mx2_x2
xsubckt_6638_mx2_x2 0 2391 1 8218 2392 2393 mx2_x2
xsubckt_7322_ao22_x2 0 8522 1 8606 8686 381 ao22_x2
xsubckt_7994_sff1_x4 1 2219 0 10363 1781 sff1_x4
xsubckt_8816_sff1_x4 1 2066 0 9606 709 sff1_x4
xsubckt_9267_sff1_x4 1 2110 0 9173 1425 sff1_x4
xfeed_569 1 0 decap_w0
xfeed_568 1 0 tie
xfeed_567 1 0 tie
xfeed_566 1 0 tie
xfeed_565 1 0 decap_w0
xfeed_564 1 0 tie
xfeed_563 1 0 decap_w0
xfeed_562 1 0 decap_w0
xfeed_561 1 0 tie
xfeed_560 1 0 decap_w0
xcmpt_mem_wordsize_bit2_hfns_2 1 0 329 326 buf_x4
xcmpt_mem_wordsize_bit2_hfns_1 1 0 326 327 buf_x4
xcmpt_mem_wordsize_bit2_hfns_0 1 0 326 328 buf_x4
xsubckt_1429_nand2_x0 1 0 6931 6943 7035 nand2_x0
xsubckt_1339_nand2_x0 1 0 7026 441 8127 nand2_x0
xsubckt_3575_a2_x2 0 4796 1 4797 4804 a2_x2
xsubckt_3615_oa22_x2 0 4756 1 4757 4758 8016 oa22_x2
xsubckt_3750_a2_x2 0 4624 1 232 751 a2_x2
xsubckt_5323_oa22_x2 0 3577 1 3584 3582 3579 oa22_x2
xsubckt_5714_mx2_x2 0 9721 1 3283 483 520 mx2_x2
xsubckt_5716_mx2_x2 0 9719 1 3283 481 518 mx2_x2
xsubckt_6594_mx2_x2 0 2434 1 844 1136 1104 mx2_x2
xsubckt_6596_mx2_x2 0 2432 1 8212 2433 2436 mx2_x2
xsubckt_6598_mx2_x2 0 2430 1 844 1584 1552 mx2_x2
xsubckt_6997_a3_x2 1 8707 0 8708 8266 374 a3_x2
xsubckt_7119_oa22_x2 0 8657 1 8403 7925 2 oa22_x2
xsubckt_7313_nand2_x0 1 0 8529 724 652 nand2_x0
xsubckt_7916_sff1_x4 1 2192 0 10436 1824 sff1_x4
xsubckt_8367_sff1_x4 1 2198 0 9990 1505 sff1_x4
xsubckt_9101_sff1_x4 1 2222 0 9339 888 sff1_x4
xsubckt_1770_nand2_x0 1 0 6612 6948 7139 nand2_x0
xsubckt_1680_nand2_x0 1 0 6696 6942 7109 nand2_x0
xsubckt_1502_nand2_x0 1 0 6862 7054 7972 nand2_x0
xsubckt_380_nor4_x0 1 0 7965 648 647 660 659 nor4_x0
xsubckt_13_inv_x0 1 0 504 8403 inv_x0
xsubckt_11_inv_x0 1 0 541 8405 inv_x0
xsubckt_2562_nand2_x0 1 0 5791 6008 8130 nand2_x0
xsubckt_4798_a2_x2 0 4023 1 1947 1946 a2_x2
xsubckt_4893_nxr2_x1 3953 1 0 3955 8356 nxr2_x1
xsubckt_4923_mx3_x2 1 0 3931 6450 545 8372 8193 8194 mx3_x2
xsubckt_5670_mx2_x2 0 3303 1 812 1354 1322 mx2_x2
xsubckt_5672_mx2_x2 0 3301 1 783 3302 3305 mx2_x2
xsubckt_5674_mx2_x2 0 3299 1 812 1642 1610 mx2_x2
xsubckt_5718_mx2_x2 0 9717 1 3283 479 516 mx2_x2
xsubckt_7223_nand2_x0 1 0 8598 7976 378 nand2_x0
xsubckt_7309_nand3_x0 1 0 8532 8533 8244 701 nand3_x0
xsubckt_8201_sff1_x4 1 2126 0 10156 1257 sff1_x4
xsubckt_8724_sff1_x4 1 2179 0 2292 2260 sff1_x4
xsubckt_9175_sff1_x4 1 2113 0 9265 1389 sff1_x4
xfeed_576 1 0 decap_w0
xfeed_575 1 0 decap_w0
xfeed_574 1 0 decap_w0
xfeed_573 1 0 decap_w0
xfeed_572 1 0 tie
xfeed_571 1 0 decap_w0
xfeed_570 1 0 decap_w0
xspare_feed_609 1 0 tie
xspare_feed_608 1 0 tie
xspare_feed_607 1 0 decap_w0
xspare_feed_606 1 0 tie
xspare_feed_605 1 0 tie
xspare_feed_604 1 0 decap_w0
xspare_feed_603 1 0 tie
xspare_feed_602 1 0 tie
xspare_feed_601 1 0 decap_w0
xspare_feed_600 1 0 tie
xsubckt_1187_xr2_x1 7178 0 1 193 224 xr2_x1
xsubckt_519_oa22_x2 0 7819 1 7820 7822 7823 oa22_x2
xsubckt_431_oa22_x2 0 7910 1 7912 54 8402 oa22_x2
xsubckt_19_inv_x0 1 0 135 8392 inv_x0
xsubckt_17_inv_x0 1 0 132 8394 inv_x0
xsubckt_15_inv_x0 1 0 131 8401 inv_x0
xsubckt_996_nand2_x0 1 0 7358 7359 7367 nand2_x0
xsubckt_1159_nand2_x0 1 0 7204 7990 2017 nand2_x0
xsubckt_2901_nand3_x0 1 0 5458 5459 5630 6392 nand3_x0
xsubckt_4010_mx2_x2 0 4368 1 8034 4369 4370 mx2_x2
xsubckt_4012_mx2_x2 0 4366 1 812 1486 1454 mx2_x2
xsubckt_4014_mx2_x2 0 4364 1 8034 4365 4366 mx2_x2
xsubckt_4405_mx2_x2 0 10160 1 4178 6283 1283 mx2_x2
xsubckt_4927_mx3_x2 1 0 3928 6450 545 8373 8191 8192 mx3_x2
xsubckt_5238_nor2_x0 1 0 3656 3657 3659 nor2_x0
xsubckt_5283_mx2_x2 0 3614 1 8277 3615 3895 mx2_x2
xsubckt_5430_ao22_x2 0 3477 1 3478 3490 7884 ao22_x2
xsubckt_5676_mx2_x2 0 3297 1 812 1482 1450 mx2_x2
xsubckt_5678_mx2_x2 0 3295 1 8034 3296 3297 mx2_x2
xsubckt_8275_sff1_x4 1 2238 0 10082 1309 sff1_x4
xsubckt_8798_sff1_x4 1 2079 0 9624 736 sff1_x4
xfeed_579 1 0 decap_w0
xfeed_578 1 0 decap_w0
xfeed_577 1 0 decap_w0
xsubckt_1296_o2_x2 0 7069 1 191 218 o2_x2
xsubckt_1232_nand2_x0 1 0 7133 7134 7138 nand2_x0
xsubckt_2721_nand3_x0 1 0 5635 5636 5639 5949 nand3_x0
xsubckt_4016_mx2_x2 0 4362 1 813 1646 1614 mx2_x2
xsubckt_4018_mx2_x2 0 4360 1 8035 4361 4362 mx2_x2
xsubckt_4361_mx2_x2 0 10198 1 4191 6062 1456 mx2_x2
xsubckt_4363_mx2_x2 0 10196 1 4191 6044 1454 mx2_x2
xsubckt_4407_mx2_x2 0 10158 1 4179 6273 1271 mx2_x2
xsubckt_4409_mx2_x2 0 10156 1 4179 6259 1257 mx2_x2
xsubckt_6849_ao22_x2 0 8820 1 706 8277 658 ao22_x2
xsubckt_8632_sff1_x4 1 2156 0 176 113 sff1_x4
xsubckt_9083_sff1_x4 1 2126 0 9357 898 sff1_x4
xfeed_583 1 0 decap_w0
xfeed_582 1 0 decap_w0
xfeed_581 1 0 decap_w0
xfeed_580 1 0 decap_w0
xspare_feed_619 1 0 decap_w0
xspare_feed_618 1 0 tie
xspare_feed_617 1 0 tie
xspare_feed_616 1 0 decap_w0
xspare_feed_615 1 0 tie
xspare_feed_614 1 0 tie
xspare_feed_613 1 0 decap_w0
xspare_feed_612 1 0 tie
xspare_feed_611 1 0 tie
xspare_feed_610 1 0 decap_w0
xcmpt_abc_30082_new_n3819_hfns_2 1 0 7811 7808 buf_x4
xcmpt_abc_30082_new_n3819_hfns_1 1 0 7808 7809 buf_x4
xcmpt_abc_30082_new_n3819_hfns_0 1 0 7808 7810 buf_x4
xsubckt_1939_nand2_x0 1 0 6462 439 330 nand2_x0
xsubckt_548_nand2_x0 1 0 7788 633 1977 nand2_x0
xsubckt_1142_nand2_x0 1 0 7220 629 1919 nand2_x0
xsubckt_3830_mx2_x2 0 4545 1 813 913 881 mx2_x2
xsubckt_4365_mx2_x2 0 10194 1 4191 6027 1451 mx2_x2
xsubckt_4369_mx2_x2 0 10192 1 4186 6283 1731 mx2_x2
xsubckt_6926_nor2_x0 1 0 8765 377 375 nor2_x0
xsubckt_8105_sff1_x4 1 2106 0 10252 1225 sff1_x4
xsubckt_8183_sff1_x4 1 2212 0 10174 1721 sff1_x4
xsubckt_8628_sff1_x4 1 2159 0 180 117 sff1_x4
xsubckt_9005_sff1_x4 1 2123 0 10450 785 sff1_x4
xsubckt_9440_sff1_x4 1 2097 0 9003 1868 sff1_x4
xfeed_589 1 0 decap_w0
xfeed_588 1 0 decap_w0
xfeed_587 1 0 tie
xfeed_586 1 0 tie
xfeed_585 1 0 tie
xfeed_584 1 0 decap_w0
xsubckt_1759_nand2_x0 1 0 6622 7137 7971 nand2_x0
xsubckt_1631_oa22_x2 0 6742 1 6770 6754 6755 oa22_x2
xsubckt_458_nand2_x0 1 0 7874 7888 330 nand2_x0
xsubckt_603_a2_x2 0 7736 1 745 70 a2_x2
xsubckt_623_a2_x2 0 7716 1 7717 7723 a2_x2
xsubckt_711_nand2_x0 1 0 7632 634 1916 nand2_x0
xsubckt_3050_mx2_x2 0 5312 1 814 927 895 mx2_x2
xsubckt_3052_mx2_x2 0 5310 1 8035 5311 5312 mx2_x2
xsubckt_3832_mx2_x2 0 4543 1 8035 4544 4545 mx2_x2
xsubckt_3834_mx2_x2 0 4541 1 814 1489 1457 mx2_x2
xsubckt_3836_mx2_x2 0 4539 1 8035 4540 4541 mx2_x2
xsubckt_6915_oa22_x2 0 8773 1 8811 8785 8774 oa22_x2
xsubckt_7211_nor2_x0 1 0 8607 564 577 nor2_x0
xsubckt_7400_mx2_x2 0 9437 1 8495 6143 1562 mx2_x2
xsubckt_8179_sff1_x4 1 2212 0 10178 1725 sff1_x4
xsubckt_8540_sff1_x4 1 2156 0 9817 139 sff1_x4
xsubckt_9079_sff1_x4 1 2063 0 10463 1909 sff1_x4
xsubckt_9436_sff1_x4 1 2138 0 9007 906 sff1_x4
xfeed_590 1 0 decap_w0
xspare_feed_629 1 0 tie
xspare_feed_628 1 0 decap_w0
xspare_feed_627 1 0 tie
xspare_feed_626 1 0 tie
xspare_feed_625 1 0 decap_w0
xspare_feed_624 1 0 tie
xspare_feed_623 1 0 tie
xspare_feed_622 1 0 decap_w0
xspare_feed_621 1 0 tie
xspare_feed_620 1 0 tie
xsubckt_1922_nand2_x0 1 0 465 6476 6477 nand2_x0
xsubckt_1669_nand2_x0 1 0 2312 6707 6711 nand2_x0
xsubckt_770_oa22_x2 0 7573 1 7574 7614 8284 oa22_x2
xsubckt_2804_nand2_x0 1 0 5554 5555 784 nand2_x0
xsubckt_2982_nand2_x0 1 0 5379 5380 784 nand2_x0
xsubckt_3054_mx2_x2 0 5308 1 815 1503 1471 mx2_x2
xsubckt_3056_mx2_x2 0 5306 1 8036 5307 5308 mx2_x2
xsubckt_3058_mx2_x2 0 5304 1 815 1663 1631 mx2_x2
xsubckt_3838_mx2_x2 0 4537 1 815 1649 1617 mx2_x2
xsubckt_5054_nor2_x0 1 0 3827 3828 3831 nor2_x0
xsubckt_6466_oa22_x2 0 2559 1 46 1906 201 oa22_x2
xsubckt_6851_nand2_x0 1 0 8818 8828 393 nand2_x0
xsubckt_7402_mx2_x2 0 9435 1 8495 6125 1560 mx2_x2
xsubckt_7404_mx2_x2 0 9433 1 8495 6108 1557 mx2_x2
xsubckt_7406_mx2_x2 0 9431 1 8495 6089 1555 mx2_x2
xsubckt_8013_sff1_x4 1 2189 0 10344 1125 sff1_x4
xsubckt_8091_sff1_x4 1 2212 0 10266 1172 sff1_x4
xsubckt_8536_sff1_x4 1 2156 0 9821 143 sff1_x4
xsubckt_8971_sff1_x4 1 2095 0 9454 1571 sff1_x4
xfeed_599 1 0 decap_w0
xfeed_598 1 0 tie
xfeed_597 1 0 decap_w0
xfeed_596 1 0 tie
xfeed_595 1 0 tie
xfeed_594 1 0 decap_w0
xfeed_593 1 0 decap_w0
xfeed_592 1 0 tie
xfeed_591 1 0 decap_w0
xsubckt_1832_nand2_x0 1 0 6554 6557 8078 nand2_x0
xsubckt_1579_nand2_x0 1 0 6790 7079 7972 nand2_x0
xsubckt_1489_nand2_x0 1 0 6874 7050 7972 nand2_x0
xsubckt_254_inv_x0 1 0 2008 8122 inv_x0
xsubckt_252_inv_x0 1 0 416 8124 inv_x0
xsubckt_250_inv_x0 1 0 2009 8126 inv_x0
xsubckt_957_a2_x2 0 7395 1 7396 7402 a2_x2
xsubckt_977_a2_x2 0 7376 1 7377 7385 a2_x2
xsubckt_2521_mx2_x2 0 5832 1 817 1708 1676 mx2_x2
xsubckt_2523_mx2_x2 0 5830 1 791 5831 5832 mx2_x2
xsubckt_2624_nand2_x0 1 0 5731 222 741 nand2_x0
xsubckt_2714_nand2_x0 1 0 5642 5643 8025 nand2_x0
xsubckt_2958_oa22_x2 0 5402 1 5403 5442 5958 oa22_x2
xsubckt_2978_nand3_x0 1 0 5383 569 8289 90 nand3_x0
xsubckt_3506_nand2_x0 1 0 10396 4864 4923 nand2_x0
xsubckt_5043_oa22_x2 0 3837 1 700 3839 3838 oa22_x2
xsubckt_5411_nor2_x0 1 0 3495 3497 8295 nor2_x0
xsubckt_7362_mx2_x2 0 9473 1 8499 6179 1598 mx2_x2
xsubckt_7408_mx2_x2 0 9429 1 8495 6070 1553 mx2_x2
xsubckt_7493_mx3_x2 1 0 9318 8482 6295 1093 6226 6229 mx3_x2
xsubckt_7495_mx3_x2 1 0 9316 8482 6295 1121 6205 6210 mx3_x2
xsubckt_7751_mx2_x2 0 9075 1 8444 6054 975 mx2_x2
xsubckt_7753_mx2_x2 0 9073 1 8443 6034 973 mx2_x2
xsubckt_7755_mx2_x2 0 9071 1 8444 6018 970 mx2_x2
xsubckt_8087_sff1_x4 1 2242 0 10270 1177 sff1_x4
xsubckt_9344_sff1_x4 1 2103 0 9099 972 sff1_x4
xspare_feed_639 1 0 tie
xspare_feed_638 1 0 tie
xspare_feed_637 1 0 decap_w0
xspare_feed_636 1 0 tie
xspare_feed_635 1 0 tie
xspare_feed_634 1 0 decap_w0
xspare_feed_633 1 0 tie
xspare_feed_632 1 0 tie
xspare_feed_631 1 0 decap_w0
xspare_feed_630 1 0 tie
xsubckt_2138_mx2_x2 0 10456 1 6440 9401 711 mx2_x2
xsubckt_2136_mx2_x2 0 10457 1 6439 9402 712 mx2_x2
xsubckt_1742_nand2_x0 1 0 6638 7131 7972 nand2_x0
xsubckt_1652_nand2_x0 1 0 6722 7101 7972 nand2_x0
xsubckt_1419_a4_x2 0 6940 1 6945 6950 7974 8009 a4_x2
xsubckt_258_inv_x0 1 0 220 8118 inv_x0
xsubckt_256_inv_x0 1 0 402 8120 inv_x0
xsubckt_2481_mx2_x2 0 5871 1 818 1303 1271 mx2_x2
xsubckt_2525_mx2_x2 0 5828 1 818 908 876 mx2_x2
xsubckt_2527_mx2_x2 0 5826 1 779 5827 5830 mx2_x2
xsubckt_2529_mx2_x2 0 5824 1 818 1036 1004 mx2_x2
xsubckt_2870_mx2_x2 0 5489 1 790 5490 5491 mx2_x2
xsubckt_2872_mx2_x2 0 5487 1 819 900 868 mx2_x2
xsubckt_3326_nand2_x0 1 0 5041 5994 240 nand2_x0
xsubckt_4810_a4_x2 0 4013 1 4016 4028 4142 1942 a4_x2
xsubckt_5242_ao22_x2 0 3652 1 3653 3664 7885 ao22_x2
xsubckt_5607_nand3_x0 1 0 3355 3360 1992 1993 nand3_x0
xsubckt_6138_ao22_x2 0 2877 1 574 568 763 ao22_x2
xsubckt_6897_oa22_x2 0 9656 1 8823 8789 8787 oa22_x2
xsubckt_7364_mx2_x2 0 9471 1 8500 6162 1596 mx2_x2
xsubckt_7366_mx2_x2 0 9469 1 8500 6143 1594 mx2_x2
xsubckt_7368_mx2_x2 0 9467 1 8500 6125 1592 mx2_x2
xsubckt_7759_mx2_x2 0 9069 1 8439 6278 962 mx2_x2
xsubckt_8009_sff1_x4 1 2106 0 10348 1129 sff1_x4
xsubckt_8444_sff1_x4 1 2044 0 9913 1962 sff1_x4
xsubckt_8967_sff1_x4 1 2108 0 9458 1582 sff1_x4
xcmpt_abc_30082_new_n10423_hfns_2 1 0 8644 8641 buf_x4
xcmpt_abc_30082_new_n10423_hfns_1 1 0 8641 8642 buf_x4
xcmpt_abc_30082_new_n10423_hfns_0 1 0 8641 8643 buf_x4
xsubckt_2444_nand2_x0 1 0 5907 5922 8012 nand2_x0
xsubckt_2092_mx2_x2 0 6354 1 562 6355 709 mx2_x2
xsubckt_2090_mx2_x2 0 6356 1 823 6357 6372 mx2_x2
xsubckt_2015_a2_x2 0 6432 1 6433 7869 a2_x2
xsubckt_1301_a2_x2 0 7064 1 439 220 a2_x2
xsubckt_476_o2_x2 0 7861 1 58 59 o2_x2
xsubckt_2483_mx2_x2 0 5869 1 788 5870 5871 mx2_x2
xsubckt_2485_mx2_x2 0 5867 1 818 1239 1207 mx2_x2
xsubckt_2487_mx2_x2 0 5865 1 8021 5866 5869 mx2_x2
xsubckt_2874_mx2_x2 0 5485 1 8028 5486 5487 mx2_x2
xsubckt_2876_mx2_x2 0 5483 1 818 1476 1444 mx2_x2
xsubckt_2878_mx2_x2 0 5481 1 8028 5482 5483 mx2_x2
xsubckt_4118_nand2_x0 1 0 4262 4263 783 nand2_x0
xsubckt_4675_a4_x2 0 4116 1 4118 4124 4129 4143 a4_x2
xsubckt_6051_mx2_x2 0 2962 1 853 1312 1280 mx2_x2
xsubckt_6440_mx2_x2 0 2584 1 8226 2585 2586 mx2_x2
xsubckt_6442_mx2_x2 0 2582 1 848 1044 1012 mx2_x2
xsubckt_6444_mx2_x2 0 2580 1 8211 2581 2584 mx2_x2
xsubckt_6831_mx2_x2 0 9671 1 6440 8838 662 mx2_x2
xsubckt_6962_a4_x2 0 8737 1 578 395 8259 393 a4_x2
xsubckt_8801_sff1_x4 1 2079 0 9621 733 sff1_x4
xsubckt_9252_sff1_x4 1 2198 0 9188 1441 sff1_x4
xspare_feed_649 1 0 decap_w0
xspare_feed_648 1 0 tie
xspare_feed_647 1 0 tie
xspare_feed_646 1 0 decap_w0
xspare_feed_645 1 0 tie
xspare_feed_644 1 0 tie
xspare_feed_643 1 0 decap_w0
xspare_feed_642 1 0 tie
xspare_feed_641 1 0 tie
xspare_feed_640 1 0 decap_w0
xcmpt_abc_30082_new_n5461_hfns_1 1 0 6264 6265 buf_x4
xcmpt_abc_30082_new_n5461_hfns_0 1 0 6264 6266 buf_x4
xcmpt_abc_30082_new_n5505_hfns_2 1 0 6190 6187 buf_x4
xcmpt_abc_30082_new_n5505_hfns_1 1 0 6187 6188 buf_x4
xcmpt_abc_30082_new_n5505_hfns_0 1 0 6187 6189 buf_x4
xsubckt_2250_nand4_x0 1 0 6146 6174 86 85 84 nand4_x0
xsubckt_2055_a2_x2 0 6393 1 7859 1899 a2_x2
xsubckt_1950_mx2_x2 0 452 1 7807 201 439 mx2_x2
xsubckt_1472_nand2_x0 1 0 6890 7041 7971 nand2_x0
xsubckt_1443_oa22_x2 0 2319 1 6940 6918 6930 oa22_x2
xsubckt_510_nand3_x0 1 0 7827 7897 7900 7910 nand3_x0
xsubckt_600_nand3_x0 1 0 175 7739 7747 7754 nand3_x0
xsubckt_878_nand2_x0 1 0 7470 634 1970 nand2_x0
xsubckt_925_o2_x2 0 7426 1 7427 7429 o2_x2
xsubckt_2489_mx2_x2 0 5863 1 817 1655 1623 mx2_x2
xsubckt_2737_xr2_x1 5620 0 1 220 739 xr2_x1
xsubckt_3146_nand2_x0 1 0 10402 5218 5277 nand2_x0
xsubckt_5291_a2_x2 0 3607 1 3608 3609 a2_x2
xsubckt_5505_a2_x2 0 9788 1 3426 51 a2_x2
xsubckt_5525_a2_x2 0 9782 1 3412 3413 a2_x2
xsubckt_5911_mx2_x2 0 3098 1 8224 3099 3100 mx2_x2
xsubckt_6053_mx2_x2 0 2960 1 851 1248 1216 mx2_x2
xsubckt_6055_mx2_x2 0 2958 1 8224 2959 2960 mx2_x2
xsubckt_6057_mx2_x2 0 2956 1 851 1664 1632 mx2_x2
xsubckt_6446_mx2_x2 0 2578 1 851 1364 1332 mx2_x2
xsubckt_6448_mx2_x2 0 2576 1 8224 2577 2578 mx2_x2
xsubckt_6791_mx2_x2 0 8864 1 1906 8865 7866 mx2_x2
xsubckt_6855_a3_x2 1 8815 0 395 8259 393 a3_x2
xsubckt_7975_sff1_x4 1 2095 0 10382 1783 sff1_x4
xsubckt_8352_sff1_x4 1 2132 0 10005 1327 sff1_x4
xsubckt_8875_sff1_x4 1 2150 0 9550 361 sff1_x4
xcmpt_abc_30082_new_n5461_hfns_2 1 0 6267 6264 buf_x4
xsubckt_2150_o3_x2 0 6308 1 551 552 553 o3_x2
xsubckt_1635_a2_x2 0 6738 1 6739 243 a2_x2
xsubckt_679_mx2_x2 0 7663 1 216 425 407 mx2_x2
xsubckt_788_nand2_x0 1 0 7556 7809 428 nand2_x0
xsubckt_2781_nand3_x0 1 0 5576 5588 5592 772 nand3_x0
xsubckt_3922_a2_x2 0 4454 1 4455 4460 a2_x2
xsubckt_4676_a2_x2 0 4115 1 4116 1915 a2_x2
xsubckt_4831_a2_x2 0 3998 1 1938 1937 a2_x2
xsubckt_4851_a2_x2 0 9885 1 3983 42 a2_x2
xsubckt_5161_nand2_x0 1 0 3728 3729 8293 nand2_x0
xsubckt_5304_oa22_x2 0 3595 1 3606 3604 3605 oa22_x2
xsubckt_5337_nand3_x0 1 0 3565 42 138 8397 nand3_x0
xsubckt_5545_a2_x2 0 9775 1 3399 42 a2_x2
xsubckt_5581_ao22_x2 0 3373 1 3377 2001 42 ao22_x2
xsubckt_5585_a2_x2 0 9763 1 3371 42 a2_x2
xsubckt_5913_mx2_x2 0 3096 1 857 1638 1606 mx2_x2
xsubckt_5915_mx2_x2 0 3094 1 8225 3095 3096 mx2_x2
xsubckt_5917_mx2_x2 0 3092 1 857 1414 1382 mx2_x2
xsubckt_6059_mx2_x2 0 2954 1 8225 2955 2956 mx2_x2
xsubckt_6795_mx2_x2 0 8860 1 8864 8861 8405 mx2_x2
xsubckt_6875_a3_x2 1 8801 0 8802 8803 8804 a3_x2
xsubckt_6943_a2_x2 0 9645 1 8752 42 a2_x2
xsubckt_7178_oa22_x2 0 8631 1 42 8300 8144 oa22_x2
xsubckt_8348_sff1_x4 1 2139 0 10009 1331 sff1_x4
xsubckt_9160_sff1_x4 1 2238 0 9280 1405 sff1_x4
xsubckt_9248_sff1_x4 1 2218 0 9192 1415 sff1_x4
xspare_feed_659 1 0 tie
xspare_feed_658 1 0 decap_w0
xspare_feed_657 1 0 tie
xspare_feed_656 1 0 tie
xspare_feed_655 1 0 decap_w0
xspare_feed_654 1 0 tie
xspare_feed_653 1 0 tie
xspare_feed_652 1 0 decap_w0
xspare_feed_651 1 0 tie
xspare_feed_650 1 0 tie
xsubckt_1638_ao22_x2 0 6735 1 6743 6742 6737 ao22_x2
xsubckt_951_nand2_x0 1 0 7401 7991 2030 nand2_x0
xsubckt_1024_nand2_x0 1 0 7332 7333 1894 nand2_x0
xsubckt_3094_nxr2_x1 5269 1 0 244 763 nxr2_x1
xsubckt_3982_a2_x2 0 4395 1 4396 4398 a2_x2
xsubckt_4011_nand2_x0 1 0 4367 4368 8024 nand2_x0
xsubckt_4600_mx2_x2 0 9977 1 4152 6088 1491 mx2_x2
xsubckt_4696_a2_x2 0 4100 1 4104 1972 a2_x2
xsubckt_4769_ao22_x2 0 4045 1 4047 8329 1952 ao22_x2
xsubckt_5223_nor2_x0 1 0 3670 3671 3674 nor2_x0
xsubckt_5500_nand3_x0 1 0 3429 3433 2028 2030 nand3_x0
xsubckt_5871_mx2_x2 0 3137 1 856 1287 1255 mx2_x2
xsubckt_5873_mx2_x2 0 3135 1 856 1223 1191 mx2_x2
xsubckt_5919_mx2_x2 0 3090 1 8214 3091 3094 mx2_x2
xsubckt_7012_oa22_x2 0 8695 1 8244 701 8419 oa22_x2
xsubckt_8260_sff1_x4 1 2109 0 10097 1674 sff1_x4
xsubckt_8705_sff1_x4 1 2086 0 9685 199 sff1_x4
xsubckt_8783_sff1_x4 1 2073 0 9639 619 sff1_x4
xsubckt_1308_nxr2_x1 7057 1 0 440 221 nxr2_x1
xsubckt_1220_nxr2_x1 7145 1 0 199 231 nxr2_x1
xsubckt_777_ao22_x2 0 7566 1 7567 7571 7795 ao22_x2
xsubckt_3746_nand2_x0 1 0 10392 4628 4687 nand2_x0
xsubckt_4211_mx2_x2 0 10336 1 4214 6151 1147 mx2_x2
xsubckt_4213_mx2_x2 0 10334 1 4215 6134 1145 mx2_x2
xsubckt_4342_mx3_x2 1 0 10217 4193 6290 1446 6236 6239 mx3_x2
xsubckt_4344_mx3_x2 1 0 10215 4193 6289 1444 6216 6220 mx3_x2
xsubckt_4346_mx3_x2 1 0 10213 4193 6289 1472 6197 6201 mx3_x2
xsubckt_4602_mx2_x2 0 9975 1 4152 6071 1489 mx2_x2
xsubckt_4604_mx2_x2 0 9973 1 4152 6053 1487 mx2_x2
xsubckt_4606_mx2_x2 0 9971 1 4152 6035 1485 mx2_x2
xsubckt_5297_nor2_x0 1 0 3601 3602 3603 nor2_x0
xsubckt_5875_mx2_x2 0 3133 1 8218 3134 3135 mx2_x2
xsubckt_5877_mx2_x2 0 3131 1 855 1639 1607 mx2_x2
xsubckt_5879_mx2_x2 0 3129 1 8226 3130 3131 mx2_x2
xsubckt_6247_o2_x2 0 2771 1 2772 7931 o2_x2
xsubckt_7008_oa22_x2 0 8698 1 8245 701 8298 oa22_x2
xsubckt_8256_sff1_x4 1 2123 0 10101 1679 sff1_x4
xsubckt_8691_sff1_x4 1 2166 0 9699 213 sff1_x4
xsubckt_8779_sff1_x4 1 2070 0 9643 623 sff1_x4
xsubckt_9156_sff1_x4 1 2198 0 9284 1409 sff1_x4
xspare_feed_669 1 0 tie
xspare_feed_668 1 0 tie
xspare_feed_667 1 0 decap_w0
xspare_feed_666 1 0 tie
xspare_feed_665 1 0 tie
xspare_feed_664 1 0 decap_w0
xspare_feed_663 1 0 tie
xspare_feed_662 1 0 tie
xspare_feed_661 1 0 decap_w0
xspare_feed_660 1 0 tie
xsubckt_2243_nand3_x0 1 0 6155 6174 86 85 nand3_x0
xsubckt_1804_nand2_x0 1 0 6580 7147 7972 nand2_x0
xsubckt_1294_nxr2_x1 7071 1 0 192 219 nxr2_x1
xsubckt_2604_oa22_x2 0 5750 1 5799 5795 5798 oa22_x2
xsubckt_3930_o2_x2 0 4447 1 229 748 o2_x2
xsubckt_4171_mx2_x2 0 10370 1 4224 6169 1789 mx2_x2
xsubckt_4215_mx2_x2 0 10332 1 4215 6116 1142 mx2_x2
xsubckt_4217_mx2_x2 0 10330 1 4215 6097 1140 mx2_x2
xsubckt_4219_mx2_x2 0 10328 1 4215 6081 1138 mx2_x2
xsubckt_4560_mx2_x2 0 10015 1 4157 6143 1338 mx2_x2
xsubckt_4562_mx2_x2 0 10013 1 4157 6124 1336 mx2_x2
xsubckt_4608_mx2_x2 0 9969 1 4152 6017 1482 mx2_x2
xsubckt_5604_nxr2_x1 3357 1 0 3360 8093 nxr2_x1
xsubckt_8613_sff1_x4 1 2083 0 187 124 sff1_x4
xsubckt_9064_sff1_x4 1 2145 0 9366 1362 sff1_x4
xsubckt_1892_nand2_x0 1 0 6498 7179 7972 nand2_x0
xsubckt_1714_nand2_x0 1 0 2309 6665 6669 nand2_x0
xsubckt_1683_o2_x2 0 2311 1 6694 6698 o2_x2
xsubckt_1216_nxr2_x1 7149 1 0 200 232 nxr2_x1
xsubckt_413_nand2_x0 1 0 7932 1905 44 nand2_x0
xsubckt_3566_nand2_x0 1 0 4805 5994 235 nand2_x0
xsubckt_4173_mx2_x2 0 10368 1 4224 6152 1787 mx2_x2
xsubckt_4175_mx2_x2 0 10366 1 4224 6135 1785 mx2_x2
xsubckt_4564_mx2_x2 0 10011 1 4157 6108 1333 mx2_x2
xsubckt_4566_mx2_x2 0 10009 1 4157 6089 1331 mx2_x2
xsubckt_4568_mx2_x2 0 10007 1 4157 6071 1329 mx2_x2
xsubckt_5643_oa22_x2 0 3330 1 4279 4277 4278 oa22_x2
xsubckt_5887_o2_x2 0 3121 1 3122 7931 o2_x2
xsubckt_7345_nand2_x0 1 0 8503 8504 8506 nand2_x0
xsubckt_8164_sff1_x4 1 2112 0 10193 1450 sff1_x4
xsubckt_8687_sff1_x4 1 2172 0 9703 439 sff1_x4
xsubckt_9421_sff1_x4 1 2203 0 9022 923 sff1_x4
xspare_feed_679 1 0 decap_w0
xspare_feed_678 1 0 tie
xspare_feed_677 1 0 tie
xspare_feed_676 1 0 decap_w0
xspare_feed_675 1 0 tie
xspare_feed_674 1 0 tie
xspare_feed_673 1 0 decap_w0
xspare_feed_672 1 0 tie
xspare_feed_671 1 0 tie
xspare_feed_670 1 0 decap_w0
xcmpt_abc_30082_new_n3629_hfns_6 1 0 8026 8019 buf_x4
xcmpt_abc_30082_new_n3629_hfns_5 1 0 8019 8020 buf_x4
xcmpt_abc_30082_new_n3629_hfns_4 1 0 8019 8021 buf_x4
xcmpt_abc_30082_new_n3629_hfns_3 1 0 8019 8022 buf_x4
xcmpt_abc_30082_new_n3629_hfns_2 1 0 8019 8023 buf_x4
xcmpt_abc_30082_new_n3629_hfns_1 1 0 8019 8024 buf_x4
xcmpt_abc_30082_new_n3629_hfns_0 1 0 8019 8025 buf_x4
xsubckt_1534_nand2_x0 1 0 6832 7063 7971 nand2_x0
xsubckt_493_a3_x2 1 10465 0 7844 7936 7942 a3_x2
xsubckt_1003_nand3_x0 1 0 7352 7353 7354 1902 nand3_x0
xsubckt_3386_nand2_x0 1 0 10398 4982 5041 nand2_x0
xsubckt_3640_mx2_x2 0 4732 1 787 4733 4734 mx2_x2
xsubckt_3642_mx2_x2 0 4730 1 798 1876 1524 mx2_x2
xsubckt_4177_mx2_x2 0 10364 1 4224 6116 1782 mx2_x2
xsubckt_4179_mx2_x2 0 10362 1 4224 6098 1780 mx2_x2
xsubckt_5403_nand2_x0 1 0 3503 3513 3523 nand2_x0
xsubckt_5562_nor2_x0 1 0 9770 3387 3388 nor2_x0
xsubckt_7115_ao22_x2 0 8659 1 706 8279 43 ao22_x2
xsubckt_7732_mx3_x2 1 0 9094 8446 6292 965 6225 6229 mx3_x2
xsubckt_8521_sff1_x4 1 2159 0 9836 129 sff1_x4
xsubckt_8609_sff1_x4 1 2044 0 9748 1983 sff1_x4
xsubckt_9495_sff1_x4 1 2129 0 8948 1840 sff1_x4
xsubckt_100_inv_x0 1 0 1921 8311 inv_x0
xsubckt_102_inv_x0 1 0 1954 8309 inv_x0
xsubckt_104_inv_x0 1 0 1976 8307 inv_x0
xsubckt_541_a2_x2 0 7798 1 330 249 a2_x2
xsubckt_2455_nxr2_x1 5896 1 0 767 217 nxr2_x1
xsubckt_3644_mx2_x2 0 4728 1 8034 4729 4730 mx2_x2
xsubckt_3646_mx2_x2 0 4726 1 797 1716 1684 mx2_x2
xsubckt_3648_mx2_x2 0 4724 1 788 4725 4726 mx2_x2
xsubckt_5063_nxr2_x1 3819 1 0 3835 3940 nxr2_x1
xsubckt_7601_mx2_x2 0 9216 1 8465 6170 1085 mx2_x2
xsubckt_7603_mx2_x2 0 9214 1 8465 6152 1083 mx2_x2
xsubckt_7605_mx2_x2 0 9212 1 8465 6135 1081 mx2_x2
xsubckt_7734_mx3_x2 1 0 9092 8446 6292 993 6206 6209 mx3_x2
xsubckt_7858_nand4_x0 1 0 8426 8300 43 366 365 nand4_x0
xsubckt_8072_sff1_x4 1 2097 0 10285 1164 sff1_x4
xsubckt_8595_sff1_x4 1 2047 0 9762 1999 sff1_x4
xsubckt_9417_sff1_x4 1 2222 0 9026 927 sff1_x4
xspare_feed_689 1 0 tie
xspare_feed_688 1 0 decap_w0
xspare_feed_687 1 0 tie
xspare_feed_686 1 0 tie
xspare_feed_685 1 0 decap_w0
xspare_feed_684 1 0 tie
xspare_feed_683 1 0 tie
xspare_feed_682 1 0 decap_w0
xspare_feed_681 1 0 tie
xspare_feed_680 1 0 tie
xsubckt_2331_mx2_x2 0 6041 1 545 102 2266 mx2_x2
xsubckt_2059_oa22_x2 0 317 1 8283 6394 6387 oa22_x2
xsubckt_1871_nand3_x0 1 0 6518 6545 8051 8052 nand3_x0
xsubckt_1520_oa22_x2 0 6846 1 6860 6854 6855 oa22_x2
xsubckt_1362_ao22_x2 0 7003 1 7004 7019 7103 ao22_x2
xsubckt_1354_nand2_x0 1 0 7011 211 8105 nand2_x0
xsubckt_106_inv_x0 1 0 54 8305 inv_x0
xsubckt_108_inv_x0 1 0 364 8303 inv_x0
xsubckt_3997_mx2_x2 0 4381 1 821 1038 1006 mx2_x2
xsubckt_4686_nxr2_x1 4108 1 0 4111 8314 nxr2_x1
xsubckt_5133_nand2_x0 1 0 3754 3755 8295 nand2_x0
xsubckt_7216_mx2_x2 0 9517 1 8832 8603 743 mx2_x2
xsubckt_7607_mx2_x2 0 9210 1 8464 6116 1078 mx2_x2
xsubckt_7609_mx2_x2 0 9208 1 8464 6098 1076 mx2_x2
xsubckt_8517_sff1_x4 1 2163 0 9840 155 sff1_x4
xsubckt_8952_sff1_x4 1 2245 0 9473 1598 sff1_x4
xcmpt_abc_30082_new_n7899_hfns_2 1 0 4148 4145 buf_x4
xcmpt_abc_30082_new_n7899_hfns_1 1 0 4145 4146 buf_x4
xcmpt_abc_30082_new_n7899_hfns_0 1 0 4145 4147 buf_x4
xsubckt_2337_mx2_x2 0 10418 1 6300 6035 1805 mx2_x2
xsubckt_2056_nand2_x0 1 0 6389 7859 1898 nand2_x0
xsubckt_480_nand3_x0 1 0 7854 7860 7863 1898 nand3_x0
xsubckt_2851_oa22_x2 0 5508 1 5566 5564 5563 oa22_x2
xsubckt_4647_oa22_x2 0 4136 1 1912 703 1977 oa22_x2
xsubckt_5024_oa22_x2 0 3855 1 8294 3949 8276 oa22_x2
xsubckt_7324_nand3_x0 1 0 8520 8521 8244 703 nand3_x0
xsubckt_7565_mx2_x2 0 9250 1 8470 6188 1215 mx2_x2
xsubckt_7567_mx2_x2 0 9248 1 8470 6169 1213 mx2_x2
xsubckt_7569_mx2_x2 0 9246 1 8470 6151 1211 mx2_x2
xsubckt_7698_mx3_x2 1 0 9126 8451 6293 997 6226 6229 mx3_x2
xsubckt_8068_sff1_x4 1 2108 0 10289 1738 sff1_x4
xsubckt_8425_sff1_x4 1 2057 0 9932 1954 sff1_x4
xsubckt_8948_sff1_x4 1 2235 0 9477 1572 sff1_x4
xsubckt_9325_sff1_x4 1 2216 0 9115 1016 sff1_x4
xspare_feed_699 1 0 tie
xspare_feed_698 1 0 tie
xspare_feed_697 1 0 decap_w0
xspare_feed_696 1 0 tie
xspare_feed_695 1 0 tie
xspare_feed_694 1 0 decap_w0
xspare_feed_693 1 0 tie
xspare_feed_692 1 0 tie
xspare_feed_691 1 0 decap_w0
xspare_feed_690 1 0 tie
xsubckt_2295_mx2_x2 0 10424 1 6299 6088 1811 mx2_x2
xsubckt_833_nand2_x0 1 0 7513 633 1972 nand2_x0
xsubckt_946_ao22_x2 0 7406 1 7408 7411 1902 ao22_x2
xsubckt_1084_nand2_x0 1 0 7275 7990 2022 nand2_x0
xsubckt_2684_mx2_x2 0 5672 1 820 1031 999 mx2_x2
xsubckt_2926_nand2_x0 1 0 5434 5435 8023 nand2_x0
xsubckt_3101_nand2_x0 1 0 5262 5263 780 nand2_x0
xsubckt_3694_nxr2_x1 4679 1 0 233 752 nxr2_x1
xsubckt_4778_nand2_x0 1 0 4037 4040 8331 nand2_x0
xsubckt_4807_a4_x2 0 4016 1 1947 1946 1945 1944 a4_x2
xsubckt_5609_a3_x2 1 9756 0 3354 3355 47 a3_x2
xsubckt_5890_oa22_x2 0 3119 1 47 1905 439 oa22_x2
xsubckt_6252_mx2_x2 0 2767 1 858 1850 1818 mx2_x2
xsubckt_6641_mx2_x2 0 2388 1 8206 2389 2404 mx2_x2
xsubckt_6880_a4_x2 0 8797 1 8827 8245 571 702 a4_x2
xsubckt_7960_sff1_x4 1 2166 0 10397 239 sff1_x4
xsubckt_8499_sff1_x4 1 2159 0 9858 87 sff1_x4
xsubckt_8860_sff1_x4 1 2053 0 9565 578 sff1_x4
xsubckt_9399_sff1_x4 1 2129 0 9044 944 sff1_x4
xsubckt_1954_nand2_x0 1 0 450 6458 6485 nand2_x0
xsubckt_655_oa22_x2 0 7686 1 7806 7939 8230 oa22_x2
xsubckt_2688_mx2_x2 0 5668 1 809 1159 1063 mx2_x2
xsubckt_2847_oa22_x2 0 5511 1 5512 5559 5993 oa22_x2
xsubckt_3331_a2_x2 0 5036 1 240 759 a2_x2
xsubckt_3896_nand2_x0 1 0 4480 4481 781 nand2_x0
xsubckt_5248_a2_x2 0 3647 1 3900 713 a2_x2
xsubckt_5423_a2_x2 0 3484 1 3865 8268 a2_x2
xsubckt_6177_a2_x2 0 9696 1 2840 2874 a2_x2
xsubckt_6254_mx2_x2 0 2765 1 863 1722 1690 mx2_x2
xsubckt_6256_mx2_x2 0 2763 1 835 2764 2765 mx2_x2
xsubckt_6258_mx2_x2 0 2761 1 863 1882 1530 mx2_x2
xsubckt_6647_mx2_x2 0 2383 1 863 910 878 mx2_x2
xsubckt_6649_mx2_x2 0 2381 1 8222 2382 2383 mx2_x2
xsubckt_6911_ao22_x2 0 8776 1 706 8279 612 ao22_x2
xsubckt_8333_sff1_x4 1 2198 0 10024 1317 sff1_x4
xsubckt_8856_sff1_x4 1 2111 0 9569 1517 sff1_x4
xsubckt_9233_sff1_x4 1 2136 0 9207 1075 sff1_x4
xsubckt_1864_nand2_x0 1 0 6524 6942 7171 nand2_x0
xsubckt_1398_a2_x2 0 6967 1 468 249 a2_x2
xsubckt_1230_xr2_x1 7135 0 1 202 234 xr2_x1
xsubckt_2911_a2_x2 0 5449 1 247 766 a2_x2
xsubckt_3132_oa22_x2 0 5231 1 5232 5233 776 oa22_x2
xsubckt_4828_a2_x2 0 9891 1 4000 46 a2_x2
xsubckt_5288_a2_x2 0 3610 1 3624 3891 a2_x2
xsubckt_5721_mx2_x2 0 3280 1 7843 8297 506 mx2_x2
xsubckt_6462_ao22_x2 0 2562 1 574 567 753 ao22_x2
xsubckt_7956_sff1_x4 1 2163 0 10401 243 sff1_x4
xsubckt_9141_sff1_x4 1 2132 0 9299 1103 sff1_x4
xsubckt_9229_sff1_x4 1 2222 0 9211 1080 sff1_x4
xsubckt_1887_a2_x2 0 6503 1 6504 8416 a2_x2
xsubckt_1847_a2_x2 0 6540 1 6541 228 a2_x2
xsubckt_1774_nand2_x0 1 0 2304 6609 6613 nand2_x0
xsubckt_473_nand2_x0 1 0 7864 7865 7933 nand2_x0
xsubckt_383_nand2_x0 1 0 7962 7963 7978 nand2_x0
xsubckt_20_inv_x0 1 0 136 8391 inv_x0
xsubckt_2566_nand2_x0 1 0 5787 5788 5789 nand2_x0
xsubckt_3701_nand2_x0 1 0 4672 4673 784 nand2_x0
xsubckt_4140_nand3_x0 1 0 4240 4250 4254 771 nand3_x0
xsubckt_4888_a2_x2 0 3956 1 3957 46 a2_x2
xsubckt_5681_mx2_x2 0 3292 1 8012 3293 3308 mx2_x2
xsubckt_8241_sff1_x4 1 2222 0 10116 1695 sff1_x4
xsubckt_8329_sff1_x4 1 2126 0 10028 1321 sff1_x4
xsubckt_8764_sff1_x4 1 2073 0 9658 645 sff1_x4
xsubckt_1201_nxr2_x1 7164 1 0 196 228 nxr2_x1
xsubckt_26_inv_x0 1 0 142 8385 inv_x0
xsubckt_24_inv_x0 1 0 140 8387 inv_x0
xsubckt_22_inv_x0 1 0 138 8389 inv_x0
xsubckt_2462_nand4_x0 1 0 5889 6008 7859 222 1899 nand4_x0
xsubckt_3327_ao22_x2 0 5040 1 5098 5093 5095 ao22_x2
xsubckt_4021_mx2_x2 0 4357 1 799 1134 1102 mx2_x2
xsubckt_4410_mx2_x2 0 10155 1 4179 6251 1256 mx2_x2
xsubckt_4713_nor3_x0 1 0 9919 4087 4089 8305 nor3_x0
xsubckt_5256_o2_x2 0 9823 1 3640 3651 o2_x2
xsubckt_5431_o2_x2 0 9811 1 3477 3491 o2_x2
xsubckt_5685_mx2_x2 0 9745 1 3331 3289 224 mx2_x2
xsubckt_9137_sff1_x4 1 2145 0 9303 1107 sff1_x4
xsubckt_1798_nxr2_x1 6586 1 0 6590 8083 nxr2_x1
xsubckt_1527_ao22_x2 0 6839 1 6841 6842 220 ao22_x2
xsubckt_1275_nxr2_x1 7090 1 0 211 244 nxr2_x1
xsubckt_1196_xr2_x1 7169 0 1 195 227 xr2_x1
xsubckt_28_inv_x0 1 0 145 8383 inv_x0
xsubckt_994_oa22_x2 0 7360 1 7361 7365 7792 oa22_x2
xsubckt_3521_nand2_x0 1 0 4849 4850 780 nand2_x0
xsubckt_3994_oa22_x2 0 4384 1 4386 4390 7907 oa22_x2
xsubckt_4025_mx2_x2 0 4353 1 806 1294 1262 mx2_x2
xsubckt_4370_mx2_x2 0 10191 1 4186 6278 1730 mx2_x2
xsubckt_4418_mx2_x2 0 10147 1 4179 6179 1278 mx2_x2
xsubckt_5105_nand2_x0 1 0 3780 3781 8295 nand2_x0
xsubckt_7266_ao22_x2 0 8567 1 662 644 391 ao22_x2
xsubckt_8237_sff1_x4 1 2209 0 10120 1669 sff1_x4
xsubckt_8672_sff1_x4 1 2182 0 9717 516 sff1_x4
xsubckt_2335_ao22_x2 0 6037 1 71 6048 6289 ao22_x2
xsubckt_2014_nand4_x0 1 0 6433 6434 7912 53 504 nand4_x0
xsubckt_3341_nand2_x0 1 0 5026 5027 779 nand2_x0
xsubckt_3517_nand3_x0 1 0 4853 568 8289 80 nand3_x0
xsubckt_3916_oa22_x2 0 4460 1 4461 4500 5957 oa22_x2
xsubckt_4372_mx2_x2 0 10189 1 4185 6265 1708 mx2_x2
xsubckt_4374_mx2_x2 0 10187 1 4185 6252 1704 mx2_x2
xsubckt_5193_nand2_x0 1 0 3698 3913 8260 nand2_x0
xsubckt_5267_oa22_x2 0 3629 1 3631 3633 8294 oa22_x2
xsubckt_5466_ao22_x2 0 3452 1 8116 3456 8114 ao22_x2
xsubckt_6499_o2_x2 0 2526 1 2527 7930 o2_x2
xsubckt_6928_o2_x2 0 8763 1 8764 8822 o2_x2
xsubckt_7120_nand2_x0 1 0 8656 8657 49 nand2_x0
xsubckt_8668_sff1_x4 1 2182 0 9721 520 sff1_x4
xsubckt_9045_sff1_x4 1 2245 0 9385 1352 sff1_x4
xsubckt_9480_sff1_x4 1 2192 0 8963 1856 sff1_x4
xsubckt_645_a3_x2 1 7695 0 7696 7697 7698 a3_x2
xsubckt_805_nand2_x0 1 0 7540 7542 7544 nand2_x0
xsubckt_983_nand2_x0 1 0 7371 7372 7375 nand2_x0
xsubckt_3103_mx2_x2 0 5260 1 805 1182 1086 mx2_x2
xsubckt_3107_mx2_x2 0 5256 1 805 1790 1758 mx2_x2
xsubckt_3161_nand2_x0 1 0 5203 5204 783 nand2_x0
xsubckt_3337_nand3_x0 1 0 5030 567 8290 84 nand3_x0
xsubckt_3843_mx2_x2 0 4532 1 805 1137 1105 mx2_x2
xsubckt_6797_ao22_x2 0 8859 1 8422 577 8406 ao22_x2
xsubckt_6955_oa22_x2 0 8742 1 8750 8743 8744 oa22_x2
xsubckt_7800_mx2_x2 0 9030 1 8433 6223 901 mx2_x2
xsubckt_8145_sff1_x4 1 2247 0 10212 1471 sff1_x4
xsubckt_8502_sff1_x4 1 2159 0 9855 84 sff1_x4
xsubckt_8580_sff1_x4 1 2057 0 9777 2015 sff1_x4
xsubckt_9402_sff1_x4 1 2119 0 9041 941 sff1_x4
xsubckt_1926_nand2_x0 1 0 6472 7810 212 nand2_x0
xsubckt_1540_nxr2_x1 6827 1 0 6829 8054 nxr2_x1
xsubckt_303_inv_x0 1 0 227 8073 inv_x0
xsubckt_301_inv_x0 1 0 228 8075 inv_x0
xsubckt_625_nand2_x0 1 0 164 7715 7724 nand2_x0
xsubckt_893_nand2_x0 1 0 7456 241 1899 nand2_x0
xsubckt_2567_oa22_x2 0 5786 1 5793 5792 5787 oa22_x2
xsubckt_2808_nand2_x0 1 0 5550 5551 8020 nand2_x0
xsubckt_2986_nand2_x0 1 0 5375 5376 8020 nand2_x0
xsubckt_3063_mx2_x2 0 5299 1 804 1151 1119 mx2_x2
xsubckt_3847_mx2_x2 0 4528 1 804 1297 1265 mx2_x2
xsubckt_4039_nand3_x0 1 0 4339 4340 4517 7857 nand3_x0
xsubckt_7022_mx2_x2 0 9397 1 7918 413 381 mx2_x2
xsubckt_7411_mx2_x2 0 9426 1 8495 6044 1550 mx2_x2
xsubckt_7413_mx2_x2 0 9424 1 8494 6027 1547 mx2_x2
xsubckt_7804_mx2_x2 0 9026 1 8434 6189 927 mx2_x2
xsubckt_7806_mx2_x2 0 9024 1 8434 6170 925 mx2_x2
xsubckt_8053_sff1_x4 1 2203 0 10304 1755 sff1_x4
xsubckt_8576_sff1_x4 1 2050 0 9781 2020 sff1_x4
xsubckt_9476_sff1_x4 1 2172 0 8967 1830 sff1_x4
xcmpt_cpuregs_rdreg_0_q_0_hfns_9 1 0 847 838 buf_x4
xcmpt_cpuregs_rdreg_0_q_0_hfns_8 1 0 847 839 buf_x4
xcmpt_cpuregs_rdreg_0_q_0_hfns_7 1 0 847 840 buf_x4
xcmpt_cpuregs_rdreg_0_q_0_hfns_6 1 0 847 841 buf_x4
xcmpt_cpuregs_rdreg_0_q_0_hfns_5 1 0 847 842 buf_x4
xcmpt_cpuregs_rdreg_0_q_0_hfns_4 1 0 847 843 buf_x4
xcmpt_cpuregs_rdreg_0_q_0_hfns_3 1 0 847 844 buf_x4
xcmpt_cpuregs_rdreg_0_q_0_hfns_2 1 0 847 854 buf_x4
xcmpt_cpuregs_rdreg_0_q_0_hfns_1 1 0 847 865 buf_x4
xcmpt_cpuregs_rdreg_0_q_0_hfns_0 1 0 847 866 buf_x4
xsubckt_309_inv_x0 1 0 445 8067 inv_x0
xsubckt_307_inv_x0 1 0 1981 8069 inv_x0
xsubckt_305_inv_x0 1 0 2017 8071 inv_x0
xsubckt_261_inv_x0 1 0 219 8115 inv_x0
xsubckt_535_nand2_x0 1 0 7804 328 217 nand2_x0
xsubckt_598_a2_x2 0 7740 1 237 1897 a2_x2
xsubckt_613_o3_x2 0 7726 1 408 330 328 o3_x2
xsubckt_889_nand3_x0 1 0 7460 7461 7462 1902 nand3_x0
xsubckt_2530_mx2_x2 0 5823 1 789 5824 5825 mx2_x2
xsubckt_2921_mx2_x2 0 5439 1 789 5440 5441 mx2_x2
xsubckt_2923_mx2_x2 0 5437 1 810 1889 1537 mx2_x2
xsubckt_3067_mx2_x2 0 5295 1 810 1311 1279 mx2_x2
xsubckt_3157_nand3_x0 1 0 5207 569 8290 87 nand3_x0
xsubckt_3375_oa22_x2 0 4992 1 4993 4994 8017 oa22_x2
xsubckt_3458_mx2_x2 0 4911 1 810 984 952 mx2_x2
xsubckt_5731_ao22_x2 0 3271 1 3272 3276 7842 ao22_x2
xsubckt_6428_oa22_x2 0 2595 1 3191 2598 2596 oa22_x2
xsubckt_6816_inv_x0 1 0 8847 9419 inv_x0
xsubckt_7024_mx2_x2 0 9396 1 7918 412 380 mx2_x2
xsubckt_7026_mx2_x2 0 9395 1 7918 411 379 mx2_x2
xsubckt_7028_mx2_x2 0 9394 1 7918 410 378 mx2_x2
xsubckt_7417_mx2_x2 0 9390 1 8490 6283 1379 mx2_x2
xsubckt_7419_mx2_x2 0 9388 1 8490 6272 1367 mx2_x2
xsubckt_7760_mx2_x2 0 9068 1 8439 6272 951 mx2_x2
xsubckt_7762_mx2_x2 0 9066 1 8439 6259 937 mx2_x2
xsubckt_7808_mx2_x2 0 9022 1 8433 6151 923 mx2_x2
xsubckt_8410_sff1_x4 1 2224 0 9947 1621 sff1_x4
xsubckt_8933_sff1_x4 1 2079 0 9492 740 sff1_x4
xsubckt_9310_sff1_x4 1 2106 0 9130 1001 sff1_x4
xsubckt_9384_sff1_x4 1 2194 0 9059 960 sff1_x4
xsubckt_2143_mx2_x2 0 9398 1 7917 414 382 mx2_x2
xsubckt_2141_mx2_x2 0 9399 1 7917 415 383 mx2_x2
xsubckt_478_o3_x2 0 7859 1 57 58 59 o3_x2
xsubckt_355_nand2_x0 1 0 7994 7997 40 nand2_x0
xsubckt_267_inv_x0 1 0 246 8109 inv_x0
xsubckt_265_inv_x0 1 0 2039 8111 inv_x0
xsubckt_263_inv_x0 1 0 218 8113 inv_x0
xcmpt_zero_10 1 0 696 zero_x1
xcmpt_zero_11 1 0 695 zero_x1
xcmpt_zero_12 1 0 694 zero_x1
xcmpt_zero_13 1 0 693 zero_x1
xcmpt_zero_14 1 0 692 zero_x1
xcmpt_zero_15 1 0 691 zero_x1
xcmpt_zero_16 1 0 690 zero_x1
xcmpt_zero_17 1 0 689 zero_x1
xcmpt_zero_18 1 0 688 zero_x1
xcmpt_zero_19 1 0 687 zero_x1
xsubckt_728_oa22_x2 0 7616 1 7621 7620 7617 oa22_x2
xsubckt_2532_mx2_x2 0 5821 1 807 1868 1516 mx2_x2
xsubckt_2534_mx2_x2 0 5819 1 784 5820 5823 mx2_x2
xsubckt_2536_mx2_x2 0 5817 1 806 1228 1196 mx2_x2
xsubckt_2925_mx2_x2 0 5435 1 8032 5436 5437 mx2_x2
xsubckt_2927_mx2_x2 0 5433 1 807 1729 1697 mx2_x2
xsubckt_2929_mx2_x2 0 5431 1 790 5432 5433 mx2_x2
xsubckt_3732_oa22_x2 0 4641 1 4642 4643 775 oa22_x2
xsubckt_3941_nand2_x0 1 0 4436 4437 781 nand2_x0
xsubckt_4471_a4_x2 0 4171 1 6307 7885 8007 555 a4_x2
xsubckt_5005_oa22_x2 0 9844 1 7885 3870 3872 oa22_x2
xsubckt_5018_a3_x2 1 3860 0 40 155 8399 a3_x2
xsubckt_5172_nand3_x0 1 0 3718 40 151 8399 nand3_x0
xsubckt_5204_ao22_x2 0 3688 1 3703 3909 8294 ao22_x2
xsubckt_5282_ao22_x2 0 3615 1 3616 3617 3622 ao22_x2
xsubckt_5601_nand4_x0 1 0 3359 3367 1994 1995 1997 nand4_x0
xsubckt_6100_mx2_x2 0 2914 1 827 2915 2922 mx2_x2
xsubckt_6818_inv_x0 1 0 8846 9420 inv_x0
xsubckt_7371_mx2_x2 0 9464 1 8500 6097 1588 mx2_x2
xsubckt_7373_mx2_x2 0 9462 1 8500 6081 1586 mx2_x2
xsubckt_7375_mx2_x2 0 9460 1 8499 6062 1584 mx2_x2
xsubckt_7764_mx2_x2 0 9064 1 8439 6245 935 mx2_x2
xsubckt_8049_sff1_x4 1 2222 0 10308 1759 sff1_x4
xsubckt_8484_sff1_x4 1 2044 0 9873 1918 sff1_x4
xsubckt_9306_sff1_x4 1 2103 0 9134 1027 sff1_x4
xsubckt_2448_nand2_x0 1 0 5903 5915 770 nand2_x0
xsubckt_269_inv_x0 1 0 2037 8107 inv_x0
xsubckt_2490_mx2_x2 0 5862 1 791 5863 5864 mx2_x2
xsubckt_2492_mx2_x2 0 5860 1 811 1431 1399 mx2_x2
xsubckt_2494_mx2_x2 0 5858 1 8025 5859 5862 mx2_x2
xsubckt_2538_mx2_x2 0 5815 1 8033 5816 5817 mx2_x2
xsubckt_2881_mx2_x2 0 5478 1 811 1572 1540 mx2_x2
xsubckt_2885_mx2_x2 0 5474 1 811 1124 1092 mx2_x2
xsubckt_3761_nand2_x0 1 0 4613 4614 784 nand2_x0
xsubckt_3937_nand3_x0 1 0 4440 569 8289 73 nand3_x0
xsubckt_4296_a4_x2 0 4201 1 4220 6306 6312 551 a4_x2
xsubckt_4725_a4_x2 0 4078 1 1969 1968 1967 1966 a4_x2
xsubckt_4765_a4_x2 0 4048 1 4049 4054 4065 4143 a4_x2
xsubckt_6108_mx2_x2 0 2907 1 841 1854 1822 mx2_x2
xsubckt_6451_mx2_x2 0 2573 1 8218 2574 2575 mx2_x2
xsubckt_7377_mx2_x2 0 9458 1 8500 6043 1582 mx2_x2
xsubckt_7379_mx2_x2 0 9456 1 8500 6027 1579 mx2_x2
xsubckt_8406_sff1_x4 1 2242 0 9951 1626 sff1_x4
xsubckt_8841_sff1_x4 1 2232 0 9584 1533 sff1_x4
xsubckt_8929_sff1_x4 1 2079 0 9496 766 sff1_x4
xsubckt_9292_sff1_x4 1 2232 0 9148 1049 sff1_x4
xsubckt_2145_a2_x2 0 6313 1 556 555 a2_x2
xsubckt_1431_a2_x2 0 6929 1 468 8285 a2_x2
xsubckt_1256_a2_x2 0 7109 1 207 240 a2_x2
xcmpt_zero_29 1 0 676 zero_x1
xcmpt_zero_28 1 0 677 zero_x1
xcmpt_zero_27 1 0 678 zero_x1
xcmpt_zero_26 1 0 679 zero_x1
xcmpt_zero_25 1 0 680 zero_x1
xcmpt_zero_24 1 0 681 zero_x1
xcmpt_zero_23 1 0 682 zero_x1
xcmpt_zero_22 1 0 683 zero_x1
xcmpt_zero_21 1 0 684 zero_x1
xcmpt_zero_20 1 0 685 zero_x1
xsubckt_2611_nand2_x0 1 0 5743 6008 8115 nand2_x0
xsubckt_2889_mx2_x2 0 5470 1 811 1284 1252 mx2_x2
xsubckt_3503_a2_x2 0 4866 1 4867 4872 a2_x2
xsubckt_3581_nand2_x0 1 0 4790 4791 780 nand2_x0
xsubckt_3757_nand3_x0 1 0 4617 568 8290 76 nand3_x0
xsubckt_3927_ao22_x2 0 4450 1 4508 4503 4505 ao22_x2
xsubckt_4091_oa22_x2 0 4288 1 4289 4290 8017 oa22_x2
xsubckt_4853_a3_x2 1 3981 0 3985 1931 8347 a3_x2
xsubckt_5112_ao22_x2 0 3773 1 3774 3775 3780 ao22_x2
xsubckt_5722_a3_x2 1 9714 0 3280 7913 44 a3_x2
xsubckt_6060_mx2_x2 0 2953 1 843 1504 1472 mx2_x2
xsubckt_6062_mx2_x2 0 2951 1 8219 2952 2953 mx2_x2
xsubckt_6064_mx2_x2 0 2949 1 828 2950 2957 mx2_x2
xsubckt_6453_mx2_x2 0 2571 1 842 1652 1620 mx2_x2
xsubckt_6455_mx2_x2 0 2569 1 8219 2570 2571 mx2_x2
xsubckt_6457_mx2_x2 0 2567 1 842 1428 1396 mx2_x2
xsubckt_7941_sff1_x4 1 2123 0 10453 823 sff1_x4
xsubckt_8392_sff1_x4 1 2099 0 9965 1612 sff1_x4
xsubckt_9214_sff1_x4 1 2100 0 9226 1065 sff1_x4
xsubckt_1920_a2_x2 0 6477 1 6478 6479 a2_x2
xsubckt_1900_a2_x2 0 6493 1 249 217 a2_x2
xsubckt_1276_a2_x2 0 7089 1 212 245 a2_x2
xsubckt_3563_a2_x2 0 4807 1 4808 4813 a2_x2
xsubckt_3577_nand3_x0 1 0 4794 568 8290 79 nand3_x0
xsubckt_3920_nand3_x0 1 0 4456 4457 4635 7857 nand3_x0
xsubckt_4472_a2_x2 0 4170 1 4171 4183 a2_x2
xsubckt_4706_a2_x2 0 9920 1 4093 43 a2_x2
xsubckt_4746_a2_x2 0 9911 1 4062 43 a2_x2
xsubckt_5305_nxr2_x1 3594 1 0 3889 730 nxr2_x1
xsubckt_5635_a2_x2 0 9748 1 3336 43 a2_x2
xsubckt_5920_mx2_x2 0 3089 1 827 3090 3097 mx2_x2
xsubckt_6459_mx2_x2 0 2565 1 8211 2566 2569 mx2_x2
xsubckt_6945_a3_x2 1 8750 0 578 8244 702 a3_x2
xsubckt_7937_sff1_x4 1 2123 0 10457 867 sff1_x4
xsubckt_8314_sff1_x4 1 2223 0 10043 1653 sff1_x4
xsubckt_8837_sff1_x4 1 2193 0 9588 1537 sff1_x4
xsubckt_9288_sff1_x4 1 2232 0 9152 1053 sff1_x4
xcmpt_abc_30082_new_n5476_hfns_2 1 0 6246 6243 buf_x4
xcmpt_abc_30082_new_n5476_hfns_1 1 0 6243 6244 buf_x4
xcmpt_abc_30082_new_n5476_hfns_0 1 0 6243 6245 buf_x4
xsubckt_1940_a2_x2 0 6461 1 6462 6463 a2_x2
xsubckt_1678_ao22_x2 0 6698 1 6699 6700 6940 ao22_x2
xcmpt_zero_39 1 0 291 zero_x1
xcmpt_zero_38 1 0 302 zero_x1
xcmpt_zero_37 1 0 313 zero_x1
xcmpt_zero_36 1 0 314 zero_x1
xcmpt_zero_35 1 0 500 zero_x1
xcmpt_zero_34 1 0 501 zero_x1
xcmpt_zero_33 1 0 537 zero_x1
xcmpt_zero_32 1 0 538 zero_x1
xcmpt_zero_31 1 0 673 zero_x1
xcmpt_zero_30 1 0 674 zero_x1
xsubckt_1028_nand2_x0 1 0 7328 629 1926 nand2_x0
xsubckt_4015_nand2_x0 1 0 4363 4364 783 nand2_x0
xsubckt_4786_a2_x2 0 9901 1 4032 43 a2_x2
xsubckt_5075_nand2_x0 1 0 3808 3936 8278 nand2_x0
xsubckt_5880_mx2_x2 0 3128 1 865 1479 1447 mx2_x2
xsubckt_5928_mx2_x2 0 3082 1 865 1829 1797 mx2_x2
xsubckt_6858_a2_x2 0 9666 1 8813 42 a2_x2
xsubckt_7052_oa22_x2 0 8684 1 386 8686 8685 oa22_x2
xsubckt_7339_ao22_x2 0 8508 1 8249 8607 8509 ao22_x2
xsubckt_8388_sff1_x4 1 2112 0 9969 1482 sff1_x4
xsubckt_8745_sff1_x4 1 2150 0 2300 2268 sff1_x4
xsubckt_9122_sff1_x4 1 2189 0 9318 1093 sff1_x4
xsubckt_1836_oa22_x2 0 2300 1 6551 6552 6561 oa22_x2
xsubckt_1545_nand3_x0 1 0 6822 6823 6824 6940 nand3_x0
xsubckt_1244_o2_x2 0 7121 1 205 238 o2_x2
xsubckt_775_nand2_x0 1 0 7568 2004 638 nand2_x0
xsubckt_865_nand2_x0 1 0 7483 7484 7487 nand2_x0
xsubckt_3397_nand3_x0 1 0 4971 567 8289 83 nand3_x0
xsubckt_4220_mx2_x2 0 10327 1 4215 6070 1137 mx2_x2
xsubckt_4611_mx2_x2 0 9968 1 4147 6283 1635 mx2_x2
xsubckt_4613_mx2_x2 0 9966 1 4147 6272 1623 mx2_x2
xsubckt_5252_oa22_x2 0 3643 1 3645 3648 8295 oa22_x2
xsubckt_5882_mx2_x2 0 3126 1 8221 3127 3128 mx2_x2
xsubckt_5884_mx2_x2 0 3124 1 826 3125 3132 mx2_x2
xsubckt_8222_sff1_x4 1 2119 0 10135 1265 sff1_x4
xsubckt_8296_sff1_x4 1 2099 0 10061 1644 sff1_x4
xsubckt_9118_sff1_x4 1 2106 0 9322 1097 sff1_x4
xsubckt_9196_sff1_x4 1 2242 0 9244 1209 sff1_x4
xsubckt_2320_ao22_x2 0 6056 1 73 6066 6294 ao22_x2
xsubckt_1705_nxr2_x1 6673 1 0 6675 205 nxr2_x1
xsubckt_1455_nand3_x0 1 0 6906 6907 6908 6909 nand3_x0
xsubckt_1387_oa22_x2 0 6978 1 6979 6980 7172 oa22_x2
xsubckt_1264_o2_x2 0 7101 1 209 242 o2_x2
xsubckt_397_nor4_x0 1 0 7948 643 633 637 629 nor4_x0
xcmpt_zero_40 1 0 288 zero_x1
xcmpt_zero_41 1 0 287 zero_x1
xcmpt_zero_42 1 0 286 zero_x1
xcmpt_zero_43 1 0 285 zero_x1
xcmpt_zero_44 1 0 284 zero_x1
xcmpt_zero_45 1 0 283 zero_x1
xcmpt_zero_46 1 0 312 zero_x1
xcmpt_zero_47 1 0 311 zero_x1
xcmpt_zero_48 1 0 310 zero_x1
xcmpt_zero_49 1 0 309 zero_x1
xsubckt_975_oa22_x2 0 7378 1 7379 7383 7792 oa22_x2
xsubckt_2500_nand3_x0 1 0 5852 5853 5854 776 nand3_x0
xsubckt_4222_mx2_x2 0 10325 1 4215 6053 1135 mx2_x2
xsubckt_4224_mx2_x2 0 10323 1 4215 6035 1133 mx2_x2
xsubckt_4226_mx2_x2 0 10321 1 4215 6018 1130 mx2_x2
xsubckt_4615_mx2_x2 0 9964 1 4146 6259 1609 mx2_x2
xsubckt_4617_mx2_x2 0 9962 1 4147 6245 1607 mx2_x2
xsubckt_4960_mx2_x2 0 3903 1 6445 6149 147 mx2_x2
xsubckt_8130_sff1_x4 1 2119 0 10227 1229 sff1_x4
xsubckt_8218_sff1_x4 1 2217 0 10139 1269 sff1_x4
xsubckt_8653_sff1_x4 1 2185 0 9736 536 sff1_x4
xsubckt_9030_sff1_x4 1 2066 0 9400 384 sff1_x4
xcmpt_abc_30082_new_n3630_hfns_2 1 0 8018 8015 buf_x4
xcmpt_abc_30082_new_n3630_hfns_1 1 0 8015 8016 buf_x4
xcmpt_abc_30082_new_n3630_hfns_0 1 0 8015 8017 buf_x4
xsubckt_1779_nxr2_x1 6604 1 0 6605 8047 nxr2_x1
xsubckt_1691_nxr2_x1 6686 1 0 6689 239 nxr2_x1
xsubckt_1637_nor3_x0 1 0 6736 6737 6742 6743 nor3_x0
xsubckt_523_a3_x2 1 7816 0 7824 7870 1908 a3_x2
xsubckt_371_nor2_x0 1 0 7977 644 662 nor2_x0
xsubckt_595_nand2_x0 1 0 7743 630 1949 nand2_x0
xsubckt_1011_nand2_x0 1 0 7344 634 1962 nand2_x0
xsubckt_3300_mx2_x2 0 5066 1 8036 5067 5068 mx2_x2
xsubckt_3865_o2_x2 0 4510 1 4511 5993 o2_x2
xsubckt_3975_oa22_x2 0 4402 1 4403 4404 8017 oa22_x2
xsubckt_4180_mx2_x2 0 10361 1 4223 6088 1779 mx2_x2
xsubckt_4182_mx2_x2 0 10359 1 4223 6070 1777 mx2_x2
xsubckt_4571_mx2_x2 0 10004 1 4156 6043 1326 mx2_x2
xsubckt_4573_mx2_x2 0 10002 1 4156 6026 1323 mx2_x2
xsubckt_4964_mx2_x2 0 3900 1 6444 6140 146 mx2_x2
xsubckt_5144_nand3_x0 1 0 3744 47 153 8399 nand3_x0
xsubckt_5683_oa22_x2 0 3290 1 5960 3291 3324 oa22_x2
xsubckt_9026_sff1_x4 1 2083 0 9404 389 sff1_x4
xsubckt_9461_sff1_x4 1 2145 0 8982 1874 sff1_x4
xcmpt_abc_30082_new_n3638_hfns_2 1 0 8003 8000 buf_x4
xcmpt_abc_30082_new_n3638_hfns_1 1 0 8000 8001 buf_x4
xcmpt_abc_30082_new_n3638_hfns_0 1 0 8000 8002 buf_x4
xsubckt_1792_nand4_x0 1 0 6592 6634 8045 8046 8047 nand4_x0
xsubckt_1628_nand2_x0 1 0 6745 7098 7971 nand2_x0
xcmpt_zero_50 1 0 308 zero_x1
xcmpt_zero_51 1 0 307 zero_x1
xcmpt_zero_52 1 0 306 zero_x1
xcmpt_zero_53 1 0 305 zero_x1
xcmpt_zero_54 1 0 304 zero_x1
xcmpt_zero_55 1 0 303 zero_x1
xcmpt_zero_56 1 0 301 zero_x1
xcmpt_zero_57 1 0 300 zero_x1
xcmpt_zero_58 1 0 299 zero_x1
xcmpt_zero_59 1 0 298 zero_x1
xsubckt_883_oa22_x2 0 180 1 7483 7482 7466 oa22_x2
xsubckt_2552_oa22_x2 0 5801 1 5950 5802 5833 oa22_x2
xsubckt_3302_mx2_x2 0 5064 1 816 1243 1211 mx2_x2
xsubckt_3304_mx2_x2 0 5062 1 8036 5063 5064 mx2_x2
xsubckt_3306_mx2_x2 0 5060 1 816 1371 1339 mx2_x2
xsubckt_3448_oa22_x2 0 4921 1 4979 4976 4978 oa22_x2
xsubckt_3909_nand3_x0 1 0 4467 4492 4496 8012 nand3_x0
xsubckt_4184_mx2_x2 0 10357 1 4224 6053 1775 mx2_x2
xsubckt_4186_mx2_x2 0 10355 1 4224 6035 1773 mx2_x2
xsubckt_4188_mx2_x2 0 10353 1 4224 6018 1770 mx2_x2
xsubckt_4577_mx2_x2 0 10000 1 4152 6282 1507 mx2_x2
xsubckt_4579_mx2_x2 0 9998 1 4152 6273 1495 mx2_x2
xsubckt_4968_mx2_x2 0 3897 1 6445 6132 145 mx2_x2
xsubckt_5407_nand2_x0 1 0 3499 3867 729 nand2_x0
xsubckt_7259_nand2_x0 1 0 8572 8573 8577 nand2_x0
xsubckt_8126_sff1_x4 1 2137 0 10231 1233 sff1_x4
xsubckt_8561_sff1_x4 1 2053 0 9796 2036 sff1_x4
xsubckt_8649_sff1_x4 1 2185 0 9740 510 sff1_x4
xsubckt_111_inv_x0 1 0 2 8300 inv_x0
xsubckt_905_a2_x2 0 7445 1 759 84 a2_x2
xsubckt_2761_nand2_x0 1 0 5596 5597 8022 nand2_x0
xsubckt_3022_nand3_x0 1 0 5339 5340 5517 7857 nand3_x0
xsubckt_3308_mx2_x2 0 5058 1 8029 5059 5060 mx2_x2
xsubckt_3512_xr2_x1 4858 0 1 236 755 xr2_x1
xsubckt_3651_mx2_x2 0 4721 1 793 1844 1812 mx2_x2
xsubckt_3655_mx2_x2 0 4717 1 819 1428 1396 mx2_x2
xsubckt_4049_xr2_x1 4330 0 1 227 746 xr2_x1
xsubckt_5156_oa22_x2 0 3732 1 3733 3739 8276 oa22_x2
xsubckt_5355_ao22_x2 0 3547 1 3557 3552 3550 ao22_x2
xsubckt_7610_mx2_x2 0 9207 1 8465 6088 1075 mx2_x2
xsubckt_7612_mx2_x2 0 9205 1 8465 6070 1073 mx2_x2
xsubckt_9457_sff1_x4 1 2204 0 8986 1878 sff1_x4
xcmpt_zero_60 1 0 297 zero_x1
xcmpt_zero_61 1 0 296 zero_x1
xcmpt_zero_62 1 0 295 zero_x1
xcmpt_zero_63 1 0 294 zero_x1
xcmpt_zero_64 1 0 293 zero_x1
xcmpt_zero_65 1 0 292 zero_x1
xcmpt_zero_66 1 0 290 zero_x1
xcmpt_zero_67 1 0 289 zero_x1
xcmpt_zero_68 1 0 190 zero_x1
xcmpt_zero_69 1 0 39 zero_x1
xsubckt_113_inv_x0 1 0 633 8298 inv_x0
xsubckt_115_inv_x0 1 0 652 8296 inv_x0
xsubckt_117_inv_x0 1 0 1905 8287 inv_x0
xsubckt_671_a2_x2 0 7670 1 7671 7679 a2_x2
xsubckt_713_oa22_x2 0 7630 1 7631 7635 7793 oa22_x2
xsubckt_798_nor2_x0 1 0 7546 7547 7553 nor2_x0
xsubckt_3659_mx2_x2 0 4713 1 818 1588 1556 mx2_x2
xsubckt_7225_mx2_x2 0 9514 1 8831 8597 747 mx2_x2
xsubckt_7332_nand2_x0 1 0 8514 8686 383 nand2_x0
xsubckt_7356_mx3_x2 1 0 9479 8502 6290 1574 6236 6240 mx3_x2
xsubckt_7358_mx3_x2 1 0 9477 8502 6290 1572 6216 6220 mx3_x2
xsubckt_7570_mx2_x2 0 9245 1 8470 6143 1210 mx2_x2
xsubckt_7614_mx2_x2 0 9203 1 8465 6053 1071 mx2_x2
xsubckt_7616_mx2_x2 0 9201 1 8465 6035 1069 mx2_x2
xsubckt_7618_mx2_x2 0 9199 1 8465 6018 1066 mx2_x2
xsubckt_8034_sff1_x4 1 2113 0 10323 1133 sff1_x4
xsubckt_8557_sff1_x4 1 2057 0 9800 1978 sff1_x4
xsubckt_8992_sff1_x4 1 2219 0 9433 1557 sff1_x4
xsubckt_2344_mx2_x2 0 6024 1 546 99 2263 mx2_x2
xsubckt_1178_nand2_x0 1 0 7186 1981 638 nand2_x0
xsubckt_404_o2_x2 0 7941 1 505 503 o2_x2
xsubckt_119_inv_x0 1 0 249 8285 inv_x0
xsubckt_5131_a3_x2 1 3756 0 3782 3924 3927 a3_x2
xsubckt_5512_a4_x2 0 3421 1 3427 2024 2025 2026 a4_x2
xsubckt_5532_a4_x2 0 3407 1 3414 2017 2019 2020 a4_x2
xsubckt_6301_mx2_x2 0 2719 1 827 2720 2727 mx2_x2
xsubckt_7572_mx2_x2 0 9243 1 8470 6125 1208 mx2_x2
xsubckt_7574_mx2_x2 0 9241 1 8470 6107 1205 mx2_x2
xsubckt_7576_mx2_x2 0 9239 1 8470 6088 1203 mx2_x2
xsubckt_8914_sff1_x4 1 2089 0 9511 750 sff1_x4
xsubckt_8988_sff1_x4 1 2246 0 9437 1562 sff1_x4
xsubckt_9365_sff1_x4 1 2145 0 9078 978 sff1_x4
xsubckt_2132_ao22_x2 0 6315 1 8252 8274 8283 ao22_x2
xsubckt_532_mx2_x2 0 7806 1 328 330 216 mx2_x2
xsubckt_468_inv_x0 1 0 7869 9675 inv_x0
xcmpt_zero_70 1 0 38 zero_x1
xcmpt_zero_71 1 0 27 zero_x1
xcmpt_zero_72 1 0 16 zero_x1
xcmpt_zero_73 1 0 9 zero_x1
xcmpt_zero_74 1 0 8 zero_x1
xcmpt_zero_75 1 0 7 zero_x1
xcmpt_zero_76 1 0 6 zero_x1
xcmpt_zero_77 1 0 5 zero_x1
xcmpt_zero_78 1 0 4 zero_x1
xcmpt_zero_79 1 0 37 zero_x1
xsubckt_908_ao22_x2 0 7442 1 7444 7447 1903 ao22_x2
xsubckt_2691_mx2_x2 0 5665 1 817 1703 1671 mx2_x2
xsubckt_2693_mx2_x2 0 5663 1 788 5664 5665 mx2_x2
xsubckt_3028_ao22_x2 0 5334 1 5393 5391 5388 ao22_x2
xsubckt_3105_nand2_x0 1 0 5258 5259 8021 nand2_x0
xsubckt_6303_mx2_x2 0 2717 1 852 1305 1273 mx2_x2
xsubckt_6305_mx2_x2 0 2715 1 852 1241 1209 mx2_x2
xsubckt_6307_mx2_x2 0 2713 1 8224 2714 2715 mx2_x2
xsubckt_6650_mx2_x2 0 2380 1 852 1710 1678 mx2_x2
xsubckt_7116_a2_x2 0 9564 1 8659 8660 a2_x2
xsubckt_7449_a4_x2 0 8487 1 4212 6303 6305 7884 a4_x2
xsubckt_7578_mx2_x2 0 9237 1 8470 6071 1201 mx2_x2
xsubckt_8465_sff1_x4 1 2057 0 9892 1939 sff1_x4
xsubckt_8822_sff1_x4 1 2053 0 9601 564 sff1_x4
xcmpt_abc_30082_new_n10637_hfns_2 1 0 8501 8498 buf_x4
xcmpt_abc_30082_new_n10637_hfns_1 1 0 8498 8499 buf_x4
xcmpt_abc_30082_new_n10637_hfns_0 1 0 8498 8500 buf_x4
xsubckt_2269_a3_x2 1 6121 0 6122 540 8409 a3_x2
xsubckt_2219_nand3_x0 1 0 6185 6186 540 8409 nand3_x0
xsubckt_2133_nand2_x0 1 0 6314 6315 6316 nand2_x0
xsubckt_1958_nand2_x0 1 0 448 6456 6477 nand2_x0
xsubckt_1860_nxr2_x1 6528 1 0 6532 8073 nxr2_x1
xsubckt_1535_a3_x2 1 6831 0 6832 6833 6834 a3_x2
xsubckt_1251_nand2_x0 1 0 7114 7115 7119 nand2_x0
xsubckt_514_nor3_x0 1 0 7824 7937 7943 8305 nor3_x0
xsubckt_657_nand2_x0 1 0 7684 7685 7798 nand2_x0
xsubckt_2695_mx2_x2 0 5661 1 795 903 871 mx2_x2
xsubckt_2697_mx2_x2 0 5659 1 8031 5660 5661 mx2_x2
xsubckt_2699_mx2_x2 0 5657 1 795 1479 1447 mx2_x2
xsubckt_4330_a2_x2 0 4196 1 552 8006 a2_x2
xsubckt_4751_a3_x2 1 4058 0 4059 4064 1958 a3_x2
xsubckt_5120_nand2_x0 1 0 3766 3767 8294 nand2_x0
xsubckt_5852_oa22_x2 0 3155 1 3191 3158 3156 oa22_x2
xsubckt_6261_mx2_x2 0 2758 1 857 986 954 mx2_x2
xsubckt_6263_mx2_x2 0 2756 1 834 2757 2758 mx2_x2
xsubckt_6265_mx2_x2 0 2754 1 828 2755 2762 mx2_x2
xsubckt_6309_mx2_x2 0 2711 1 857 1657 1625 mx2_x2
xsubckt_6652_mx2_x2 0 2378 1 834 2379 2380 mx2_x2
xsubckt_6654_mx2_x2 0 2376 1 857 1870 1518 mx2_x2
xsubckt_6656_mx2_x2 0 2374 1 8225 2375 2376 mx2_x2
xsubckt_6752_oa22_x2 0 8901 1 3191 8904 8902 oa22_x2
xsubckt_6990_a4_x2 0 8714 1 371 372 373 8235 a4_x2
xsubckt_7900_buf_x1 1 0 1871 8979 buf_x1
xsubckt_7922_sff1_x4 1 2224 0 10430 1818 sff1_x4
xsubckt_8373_sff1_x4 1 2203 0 9984 1499 sff1_x4
xsubckt_8896_sff1_x4 1 2050 0 9529 338 sff1_x4
xsubckt_9273_sff1_x4 1 2113 0 9167 1418 sff1_x4
xsubckt_1663_ao22_x2 0 6712 1 6729 6726 6714 ao22_x2
xsubckt_1464_oa22_x2 0 6898 1 8415 6903 445 oa22_x2
xsubckt_1194_a2_x2 0 7171 1 195 227 a2_x2
xcmpt_zero_89 1 0 26 zero_x1
xcmpt_zero_88 1 0 28 zero_x1
xcmpt_zero_87 1 0 29 zero_x1
xcmpt_zero_86 1 0 30 zero_x1
xcmpt_zero_85 1 0 31 zero_x1
xcmpt_zero_84 1 0 32 zero_x1
xcmpt_zero_83 1 0 33 zero_x1
xcmpt_zero_82 1 0 34 zero_x1
xcmpt_zero_81 1 0 35 zero_x1
xcmpt_zero_80 1 0 36 zero_x1
xsubckt_567_nand2_x0 1 0 7770 630 1950 nand2_x0
xsubckt_744_xr2_x1 7598 0 1 737 62 xr2_x1
xsubckt_820_nand2_x0 1 0 183 7526 7539 nand2_x0
xsubckt_910_nand2_x0 1 0 7440 7441 1894 nand2_x0
xsubckt_1161_nand2_x0 1 0 7202 1982 637 nand2_x0
xsubckt_5030_nand2_x0 1 0 3849 3850 3852 nand2_x0
xsubckt_5116_nand3_x0 1 0 3770 41 125 8399 nand3_x0
xsubckt_5364_nxr2_x1 3539 1 0 3563 3876 nxr2_x1
xsubckt_5553_a2_x2 0 3393 1 3395 2010 a2_x2
xsubckt_6267_mx2_x2 0 2752 1 856 1306 1274 mx2_x2
xsubckt_6269_mx2_x2 0 2750 1 856 1242 1210 mx2_x2
xsubckt_6658_mx2_x2 0 2372 1 856 1038 1006 mx2_x2
xsubckt_7196_a2_x2 0 8618 1 718 8422 a2_x2
xsubckt_7221_nand3_x0 1 0 8599 8600 8604 8609 nand3_x0
xsubckt_7902_buf_x1 1 0 1869 8977 buf_x1
xsubckt_7904_buf_x1 1 0 1866 8975 buf_x1
xsubckt_7996_sff1_x4 1 2142 0 10361 1779 sff1_x4
xsubckt_8730_sff1_x4 1 2185 0 2316 2284 sff1_x4
xsubckt_8818_sff1_x4 1 2089 0 320 570 sff1_x4
xsubckt_9269_sff1_x4 1 2132 0 9171 1423 sff1_x4
xsubckt_1856_nxr2_x1 6532 1 0 6533 8052 nxr2_x1
xsubckt_1245_xr2_x1 7120 0 1 205 238 xr2_x1
xsubckt_816_nand3_x0 1 0 7529 7530 7531 7532 nand3_x0
xsubckt_2717_oa22_x2 0 5639 1 5640 5641 775 oa22_x2
xsubckt_2846_a2_x2 0 5512 1 5513 5518 a2_x2
xsubckt_3617_oa22_x2 0 4754 1 4755 4794 5958 oa22_x2
xsubckt_3705_nand2_x0 1 0 4668 4669 8024 nand2_x0
xsubckt_3990_a2_x2 0 4388 1 228 747 a2_x2
xsubckt_4203_mx3_x2 1 0 10344 4217 6290 1125 6225 6229 mx3_x2
xsubckt_4664_a2_x2 0 9930 1 4125 53 a2_x2
xsubckt_4821_nxr2_x1 4005 1 0 4006 8340 nxr2_x1
xsubckt_5325_oa22_x2 0 3575 1 3576 3577 3585 oa22_x2
xsubckt_5398_a2_x2 0 3508 1 3867 8277 a2_x2
xsubckt_5524_ao22_x2 0 3412 1 3416 2021 46 ao22_x2
xsubckt_5593_a2_x2 0 3365 1 3367 1997 a2_x2
xsubckt_5734_mx2_x2 0 3268 1 1899 1906 8402 mx2_x2
xsubckt_6971_a2_x2 0 9638 1 8731 40 a2_x2
xsubckt_7860_a2_x2 0 8424 1 8425 8426 a2_x2
xsubckt_7918_sff1_x4 1 2225 0 10434 1822 sff1_x4
xsubckt_8281_sff1_x4 1 2214 0 10076 1302 sff1_x4
xsubckt_8369_sff1_x4 1 2247 0 9988 1503 sff1_x4
xsubckt_9103_sff1_x4 1 2218 0 9337 885 sff1_x4
xsubckt_9181_sff1_x4 1 2103 0 9259 1196 sff1_x4
xcmpt_abc_30082_new_n5288_hfns_3 1 0 6442 6438 buf_x4
xcmpt_abc_30082_new_n5288_hfns_2 1 0 6438 6439 buf_x4
xcmpt_abc_30082_new_n5288_hfns_1 1 0 6438 6440 buf_x4
xcmpt_abc_30082_new_n5288_hfns_0 1 0 6438 6441 buf_x4
xsubckt_1941_nand2_x0 1 0 6460 7809 209 nand2_x0
xsubckt_1764_nxr2_x1 6618 1 0 6619 8046 nxr2_x1
xsubckt_1416_o2_x2 0 6949 1 612 613 o2_x2
xsubckt_1372_oa22_x2 0 6993 1 6994 6995 7133 oa22_x2
xsubckt_1249_xr2_x1 7116 0 1 206 239 xr2_x1
xsubckt_33_inv_x0 1 0 150 8378 inv_x0
xsubckt_31_inv_x0 1 0 148 8380 inv_x0
xcmpt_zero_99 1 0 15 zero_x1
xcmpt_zero_98 1 0 17 zero_x1
xcmpt_zero_97 1 0 18 zero_x1
xcmpt_zero_96 1 0 19 zero_x1
xcmpt_zero_95 1 0 20 zero_x1
xcmpt_zero_94 1 0 21 zero_x1
xcmpt_zero_93 1 0 22 zero_x1
xcmpt_zero_92 1 0 23 zero_x1
xcmpt_zero_91 1 0 24 zero_x1
xcmpt_zero_90 1 0 25 zero_x1
xsubckt_640_nand2_x0 1 0 7700 223 1897 nand2_x0
xsubckt_960_oa22_x2 0 7393 1 7411 7410 7409 oa22_x2
xsubckt_1136_ao22_x2 0 7226 1 7228 7231 1903 ao22_x2
xsubckt_4205_mx3_x2 1 0 10342 4217 6291 1153 6206 6209 mx3_x2
xsubckt_4550_mx3_x2 1 0 10025 4159 6291 1318 6236 6240 mx3_x2
xsubckt_4552_mx3_x2 1 0 10023 4159 6291 1316 6216 6220 mx3_x2
xsubckt_4943_mx3_x2 1 0 3916 6449 547 8377 8183 8184 mx3_x2
xsubckt_5692_mx2_x2 0 9743 1 3283 478 515 mx2_x2
xsubckt_5694_mx2_x2 0 9741 1 3283 474 511 mx2_x2
xsubckt_6498_ao22_x2 0 2527 1 573 567 752 ao22_x2
xsubckt_8203_sff1_x4 1 2217 0 10154 1255 sff1_x4
xsubckt_8726_sff1_x4 1 2193 0 2290 2258 sff1_x4
xsubckt_9177_sff1_x4 1 2113 0 9263 1386 sff1_x4
xsubckt_1851_nand2_x0 1 0 6536 6538 6546 nand2_x0
xsubckt_1761_nand2_x0 1 0 2305 6621 6625 nand2_x0
xsubckt_39_inv_x0 1 0 126 8372 inv_x0
xsubckt_37_inv_x0 1 0 154 8374 inv_x0
xsubckt_35_inv_x0 1 0 152 8376 inv_x0
xsubckt_636_nand3_x0 1 0 7704 7705 7706 7708 nand3_x0
xsubckt_956_oa22_x2 0 7396 1 7397 7401 7793 oa22_x2
xsubckt_3525_nand2_x0 1 0 4845 4846 8021 nand2_x0
xsubckt_4165_mx3_x2 1 0 10376 4226 6292 1765 6226 6229 mx3_x2
xsubckt_4167_mx3_x2 1 0 10374 4226 6292 1793 6205 6210 mx3_x2
xsubckt_4421_mx2_x2 0 10144 1 4179 6152 1275 mx2_x2
xsubckt_4423_mx2_x2 0 10142 1 4179 6134 1273 mx2_x2
xsubckt_4425_mx2_x2 0 10140 1 4179 6116 1270 mx2_x2
xsubckt_4554_mx3_x2 1 0 10021 4159 6292 1344 6196 6200 mx3_x2
xsubckt_4698_ao22_x2 0 9922 1 4099 4100 43 ao22_x2
xsubckt_4947_mx3_x2 1 0 3913 6448 546 8378 8181 8182 mx3_x2
xsubckt_5180_nxr2_x1 3710 1 0 3916 734 nxr2_x1
xsubckt_5386_o2_x2 0 3518 1 3519 3532 o2_x2
xsubckt_5561_o2_x2 0 3387 1 3389 8305 o2_x2
xsubckt_5696_mx2_x2 0 9739 1 3283 472 509 mx2_x2
xsubckt_5698_mx2_x2 0 9737 1 3283 470 507 mx2_x2
xsubckt_8277_sff1_x4 1 2205 0 10080 1307 sff1_x4
xsubckt_9011_sff1_x4 1 2053 0 9419 376 sff1_x4
xcmpt_abc_30082_new_n3442_hfns_2 1 0 8246 8243 buf_x4
xcmpt_abc_30082_new_n3442_hfns_1 1 0 8243 8244 buf_x4
xcmpt_abc_30082_new_n3442_hfns_0 1 0 8243 8245 buf_x4
xsubckt_1672_nxr2_x1 6704 1 0 6706 207 nxr2_x1
xsubckt_401_a3_x2 1 7944 0 7963 7978 7985 a3_x2
xsubckt_352_nor2_x0 1 0 7997 366 365 nor2_x0
xsubckt_3345_nand2_x0 1 0 5022 5023 8021 nand2_x0
xsubckt_4381_mx2_x2 0 10180 1 4186 6189 1727 mx2_x2
xsubckt_4383_mx2_x2 0 10178 1 4186 6170 1725 mx2_x2
xsubckt_4427_mx2_x2 0 10138 1 4179 6098 1268 mx2_x2
xsubckt_4429_mx2_x2 0 10136 1 4179 6080 1266 mx2_x2
xsubckt_5625_nxr2_x1 3342 1 0 3346 8082 nxr2_x1
xsubckt_8111_sff1_x4 1 2194 0 10246 1249 sff1_x4
xsubckt_8634_sff1_x4 1 2156 0 173 110 sff1_x4
xsubckt_9085_sff1_x4 1 2096 0 9355 876 sff1_x4
xsubckt_1581_nand2_x0 1 0 2318 6789 6793 nand2_x0
xsubckt_429_oa22_x2 0 7912 1 7915 7920 7924 oa22_x2
xsubckt_3110_mx2_x2 0 5253 1 821 926 894 mx2_x2
xsubckt_3112_mx2_x2 0 5251 1 8034 5252 5253 mx2_x2
xsubckt_3114_mx2_x2 0 5249 1 821 1502 1470 mx2_x2
xsubckt_4385_mx2_x2 0 10176 1 4185 6151 1723 mx2_x2
xsubckt_4387_mx2_x2 0 10174 1 4186 6135 1721 mx2_x2
xsubckt_4389_mx2_x2 0 10172 1 4186 6115 1718 mx2_x2
xsubckt_5428_ao22_x2 0 3479 1 3480 3481 3487 ao22_x2
xsubckt_6921_oa22_x2 0 9649 1 8794 8789 8770 oa22_x2
xsubckt_7020_nand4_x0 1 0 8688 8697 8700 8712 8715 nand4_x0
xsubckt_8107_sff1_x4 1 2217 0 10250 1223 sff1_x4
xsubckt_8185_sff1_x4 1 2206 0 10172 1718 sff1_x4
xsubckt_9007_sff1_x4 1 2086 0 10448 773 sff1_x4
xsubckt_9442_sff1_x4 1 2245 0 9001 1864 sff1_x4
xcmpt_abc_30082_new_n11012_hfns_2 1 0 8445 8442 buf_x4
xcmpt_abc_30082_new_n11012_hfns_1 1 0 8442 8443 buf_x4
xcmpt_abc_30082_new_n11012_hfns_0 1 0 8442 8444 buf_x4
xsubckt_2017_nor2_x0 1 0 6431 727 712 nor2_x0
xsubckt_1491_nand2_x0 1 0 2294 6873 6877 nand2_x0
xsubckt_1223_nand2_x0 1 0 7142 7144 7163 nand2_x0
xsubckt_354_a2_x2 0 7995 1 7997 54 a2_x2
xsubckt_310_inv_x0 1 0 456 8066 inv_x0
xsubckt_823_a2_x2 0 7523 1 763 88 a2_x2
xsubckt_897_nand2_x0 1 0 7452 634 1969 nand2_x0
xsubckt_3116_mx2_x2 0 5247 1 8035 5248 5249 mx2_x2
xsubckt_3118_mx2_x2 0 5245 1 821 1662 1630 mx2_x2
xsubckt_3165_nand2_x0 1 0 5199 5200 8025 nand2_x0
xsubckt_3463_mx2_x2 0 4906 1 821 1176 1080 mx2_x2
xsubckt_3628_ao22_x2 0 4744 1 4804 4802 4799 ao22_x2
xsubckt_5533_nxr2_x1 3406 1 0 3410 8071 nxr2_x1
xsubckt_7420_mx2_x2 0 9387 1 8490 6266 1356 mx2_x2
xsubckt_7811_mx2_x2 0 9019 1 8433 6124 920 mx2_x2
xsubckt_7813_mx2_x2 0 9017 1 8433 6107 917 mx2_x2
xsubckt_8542_sff1_x4 1 2150 0 9815 137 sff1_x4
xsubckt_9438_sff1_x4 1 2116 0 9005 1890 sff1_x4
xsubckt_1184_oa22_x2 0 162 1 7194 7193 7181 oa22_x2
xsubckt_316_inv_x0 1 0 210 8060 inv_x0
xsubckt_314_inv_x0 1 0 442 8062 inv_x0
xsubckt_312_inv_x0 1 0 440 8064 inv_x0
xsubckt_863_a2_x2 0 7485 1 761 86 a2_x2
xsubckt_3467_mx2_x2 0 4902 1 820 1784 1752 mx2_x2
xsubckt_6821_inv_x0 1 0 8844 9416 inv_x0
xsubckt_6823_inv_x0 1 0 8843 9418 inv_x0
xsubckt_7031_mx2_x2 0 9625 1 6439 9393 722 mx2_x2
xsubckt_7033_mx2_x2 0 9624 1 6439 9392 736 mx2_x2
xsubckt_7035_mx2_x2 0 9622 1 6439 9409 734 mx2_x2
xsubckt_7422_mx2_x2 0 9385 1 8490 6251 1352 mx2_x2
xsubckt_7815_mx2_x2 0 9015 1 8434 6089 915 mx2_x2
xsubckt_7817_mx2_x2 0 9013 1 8434 6071 913 mx2_x2
xsubckt_8015_sff1_x4 1 2195 0 10342 1153 sff1_x4
xsubckt_8093_sff1_x4 1 2145 0 10264 1170 sff1_x4
xsubckt_8450_sff1_x4 1 2044 0 9907 1956 sff1_x4
xsubckt_8538_sff1_x4 1 2176 0 9819 141 sff1_x4
xsubckt_8973_sff1_x4 1 2098 0 9452 1559 sff1_x4
xsubckt_9350_sff1_x4 1 2193 0 9093 964 sff1_x4
xsubckt_318_inv_x0 1 0 212 8058 inv_x0
xsubckt_274_inv_x0 1 0 243 8102 inv_x0
xsubckt_272_inv_x0 1 0 2000 8104 inv_x0
xsubckt_270_inv_x0 1 0 245 8106 inv_x0
xsubckt_970_nand2_x0 1 0 7383 7991 2028 nand2_x0
xsubckt_1043_nand2_x0 1 0 7314 7315 1895 nand2_x0
xsubckt_2541_mx2_x2 0 5812 1 791 5813 5814 mx2_x2
xsubckt_2543_mx2_x2 0 5810 1 809 1580 1548 mx2_x2
xsubckt_2932_mx2_x2 0 5428 1 809 1857 1825 mx2_x2
xsubckt_2936_mx2_x2 0 5424 1 809 1441 1409 mx2_x2
xsubckt_3945_nand2_x0 1 0 4432 4433 8024 nand2_x0
xsubckt_5480_oa22_x2 0 3442 1 3446 2036 8305 oa22_x2
xsubckt_6825_inv_x0 1 0 8842 9417 inv_x0
xsubckt_7037_mx2_x2 0 9391 1 7918 406 374 mx2_x2
xsubckt_7039_mx2_x2 0 9415 1 7918 402 370 mx2_x2
xsubckt_7202_oa22_x2 0 9519 1 8283 8616 8615 oa22_x2
xsubckt_7380_mx2_x2 0 9455 1 8500 6018 1578 mx2_x2
xsubckt_7771_mx2_x2 0 9057 1 8439 6179 958 mx2_x2
xsubckt_7773_mx2_x2 0 9055 1 8439 6162 956 mx2_x2
xsubckt_7775_mx2_x2 0 9053 1 8439 6143 954 mx2_x2
xsubckt_7819_mx2_x2 0 9011 1 8433 6054 911 mx2_x2
xsubckt_8089_sff1_x4 1 2204 0 10268 1174 sff1_x4
xsubckt_9346_sff1_x4 1 2242 0 9097 968 sff1_x4
xsubckt_1913_nand2_x0 1 0 6483 214 328 nand2_x0
xsubckt_1537_oa22_x2 0 6830 1 6846 6838 6839 oa22_x2
xsubckt_278_inv_x0 1 0 241 8098 inv_x0
xsubckt_276_inv_x0 1 0 1998 8100 inv_x0
xsubckt_2545_mx2_x2 0 5808 1 791 5809 5810 mx2_x2
xsubckt_2547_mx2_x2 0 5806 1 809 1420 1388 mx2_x2
xsubckt_2549_mx2_x2 0 5804 1 8025 5805 5808 mx2_x2
xsubckt_2890_mx2_x2 0 5469 1 8036 5470 5471 mx2_x2
xsubckt_2973_nand2_x0 1 0 5388 246 765 nand2_x0
xsubckt_3087_ao22_x2 0 5276 1 5334 5329 5331 ao22_x2
xsubckt_3765_nand2_x0 1 0 4609 4610 8025 nand2_x0
xsubckt_5437_nxr2_x1 3471 1 0 3472 3473 nxr2_x1
xsubckt_5569_a4_x2 0 3382 1 3389 2004 2005 2006 a4_x2
xsubckt_6105_a2_x2 0 9698 1 2910 2944 a2_x2
xsubckt_6111_mx2_x2 0 2904 1 861 1790 1758 mx2_x2
xsubckt_6113_mx2_x2 0 2902 1 8215 2903 2906 mx2_x2
xsubckt_6115_mx2_x2 0 2900 1 861 1182 1086 mx2_x2
xsubckt_6504_mx2_x2 0 2522 1 861 1842 1810 mx2_x2
xsubckt_6506_mx2_x2 0 2520 1 861 1714 1682 mx2_x2
xsubckt_7384_mx2_x2 0 9453 1 8495 6278 1570 mx2_x2
xsubckt_7386_mx2_x2 0 9451 1 8495 6266 1548 mx2_x2
xsubckt_7388_mx2_x2 0 9449 1 8495 6251 1544 mx2_x2
xsubckt_7777_mx2_x2 0 9051 1 8439 6125 952 mx2_x2
xsubckt_7779_mx2_x2 0 9049 1 8438 6108 949 mx2_x2
xsubckt_8446_sff1_x4 1 2044 0 9911 1960 sff1_x4
xsubckt_8881_sff1_x4 1 2070 0 9544 355 sff1_x4
xsubckt_8969_sff1_x4 1 2119 0 9456 1579 sff1_x4
xsubckt_2362_a3_x2 1 5998 0 5999 6003 7854 a3_x2
xsubckt_1823_nand2_x0 1 0 6563 6943 7161 nand2_x0
xsubckt_1306_a2_x2 0 7059 1 440 221 a2_x2
xsubckt_602_oa22_x2 0 7737 1 7766 7751 7753 oa22_x2
xsubckt_1052_a2_x2 0 7305 1 7306 7312 a2_x2
xsubckt_2615_nand2_x0 1 0 5739 5740 7857 nand2_x0
xsubckt_2883_nand2_x0 1 0 5476 5477 8022 nand2_x0
xsubckt_4855_a4_x2 0 3980 1 1934 1933 1931 1930 a4_x2
xsubckt_4875_a4_x2 0 3966 1 3971 1925 1924 1923 a4_x2
xsubckt_5236_a2_x2 0 3658 1 3903 714 a2_x2
xsubckt_5617_a3_x2 1 3348 0 3353 1989 1990 a3_x2
xsubckt_6071_mx2_x2 0 2943 1 839 927 895 mx2_x2
xsubckt_6117_mx2_x2 0 2898 1 839 990 958 mx2_x2
xsubckt_6119_mx2_x2 0 2896 1 834 2897 2898 mx2_x2
xsubckt_6460_mx2_x2 0 2564 1 828 2565 2572 mx2_x2
xsubckt_6508_mx2_x2 0 2518 1 834 2519 2520 mx2_x2
xsubckt_7074_a2_x2 0 9599 1 8669 50 a2_x2
xsubckt_7981_sff1_x4 1 2172 0 10376 1765 sff1_x4
xsubckt_8803_sff1_x4 1 2079 0 9619 731 sff1_x4
xsubckt_9254_sff1_x4 1 2247 0 9186 1439 sff1_x4
xsubckt_1541_a2_x2 0 6826 1 6827 219 a2_x2
xsubckt_1445_oa22_x2 0 6916 1 8416 6926 8066 oa22_x2
xsubckt_3585_nand2_x0 1 0 4786 4787 8022 nand2_x0
xsubckt_4748_a3_x2 1 4060 0 4064 1960 8325 a3_x2
xsubckt_4788_a3_x2 1 4030 0 4034 1949 8334 a3_x2
xsubckt_4933_oa22_x2 0 9862 1 7885 3924 3926 oa22_x2
xsubckt_5451_a2_x2 0 9805 1 3463 53 a2_x2
xsubckt_5690_nand2_x0 1 0 3284 3286 3287 nand2_x0
xsubckt_5931_mx2_x2 0 3079 1 839 1765 1733 mx2_x2
xsubckt_6073_mx2_x2 0 2941 1 8226 2942 2943 mx2_x2
xsubckt_6075_mx2_x2 0 2939 1 838 1791 1759 mx2_x2
xsubckt_6077_mx2_x2 0 2937 1 8212 2938 2941 mx2_x2
xsubckt_6284_oa22_x2 0 2735 1 3191 2738 2736 oa22_x2
xsubckt_6468_mx2_x2 0 2557 1 839 1843 1811 mx2_x2
xsubckt_7977_sff1_x4 1 2100 0 10380 1769 sff1_x4
xsubckt_8354_sff1_x4 1 2119 0 10003 1325 sff1_x4
xsubckt_8877_sff1_x4 1 2070 0 9548 359 sff1_x4
xcmpt_abc_30082_new_n5485_hfns_2 1 0 6227 6224 buf_x4
xcmpt_abc_30082_new_n5485_hfns_1 1 0 6224 6225 buf_x4
xcmpt_abc_30082_new_n5485_hfns_0 1 0 6224 6226 buf_x4
xsubckt_1553_nand2_x0 1 0 6815 7069 7972 nand2_x0
xsubckt_2744_a2_x2 0 5613 1 5614 5616 a2_x2
xsubckt_2952_nand3_x0 1 0 5408 5418 5422 770 nand3_x0
xsubckt_4019_nand2_x0 1 0 4359 4360 8021 nand2_x0
xsubckt_4836_a2_x2 0 9889 1 3995 3996 a2_x2
xsubckt_5148_ao22_x2 0 3740 1 3756 3921 8295 ao22_x2
xsubckt_5422_nand2_x0 1 0 3485 3864 730 nand2_x0
xsubckt_5933_mx2_x2 0 3077 1 8211 3078 3081 mx2_x2
xsubckt_5935_mx2_x2 0 3075 1 838 1157 1061 mx2_x2
xsubckt_5937_mx2_x2 0 3073 1 838 965 933 mx2_x2
xsubckt_6079_mx2_x2 0 2935 1 838 1183 1087 mx2_x2
xsubckt_7184_nand2_x0 1 0 8626 8627 8637 nand2_x0
xsubckt_7274_nand2_x0 1 0 8560 8561 8577 nand2_x0
xsubckt_8711_sff1_x4 1 2086 0 9679 193 sff1_x4
xsubckt_9162_sff1_x4 1 2205 0 9278 1403 sff1_x4
xcmpt_abc_30082_new_n5489_hfns_2 1 0 6221 6218 buf_x4
xcmpt_abc_30082_new_n5489_hfns_1 1 0 6218 6219 buf_x4
xcmpt_abc_30082_new_n5489_hfns_0 1 0 6218 6220 buf_x4
xsubckt_1353_oa22_x2 0 7012 1 7013 7016 7084 oa22_x2
xsubckt_477_nor3_x0 1 0 7860 57 58 59 nor3_x0
xsubckt_941_oa22_x2 0 7411 1 7429 7427 7428 oa22_x2
xsubckt_3149_oa22_x2 0 5215 1 5275 5273 5272 oa22_x2
xsubckt_4929_oa22_x2 0 9863 1 7884 3927 3929 oa22_x2
xsubckt_5891_mx2_x2 0 3118 1 838 902 870 mx2_x2
xsubckt_5893_mx2_x2 0 3116 1 8224 3117 3118 mx2_x2
xsubckt_5939_mx2_x2 0 3071 1 833 3072 3073 mx2_x2
xsubckt_7213_ao22_x2 0 8605 1 577 564 374 ao22_x2
xsubckt_8262_sff1_x4 1 2126 0 10095 1314 sff1_x4
xsubckt_8707_sff1_x4 1 2086 0 9683 197 sff1_x4
xsubckt_8785_sff1_x4 1 2073 0 9637 664 sff1_x4
xsubckt_2196_nxr2_x1 6227 1 0 6242 8362 nxr2_x1
xsubckt_1373_nand2_x0 1 0 6992 201 8087 nand2_x0
xsubckt_1349_oa22_x2 0 7016 1 7017 7018 7075 oa22_x2
xsubckt_689_nand2_x0 1 0 7653 630 1945 nand2_x0
xsubckt_1105_nand2_x0 1 0 7255 1986 638 nand2_x0
xsubckt_4231_mx2_x2 0 10319 1 4209 6278 1762 mx2_x2
xsubckt_4233_mx2_x2 0 10317 1 4209 6266 1740 mx2_x2
xsubckt_4624_mx2_x2 0 9955 1 4147 6179 1630 mx2_x2
xsubckt_5056_ao22_x2 0 3825 1 3826 3827 3832 ao22_x2
xsubckt_5069_o2_x2 0 3813 1 3815 3817 o2_x2
xsubckt_5292_oa22_x2 0 3606 1 3621 3619 3620 oa22_x2
xsubckt_5895_mx2_x2 0 3114 1 838 1766 1734 mx2_x2
xsubckt_5897_mx2_x2 0 3112 1 8210 3113 3116 mx2_x2
xsubckt_5899_mx2_x2 0 3110 1 838 1158 1062 mx2_x2
xsubckt_6427_o2_x2 0 2596 1 2597 7931 o2_x2
xsubckt_8258_sff1_x4 1 2111 0 10099 1677 sff1_x4
xsubckt_8693_sff1_x4 1 2172 0 9697 211 sff1_x4
xsubckt_9070_sff1_x4 1 2137 0 9360 1355 sff1_x4
xsubckt_9158_sff1_x4 1 2248 0 9282 1407 sff1_x4
xsubckt_1886_nand4_x0 1 0 6504 6545 8051 8052 8053 nand4_x0
xsubckt_1193_nand2_x0 1 0 7172 7173 7177 nand2_x0
xsubckt_937_oa22_x2 0 7414 1 7415 7419 7793 oa22_x2
xsubckt_2682_nand3_x0 1 0 5674 568 8290 65 nand3_x0
xsubckt_3492_oa22_x2 0 4877 1 4878 4879 776 oa22_x2
xsubckt_3700_mx2_x2 0 4673 1 789 4674 4675 mx2_x2
xsubckt_3917_nand2_x0 1 0 4459 6007 8070 nand2_x0
xsubckt_4235_mx2_x2 0 10315 1 4209 6252 1736 mx2_x2
xsubckt_4580_mx2_x2 0 9997 1 4152 6266 1484 mx2_x2
xsubckt_4582_mx2_x2 0 9995 1 4151 6252 1480 mx2_x2
xsubckt_4626_mx2_x2 0 9953 1 4146 6161 1628 mx2_x2
xsubckt_4628_mx2_x2 0 9951 1 4146 6143 1626 mx2_x2
xsubckt_8170_sff1_x4 1 2222 0 10187 1704 sff1_x4
xsubckt_8615_sff1_x4 1 2163 0 175 112 sff1_x4
xsubckt_9066_sff1_x4 1 2203 0 9364 1360 sff1_x4
xsubckt_2324_nand3_x0 1 0 6050 6051 541 8409 nand3_x0
xsubckt_488_oa22_x2 0 7846 1 7847 7869 7934 oa22_x2
xsubckt_438_a3_x2 1 7900 0 1894 41 8404 a3_x2
xsubckt_2791_ao22_x2 0 5567 1 5626 5624 5621 ao22_x2
xsubckt_3702_mx2_x2 0 4671 1 807 1875 1523 mx2_x2
xsubckt_3704_mx2_x2 0 4669 1 8032 4670 4671 mx2_x2
xsubckt_3706_mx2_x2 0 4667 1 807 1715 1683 mx2_x2
xsubckt_4195_mx2_x2 0 10352 1 4215 6283 1155 mx2_x2
xsubckt_5487_ao22_x2 0 3437 1 3441 2034 41 ao22_x2
xsubckt_6987_nor2_x0 1 0 8717 389 388 nor2_x0
xsubckt_8166_sff1_x4 1 2126 0 10191 1730 sff1_x4
xsubckt_8689_sff1_x4 1 2172 0 9701 191 sff1_x4
xsubckt_9423_sff1_x4 1 2232 0 9020 921 sff1_x4
xspare_buffer_108 1 0 2200 2173 buf_x4
xspare_buffer_104 1 0 2200 2186 buf_x4
xspare_buffer_100 1 0 2200 2199 buf_x4
xsubckt_546_a2_x2 0 7790 1 7991 2041 a2_x2
xsubckt_672_nand2_x0 1 0 160 7670 7687 nand2_x0
xsubckt_2765_nand2_x0 1 0 5592 5593 784 nand2_x0
xsubckt_3660_mx2_x2 0 4712 1 8032 4713 4714 mx2_x2
xsubckt_3662_mx2_x2 0 4710 1 807 1236 1204 mx2_x2
xsubckt_3687_ao22_x2 0 4686 1 4744 4739 4741 ao22_x2
xsubckt_3708_mx2_x2 0 4665 1 791 4666 4667 mx2_x2
xsubckt_3900_nand2_x0 1 0 4476 4477 8023 nand2_x0
xsubckt_4086_nand3_x0 1 0 4293 4318 4322 8012 nand3_x0
xsubckt_4197_mx2_x2 0 10350 1 4215 6273 1143 mx2_x2
xsubckt_4199_mx2_x2 0 10348 1 4215 6258 1129 mx2_x2
xsubckt_5196_oa22_x2 0 3695 1 3697 3700 8295 oa22_x2
xsubckt_8000_sff1_x4 1 2123 0 10357 1775 sff1_x4
xsubckt_8523_sff1_x4 1 2169 0 9834 127 sff1_x4
xsubckt_9497_sff1_x4 1 2116 0 8946 1838 sff1_x4
xsubckt_2002_mx2_x2 0 9406 1 7918 423 391 mx2_x2
xsubckt_2000_mx2_x2 0 9407 1 7918 424 392 mx2_x2
xsubckt_120_inv_x0 1 0 1895 8284 inv_x0
xsubckt_122_inv_x0 1 0 61 8282 inv_x0
xsubckt_124_inv_x0 1 0 700 8280 inv_x0
xsubckt_3329_nor2_x0 1 0 5038 240 759 nor2_x0
xsubckt_3664_mx2_x2 0 4708 1 8032 4709 4710 mx2_x2
xsubckt_3666_mx2_x2 0 4706 1 813 1364 1332 mx2_x2
xsubckt_3668_mx2_x2 0 4704 1 8032 4705 4706 mx2_x2
xsubckt_5317_ao22_x2 0 3583 1 3888 3891 730 ao22_x2
xsubckt_7234_mx2_x2 0 9511 1 8831 8591 750 mx2_x2
xsubckt_7621_mx2_x2 0 9198 1 8460 6282 1443 mx2_x2
xsubckt_7623_mx2_x2 0 9196 1 8460 6273 1431 mx2_x2
xsubckt_7625_mx2_x2 0 9194 1 8460 6259 1417 mx2_x2
xsubckt_8074_sff1_x4 1 2245 0 10283 1160 sff1_x4
xsubckt_8597_sff1_x4 1 2047 0 9760 1997 sff1_x4
xsubckt_9331_sff1_x4 1 2110 0 9109 1009 sff1_x4
xsubckt_9419_sff1_x4 1 2232 0 9024 925 sff1_x4
xspare_buffer_118 1 0 2199 2196 buf_x4
xspare_buffer_117 1 0 2199 2197 buf_x4
xspare_buffer_116 1 0 2199 2198 buf_x4
xspare_buffer_112 1 0 2200 2160 buf_x4
xsubckt_2407_nand2_x0 1 0 5943 768 249 nand2_x0
xsubckt_2008_mx2_x2 0 9403 1 7917 420 388 mx2_x2
xsubckt_2006_mx2_x2 0 9404 1 7917 421 389 mx2_x2
xsubckt_2004_mx2_x2 0 9405 1 7918 422 390 mx2_x2
xsubckt_1809_ao22_x2 0 6576 1 6592 199 8416 ao22_x2
xsubckt_517_ao22_x2 0 7821 1 7962 7984 8274 ao22_x2
xsubckt_126_inv_x0 1 0 563 8273 inv_x0
xsubckt_128_inv_x0 1 0 569 8271 inv_x0
xsubckt_2621_ao22_x2 0 5734 1 5751 5749 5746 ao22_x2
xsubckt_3279_mx2_x2 0 5087 1 811 1051 1019 mx2_x2
xsubckt_3872_xr2_x1 4504 0 1 230 749 xr2_x1
xsubckt_4852_ao22_x2 0 3982 1 3984 8346 1930 ao22_x2
xsubckt_5006_a3_x2 1 3869 0 45 71 8397 a3_x2
xsubckt_5201_a3_x2 1 3691 0 45 149 8398 a3_x2
xsubckt_6701_mx2_x2 0 2330 1 841 1229 1197 mx2_x2
xsubckt_7268_nor2_x0 1 0 8565 8566 8567 nor2_x0
xsubckt_7581_mx2_x2 0 9234 1 8470 6043 1198 mx2_x2
xsubckt_7583_mx2_x2 0 9232 1 8470 6026 1195 mx2_x2
xsubckt_7627_mx2_x2 0 9192 1 8460 6245 1415 mx2_x2
xsubckt_8431_sff1_x4 1 2057 0 9926 1914 sff1_x4
xsubckt_8519_sff1_x4 1 2159 0 9838 133 sff1_x4
xsubckt_8954_sff1_x4 1 2212 0 9471 1596 sff1_x4
xsubckt_1596_oa22_x2 0 6775 1 6788 6783 6784 oa22_x2
xsubckt_1073_oa22_x2 0 169 1 7299 7298 7286 oa22_x2
xsubckt_2495_nand2_x0 1 0 5857 5872 8013 nand2_x0
xsubckt_2746_mx2_x2 0 5611 1 812 1766 1734 mx2_x2
xsubckt_2748_mx2_x2 0 5609 1 8033 5610 5611 mx2_x2
xsubckt_2834_nand3_x0 1 0 5524 5534 5538 772 nand3_x0
xsubckt_3109_nand2_x0 1 0 5254 5255 779 nand2_x0
xsubckt_5046_a3_x2 1 3835 0 3942 3945 3948 a3_x2
xsubckt_5225_ao22_x2 0 3668 1 3669 3670 3675 ao22_x2
xsubckt_5447_a4_x2 0 3465 1 2018 2029 2040 2041 a4_x2
xsubckt_5468_nor2_x0 1 0 9800 3451 3452 nor2_x0
xsubckt_6310_mx2_x2 0 2710 1 844 1593 1561 mx2_x2
xsubckt_6312_mx2_x2 0 2708 1 844 1497 1465 mx2_x2
xsubckt_6314_mx2_x2 0 2706 1 8219 2707 2708 mx2_x2
xsubckt_6703_mx2_x2 0 2328 1 8219 2329 2330 mx2_x2
xsubckt_6705_mx2_x2 0 2326 1 843 1645 1613 mx2_x2
xsubckt_6707_mx2_x2 0 2324 1 8219 2325 2326 mx2_x2
xsubckt_7587_mx2_x2 0 9230 1 8465 6282 1091 mx2_x2
xsubckt_7589_mx2_x2 0 9228 1 8465 6273 1079 mx2_x2
xsubckt_8427_sff1_x4 1 2060 0 9930 1932 sff1_x4
xsubckt_9327_sff1_x4 1 2216 0 9113 1013 sff1_x4
xspare_buffer_129 1 0 2199 2188 buf_x4
xspare_buffer_128 1 0 2199 2189 buf_x4
xspare_buffer_126 1 0 2199 2190 buf_x4
xspare_buffer_125 1 0 2199 2191 buf_x4
xspare_buffer_124 1 0 2199 2192 buf_x4
xspare_buffer_122 1 0 2199 2193 buf_x4
xspare_buffer_121 1 0 2199 2194 buf_x4
xspare_buffer_120 1 0 2199 2195 buf_x4
xsubckt_2339_a3_x2 1 6031 0 6032 541 8409 a3_x2
xsubckt_1820_a3_x2 1 6565 0 6566 6567 6568 a3_x2
xsubckt_1717_ao22_x2 0 6662 1 6676 205 8415 ao22_x2
xsubckt_1465_nxr2_x1 6897 1 0 6902 8067 nxr2_x1
xsubckt_1345_nand2_x0 1 0 7020 7021 7024 nand2_x0
xsubckt_1224_a2_x2 0 7141 1 201 233 a2_x2
xsubckt_1204_a2_x2 0 7161 1 197 229 a2_x2
xsubckt_561_nand3_x0 1 0 7776 7777 7778 7780 nand3_x0
xsubckt_2609_xr2_x1 5745 0 1 223 742 xr2_x1
xsubckt_3019_nand2_x0 1 0 5342 6007 8101 nand2_x0
xsubckt_3082_a2_x2 0 5280 1 5281 5283 a2_x2
xsubckt_3749_oa22_x2 0 4625 1 4685 4683 4682 oa22_x2
xsubckt_5299_ao22_x2 0 3599 1 3600 3611 7884 ao22_x2
xsubckt_5330_nxr2_x1 3571 1 0 3588 3882 nxr2_x1
xsubckt_5388_nand3_x0 1 0 3517 43 135 8399 nand3_x0
xsubckt_6270_mx2_x2 0 2749 1 865 1146 1114 mx2_x2
xsubckt_6272_mx2_x2 0 2747 1 8211 2748 2751 mx2_x2
xsubckt_6316_mx2_x2 0 2704 1 827 2705 2712 mx2_x2
xsubckt_6661_mx2_x2 0 2369 1 827 2370 2377 mx2_x2
xsubckt_6663_mx2_x2 0 2367 1 854 1294 1262 mx2_x2
xsubckt_6709_mx2_x2 0 2322 1 854 1421 1389 mx2_x2
xsubckt_6799_nor2_x0 1 0 9677 8858 8859 nor2_x0
xsubckt_7962_sff1_x4 1 2166 0 10395 236 sff1_x4
xsubckt_8862_sff1_x4 1 2060 0 9563 502 sff1_x4
xsubckt_914_nand2_x0 1 0 7436 630 1933 nand2_x0
xsubckt_2564_nand3_x0 1 0 5789 5790 5791 7856 nand3_x0
xsubckt_3571_a2_x2 0 4800 1 235 754 a2_x2
xsubckt_4666_a3_x2 1 4123 0 4124 4129 4143 a3_x2
xsubckt_5603_a2_x2 0 9758 1 3358 3359 a2_x2
xsubckt_5623_a2_x2 0 9752 1 3344 3345 a2_x2
xsubckt_6274_mx2_x2 0 2745 1 865 1594 1562 mx2_x2
xsubckt_6276_mx2_x2 0 2743 1 865 1498 1466 mx2_x2
xsubckt_6357_a2_x2 0 9691 1 2665 2699 a2_x2
xsubckt_6665_mx2_x2 0 2365 1 865 1230 1198 mx2_x2
xsubckt_6667_mx2_x2 0 2363 1 8220 2364 2365 mx2_x2
xsubckt_6669_mx2_x2 0 2361 1 865 1646 1614 mx2_x2
xsubckt_6788_oa22_x2 0 8866 1 3190 8869 8867 oa22_x2
xsubckt_8335_sff1_x4 1 2198 0 10022 1345 sff1_x4
xsubckt_8770_sff1_x4 1 2070 0 9652 612 sff1_x4
xsubckt_8858_sff1_x4 1 2136 0 9567 1514 sff1_x4
xsubckt_9235_sff1_x4 1 2109 0 9205 1073 sff1_x4
xcmpt_cpu_state_bit3_hfns_3 1 0 1910 1900 buf_x4
xcmpt_cpu_state_bit3_hfns_2 1 0 1900 1901 buf_x4
xcmpt_cpu_state_bit3_hfns_1 1 0 1900 1902 buf_x4
xcmpt_cpu_state_bit3_hfns_0 1 0 1900 1903 buf_x4
xcmpt_abc_30082_new_n5686_hfns_2 1 0 5959 5956 buf_x4
xcmpt_abc_30082_new_n5686_hfns_1 1 0 5956 5957 buf_x4
xcmpt_abc_30082_new_n5686_hfns_0 1 0 5956 5958 buf_x4
xspare_buffer_138 1 0 2186 2180 buf_x4
xspare_buffer_137 1 0 2186 2181 buf_x4
xspare_buffer_136 1 0 2186 2182 buf_x4
xspare_buffer_134 1 0 2186 2183 buf_x4
xspare_buffer_133 1 0 2186 2184 buf_x4
xspare_buffer_132 1 0 2186 2185 buf_x4
xspare_buffer_130 1 0 2199 2187 buf_x4
xsubckt_1682_nand3_x0 1 0 6694 6695 6696 6697 nand3_x0
xsubckt_1598_a2_x2 0 6773 1 6774 8416 a2_x2
xsubckt_467_nand4_x0 1 0 7869 7905 7912 54 8402 nand4_x0
xsubckt_734_nand2_x0 1 0 7607 630 1942 nand2_x0
xsubckt_2662_a2_x2 0 5693 1 5694 5949 a2_x2
xsubckt_3002_nand2_x0 1 0 5359 5360 8020 nand2_x0
xsubckt_5488_a2_x2 0 9794 1 3437 3438 a2_x2
xsubckt_5888_oa22_x2 0 3120 1 3191 3123 3121 oa22_x2
xsubckt_6278_mx2_x2 0 2741 1 8221 2742 2743 mx2_x2
xsubckt_7958_sff1_x4 1 2166 0 10399 241 sff1_x4
xsubckt_9143_sff1_x4 1 2119 0 9297 1101 sff1_x4
xsubckt_2181_nxr2_x1 6254 1 0 6263 8359 nxr2_x1
xsubckt_1793_a2_x2 0 6591 1 6592 8415 a2_x2
xsubckt_1258_xr2_x1 7107 0 1 207 240 xr2_x1
xsubckt_1254_xr2_x1 7111 0 1 208 241 xr2_x1
xsubckt_40_inv_x0 1 0 127 8371 inv_x0
xsubckt_644_nand2_x0 1 0 7696 633 1943 nand2_x0
xsubckt_3709_nand2_x0 1 0 4664 4665 781 nand2_x0
xsubckt_5284_nor2_x0 1 0 3613 3614 7880 nor2_x0
xsubckt_5729_nor2_x0 1 0 3273 3274 7818 nor2_x0
xsubckt_5747_mx2_x2 0 3258 1 866 1315 1283 mx2_x2
xsubckt_5749_mx2_x2 0 3256 1 835 3257 3258 mx2_x2
xsubckt_5997_a2_x2 0 9701 1 3015 3049 a2_x2
xsubckt_6031_o2_x2 0 2981 1 2982 7931 o2_x2
xsubckt_6924_nor4_x0 1 0 8767 381 380 379 378 nor4_x0
xsubckt_7873_buf_x1 1 0 1891 9006 buf_x1
xsubckt_7875_buf_x1 1 0 1879 9004 buf_x1
xsubckt_8243_sff1_x4 1 2232 0 10114 1693 sff1_x4
xsubckt_8766_sff1_x4 1 2073 0 9656 626 sff1_x4
xsubckt_9500_sff1_x4 1 2136 0 8943 1834 sff1_x4
xspare_buffer_149 1 0 2173 2171 buf_x4
xspare_buffer_148 1 0 2173 2172 buf_x4
xspare_buffer_146 1 0 2186 2174 buf_x4
xspare_buffer_145 1 0 2186 2175 buf_x4
xspare_buffer_144 1 0 2186 2176 buf_x4
xspare_buffer_142 1 0 2186 2177 buf_x4
xspare_buffer_141 1 0 2186 2178 buf_x4
xspare_buffer_140 1 0 2186 2179 buf_x4
xsubckt_1662_nor3_x0 1 0 6713 6714 6726 6729 nor3_x0
xsubckt_1292_o2_x2 0 7073 1 192 219 o2_x2
xsubckt_46_inv_x0 1 0 90 8365 inv_x0
xsubckt_44_inv_x0 1 0 133 8367 inv_x0
xsubckt_42_inv_x0 1 0 129 8369 inv_x0
xsubckt_554_nand2_x0 1 0 7782 7783 7784 nand2_x0
xsubckt_922_oa22_x2 0 7429 1 7447 7446 7445 oa22_x2
xsubckt_1077_o2_x2 0 7282 1 7283 7285 o2_x2
xsubckt_3090_o2_x2 0 5273 1 244 763 o2_x2
xsubckt_3529_nand2_x0 1 0 4841 4842 781 nand2_x0
xsubckt_4430_mx2_x2 0 10135 1 4178 6070 1265 mx2_x2
xsubckt_4432_mx2_x2 0 10133 1 4178 6054 1263 mx2_x2
xsubckt_7069_oa22_x2 0 8672 1 702 8244 8273 oa22_x2
xsubckt_7308_nand2_x0 1 0 8533 723 652 nand2_x0
xsubckt_7877_buf_x1 1 0 1865 9002 buf_x1
xsubckt_7879_buf_x1 1 0 1863 9000 buf_x1
xsubckt_8600_sff1_x4 1 2047 0 9757 1993 sff1_x4
xsubckt_9051_sff1_x4 1 2198 0 9379 1376 sff1_x4
xsubckt_9139_sff1_x4 1 2137 0 9301 1105 sff1_x4
xsubckt_2341_ao22_x2 0 6029 1 69 6039 6295 ao22_x2
xsubckt_48_inv_x0 1 0 62 8363 inv_x0
xsubckt_918_oa22_x2 0 7432 1 7433 7437 7793 oa22_x2
xsubckt_2900_nand2_x0 1 0 5459 6007 8105 nand2_x0
xsubckt_3349_nand2_x0 1 0 5018 5019 784 nand2_x0
xsubckt_3929_nor2_x0 1 0 4448 229 748 nor2_x0
xsubckt_4390_mx2_x2 0 10171 1 4186 6108 1717 mx2_x2
xsubckt_4434_mx2_x2 0 10131 1 4179 6034 1261 mx2_x2
xsubckt_4436_mx2_x2 0 10129 1 4179 6018 1258 mx2_x2
xsubckt_5114_nor2_x0 1 0 3771 3772 7881 nor2_x0
xsubckt_6679_o2_x2 0 2351 1 2352 7931 o2_x2
xsubckt_7180_ao22_x2 0 8629 1 6494 7803 436 ao22_x2
xsubckt_7861_oa22_x2 0 8423 1 8424 8651 8303 oa22_x2
xsubckt_8151_sff1_x4 1 2247 0 10206 1465 sff1_x4
xsubckt_8239_sff1_x4 1 2192 0 10118 1697 sff1_x4
xsubckt_8674_sff1_x4 1 2182 0 9715 513 sff1_x4
xspare_buffer_158 1 0 2173 2164 buf_x4
xspare_buffer_157 1 0 2173 2165 buf_x4
xspare_buffer_156 1 0 2173 2166 buf_x4
xspare_buffer_154 1 0 2173 2167 buf_x4
xspare_buffer_153 1 0 2173 2168 buf_x4
xspare_buffer_152 1 0 2173 2169 buf_x4
xspare_buffer_150 1 0 2173 2170 buf_x4
xsubckt_1634_nxr2_x1 6739 1 0 6741 210 nxr2_x1
xsubckt_356_a3_x2 1 469 0 7997 7998 55 a3_x2
xsubckt_830_oa22_x2 0 7516 1 7517 7614 8284 oa22_x2
xsubckt_3901_mx2_x2 0 4475 1 816 1232 1200 mx2_x2
xsubckt_3903_mx2_x2 0 4473 1 8036 4474 4475 mx2_x2
xsubckt_3905_mx2_x2 0 4471 1 816 1360 1328 mx2_x2
xsubckt_4392_mx2_x2 0 10169 1 4185 6089 1715 mx2_x2
xsubckt_4394_mx2_x2 0 10167 1 4185 6071 1713 mx2_x2
xsubckt_4396_mx2_x2 0 10165 1 4185 6053 1711 mx2_x2
xsubckt_9047_sff1_x4 1 2198 0 9383 1350 sff1_x4
xsubckt_9482_sff1_x4 1 2225 0 8961 1854 sff1_x4
xcmpt_abc_30082_new_n3459_hfns_6 1 0 8216 8209 buf_x4
xcmpt_abc_30082_new_n3459_hfns_5 1 0 8209 8210 buf_x4
xcmpt_abc_30082_new_n3459_hfns_4 1 0 8209 8211 buf_x4
xcmpt_abc_30082_new_n3459_hfns_3 1 0 8209 8212 buf_x4
xcmpt_abc_30082_new_n3459_hfns_2 1 0 8209 8213 buf_x4
xcmpt_abc_30082_new_n3459_hfns_1 1 0 8209 8214 buf_x4
xcmpt_abc_30082_new_n3459_hfns_0 1 0 8209 8215 buf_x4
xsubckt_2287_nand2_x0 1 0 6099 6100 6104 nand2_x0
xsubckt_424_a2_x2 0 7920 1 364 367 a2_x2
xsubckt_1150_oa22_x2 0 7213 1 7231 7230 7229 oa22_x2
xsubckt_2716_nand3_x0 1 0 5640 5650 5654 772 nand3_x0
xsubckt_3123_mx2_x2 0 5240 1 793 1150 1118 mx2_x2
xsubckt_3127_mx2_x2 0 5236 1 793 1310 1278 mx2_x2
xsubckt_3169_nand2_x0 1 0 5195 5196 780 nand2_x0
xsubckt_3470_mx2_x2 0 4899 1 793 920 888 mx2_x2
xsubckt_3518_mx2_x2 0 4852 1 793 982 950 mx2_x2
xsubckt_3907_mx2_x2 0 4469 1 8029 4470 4471 mx2_x2
xsubckt_4398_mx2_x2 0 10163 1 4186 6035 1709 mx2_x2
xsubckt_7176_ao22_x2 0 8632 1 3285 3288 324 ao22_x2
xsubckt_7560_mx3_x2 1 0 9255 8472 6295 1190 6235 6239 mx3_x2
xsubckt_7820_mx2_x2 0 9010 1 8433 6043 910 mx2_x2
xsubckt_8147_sff1_x4 1 2238 0 10210 1469 sff1_x4
xsubckt_8504_sff1_x4 1 2159 0 9853 82 sff1_x4
xsubckt_8582_sff1_x4 1 2096 0 9775 2013 sff1_x4
xsubckt_9404_sff1_x4 1 2136 0 9039 938 sff1_x4
xspare_buffer_169 1 0 2160 2155 buf_x4
xspare_buffer_168 1 0 2160 2156 buf_x4
xspare_buffer_166 1 0 2160 2157 buf_x4
xspare_buffer_165 1 0 2160 2158 buf_x4
xspare_buffer_164 1 0 2160 2159 buf_x4
xspare_buffer_162 1 0 2173 2161 buf_x4
xspare_buffer_161 1 0 2173 2162 buf_x4
xspare_buffer_160 1 0 2173 2163 buf_x4
xsubckt_1542_nxr2_x1 6825 1 0 6828 219 nxr2_x1
xsubckt_323_inv_x0 1 0 194 8053 inv_x0
xsubckt_321_inv_x0 1 0 191 8055 inv_x0
xsubckt_3332_nand2_x0 1 0 5035 240 759 nand2_x0
xsubckt_3333_xr2_x1 5034 0 1 240 759 xr2_x1
xsubckt_3472_mx2_x2 0 4897 1 8029 4898 4899 mx2_x2
xsubckt_3474_mx2_x2 0 4895 1 818 1496 1464 mx2_x2
xsubckt_3476_mx2_x2 0 4893 1 8029 4894 4895 mx2_x2
xsubckt_7040_mx2_x2 0 9618 1 6440 9415 721 mx2_x2
xsubckt_7042_mx2_x2 0 9617 1 6440 9414 720 mx2_x2
xsubckt_7431_mx2_x2 0 9376 1 8489 6170 1373 mx2_x2
xsubckt_7433_mx2_x2 0 9374 1 8490 6152 1371 mx2_x2
xsubckt_7562_mx3_x2 1 0 9253 8472 6290 1188 6216 6220 mx3_x2
xsubckt_7564_mx3_x2 1 0 9251 8472 6290 1216 6197 6201 mx3_x2
xsubckt_7822_mx2_x2 0 9008 1 8434 6027 907 mx2_x2
xsubckt_8055_sff1_x4 1 2212 0 10302 1753 sff1_x4
xsubckt_8578_sff1_x4 1 2053 0 9779 2017 sff1_x4
xsubckt_9390_sff1_x4 1 2242 0 9053 954 sff1_x4
xsubckt_9478_sff1_x4 1 2192 0 8965 1828 sff1_x4
xsubckt_2446_nand3_x0 1 0 5905 5906 5907 8016 nand3_x0
xsubckt_2403_oa22_x2 0 5947 1 5953 5955 567 oa22_x2
xsubckt_2205_mx2_x2 0 6211 1 544 122 2286 mx2_x2
xsubckt_329_inv_x0 1 0 200 8047 inv_x0
xsubckt_327_inv_x0 1 0 198 8049 inv_x0
xsubckt_325_inv_x0 1 0 196 8051 inv_x0
xsubckt_281_inv_x0 1 0 239 8095 inv_x0
xsubckt_1047_nand2_x0 1 0 7310 629 1925 nand2_x0
xsubckt_1146_oa22_x2 0 7216 1 7217 7221 7793 oa22_x2
xsubckt_2550_mx2_x2 0 5803 1 776 5804 5811 mx2_x2
xsubckt_2941_mx2_x2 0 5419 1 8030 5420 5421 mx2_x2
xsubckt_2943_mx2_x2 0 5417 1 818 1249 1217 mx2_x2
xsubckt_3377_oa22_x2 0 4990 1 4991 5030 5957 oa22_x2
xsubckt_3478_mx2_x2 0 4891 1 818 1656 1624 mx2_x2
xsubckt_3949_nand2_x0 1 0 4428 4429 783 nand2_x0
xsubckt_5085_oa22_x2 0 3798 1 3799 3808 7881 oa22_x2
xsubckt_5094_nand2_x0 1 0 3790 3933 8278 nand2_x0
xsubckt_5345_a4_x2 0 3557 1 3559 3594 3604 3606 a4_x2
xsubckt_7021_nand2_x0 1 0 9631 8688 8689 nand2_x0
xsubckt_7044_mx2_x2 0 9616 1 6440 9413 719 mx2_x2
xsubckt_7046_mx2_x2 0 9615 1 6440 9412 718 mx2_x2
xsubckt_7435_mx2_x2 0 9372 1 8490 6135 1369 mx2_x2
xsubckt_7437_mx2_x2 0 9370 1 8490 6116 1366 mx2_x2
xsubckt_7439_mx2_x2 0 9368 1 8490 6097 1364 mx2_x2
xsubckt_7780_mx2_x2 0 9048 1 8439 6097 948 mx2_x2
xsubckt_7782_mx2_x2 0 9046 1 8439 6081 946 mx2_x2
xsubckt_7826_mx2_x2 0 8974 1 8429 6283 1859 mx2_x2
xsubckt_7828_mx2_x2 0 8972 1 8429 6272 1847 mx2_x2
xsubckt_8412_sff1_x4 1 2142 0 9945 1619 sff1_x4
xsubckt_8490_sff1_x4 1 2169 0 9867 66 sff1_x4
xsubckt_8935_sff1_x4 1 2083 0 9490 742 sff1_x4
xsubckt_9312_sff1_x4 1 2142 0 9128 999 sff1_x4
xsubckt_9386_sff1_x4 1 2242 0 9057 958 sff1_x4
xspare_buffer_178 1 0 2160 2148 buf_x4
xspare_buffer_177 1 0 2160 2149 buf_x4
xspare_buffer_176 1 0 2160 2150 buf_x4
xspare_buffer_174 1 0 2160 2151 buf_x4
xspare_buffer_173 1 0 2160 2152 buf_x4
xspare_buffer_172 1 0 2160 2153 buf_x4
xspare_buffer_170 1 0 2160 2154 buf_x4
xsubckt_2209_mx2_x2 0 6202 1 547 121 2285 mx2_x2
xsubckt_2165_mx2_x2 0 10446 1 6300 6278 1826 mx2_x2
xsubckt_2163_mx2_x2 0 6280 1 547 123 2287 mx2_x2
xsubckt_2153_ao22_x2 0 6305 1 6311 6308 6307 ao22_x2
xsubckt_1917_nand2_x0 1 0 466 6480 6481 nand2_x0
xsubckt_1503_a3_x2 1 6861 0 6862 6863 6864 a3_x2
xsubckt_1450_nxr2_x1 6911 1 0 6914 8137 nxr2_x1
xsubckt_287_inv_x0 1 0 2026 8089 inv_x0
xsubckt_285_inv_x0 1 0 235 8091 inv_x0
xsubckt_283_inv_x0 1 0 1993 8093 inv_x0
xsubckt_616_nand2_x0 1 0 7723 226 1898 nand2_x0
xsubckt_794_nand2_x0 1 0 7550 630 1939 nand2_x0
xsubckt_2945_mx2_x2 0 5415 1 8031 5416 5417 mx2_x2
xsubckt_2947_mx2_x2 0 5413 1 796 1377 1345 mx2_x2
xsubckt_2949_mx2_x2 0 5411 1 8031 5412 5413 mx2_x2
xsubckt_2977_nand2_x0 1 0 5384 5385 5386 nand2_x0
xsubckt_3769_nand2_x0 1 0 4605 4606 782 nand2_x0
xsubckt_4651_a4_x2 0 4134 1 703 1977 1976 1912 a4_x2
xsubckt_6120_mx2_x2 0 2895 1 8210 2896 2899 mx2_x2
xsubckt_6122_mx2_x2 0 2893 1 851 1374 1342 mx2_x2
xsubckt_6511_mx2_x2 0 2515 1 851 1170 1074 mx2_x2
xsubckt_6513_mx2_x2 0 2513 1 851 978 946 mx2_x2
xsubckt_7048_mx2_x2 0 9614 1 6441 9411 717 mx2_x2
xsubckt_7395_mx2_x2 0 9442 1 8495 6188 1567 mx2_x2
xsubckt_7784_mx2_x2 0 9044 1 8438 6062 944 mx2_x2
xsubckt_7786_mx2_x2 0 9042 1 8438 6044 942 mx2_x2
xsubckt_7788_mx2_x2 0 9040 1 8438 6027 939 mx2_x2
xsubckt_8486_sff1_x4 1 2163 0 9871 92 sff1_x4
xsubckt_9220_sff1_x4 1 2189 0 9220 1089 sff1_x4
xsubckt_9308_sff1_x4 1 2126 0 9132 1015 sff1_x4
xcmpt_abc_30082_new_n10841_hfns_2 1 0 8471 8468 buf_x4
xcmpt_abc_30082_new_n10841_hfns_1 1 0 8468 8469 buf_x4
xcmpt_abc_30082_new_n10841_hfns_0 1 0 8468 8470 buf_x4
xsubckt_2297_a3_x2 1 6085 0 6086 541 8409 a3_x2
xsubckt_2167_mx2_x2 0 6274 1 6289 6275 8357 mx2_x2
xsubckt_289_inv_x0 1 0 233 8087 inv_x0
xsubckt_726_o2_x2 0 7618 1 557 558 o2_x2
xsubckt_2887_nand2_x0 1 0 5472 5473 781 nand2_x0
xsubckt_3932_nand2_x0 1 0 4445 229 748 nand2_x0
xsubckt_6124_mx2_x2 0 2891 1 8225 2892 2893 mx2_x2
xsubckt_6126_mx2_x2 0 2889 1 856 1150 1118 mx2_x2
xsubckt_6128_mx2_x2 0 2887 1 8214 2888 2891 mx2_x2
xsubckt_6250_oa22_x2 0 2769 1 41 1905 207 oa22_x2
xsubckt_6471_mx2_x2 0 2554 1 856 1779 1747 mx2_x2
xsubckt_6515_mx2_x2 0 2511 1 835 2512 2513 mx2_x2
xsubckt_6517_mx2_x2 0 2509 1 828 2510 2517 mx2_x2
xsubckt_6519_mx2_x2 0 2507 1 856 1298 1266 mx2_x2
xsubckt_7397_mx2_x2 0 9440 1 8495 6170 1565 mx2_x2
xsubckt_7399_mx2_x2 0 9438 1 8495 6152 1563 mx2_x2
xsubckt_8320_sff1_x4 1 2132 0 10037 1647 sff1_x4
xsubckt_8408_sff1_x4 1 2251 0 9949 1624 sff1_x4
xsubckt_8843_sff1_x4 1 2203 0 9582 1531 sff1_x4
xsubckt_9294_sff1_x4 1 2216 0 9146 1046 sff1_x4
xcmpt_abc_30082_new_n5534_hfns_2 1 0 6153 6150 buf_x4
xcmpt_abc_30082_new_n5534_hfns_1 1 0 6150 6151 buf_x4
xcmpt_abc_30082_new_n5534_hfns_0 1 0 6150 6152 buf_x4
xspare_buffer_188 1 0 2147 2120 buf_x4
xspare_buffer_184 1 0 2147 2133 buf_x4
xspare_buffer_180 1 0 2147 2146 buf_x4
xsubckt_2091_a2_x2 0 6355 1 6356 6427 a2_x2
xsubckt_1182_a2_x2 0 7182 1 7183 7189 a2_x2
xsubckt_436_nand2_x0 1 0 7902 7905 7911 nand2_x0
xsubckt_605_xr2_x1 7734 0 1 745 70 xr2_x1
xsubckt_1030_nand2_x0 1 0 7326 633 1961 nand2_x0
xsubckt_2515_nand4_x0 1 0 5837 6008 7859 221 1899 nand4_x0
xsubckt_3311_nand3_x0 1 0 5055 5065 5069 771 nand3_x0
xsubckt_3589_nand2_x0 1 0 4782 4783 781 nand2_x0
xsubckt_4093_oa22_x2 0 4286 1 4287 4326 5958 oa22_x2
xsubckt_4437_a2_x2 0 4176 1 4182 4227 a2_x2
xsubckt_5350_oa22_x2 0 3552 1 3583 3559 3554 oa22_x2
xsubckt_5493_a3_x2 1 9792 0 3434 3435 40 a3_x2
xsubckt_5521_a2_x2 0 9783 1 3415 40 a2_x2
xsubckt_6080_mx2_x2 0 2934 1 8225 2935 2936 mx2_x2
xsubckt_6082_mx2_x2 0 2932 1 855 1055 1023 mx2_x2
xsubckt_6084_mx2_x2 0 2930 1 8214 2931 2934 mx2_x2
xsubckt_6473_mx2_x2 0 2552 1 8214 2553 2556 mx2_x2
xsubckt_6475_mx2_x2 0 2550 1 856 1171 1075 mx2_x2
xsubckt_6477_mx2_x2 0 2548 1 856 979 947 mx2_x2
xsubckt_7943_sff1_x4 1 2092 0 10414 248 sff1_x4
xsubckt_8394_sff1_x4 1 2251 0 9963 1608 sff1_x4
xsubckt_9216_sff1_x4 1 2142 0 9224 1063 sff1_x4
xcmpt_abc_30082_new_n5490_hfns_2 1 0 6217 6214 buf_x4
xcmpt_abc_30082_new_n5490_hfns_1 1 0 6214 6215 buf_x4
xcmpt_abc_30082_new_n5490_hfns_0 1 0 6214 6216 buf_x4
xsubckt_1925_a2_x2 0 6473 1 6474 6475 a2_x2
xsubckt_1905_a2_x2 0 6489 1 6490 6491 a2_x2
xsubckt_1877_nxr2_x1 6512 1 0 6516 8070 nxr2_x1
xsubckt_837_ao22_x2 0 7509 1 7510 7514 7795 ao22_x2
xsubckt_3131_nand3_x0 1 0 5232 5242 5246 771 nand3_x0
xsubckt_3743_a2_x2 0 4630 1 4631 4636 a2_x2
xsubckt_4898_a3_x2 1 3950 0 45 81 8398 a3_x2
xsubckt_4973_oa22_x2 0 9852 1 7884 3894 3896 oa22_x2
xsubckt_5940_mx2_x2 0 3070 1 8215 3071 3074 mx2_x2
xsubckt_5942_mx2_x2 0 3068 1 855 1349 1317 mx2_x2
xsubckt_5944_mx2_x2 0 3066 1 8218 3067 3068 mx2_x2
xsubckt_6086_mx2_x2 0 2928 1 855 1375 1343 mx2_x2
xsubckt_6088_mx2_x2 0 2926 1 8218 2927 2928 mx2_x2
xsubckt_6479_mx2_x2 0 2546 1 836 2547 2548 mx2_x2
xsubckt_6968_ao22_x2 0 8733 1 706 8277 642 ao22_x2
xsubckt_7653_a2_x2 0 8457 1 6310 551 a2_x2
xsubckt_7939_sff1_x4 1 2066 0 10455 830 sff1_x4
xsubckt_8316_sff1_x4 1 2142 0 10041 1651 sff1_x4
xsubckt_8751_sff1_x4 1 2083 0 9671 662 sff1_x4
xsubckt_8839_sff1_x4 1 2242 0 9586 1535 sff1_x4
xcmpt_abc_30082_new_n5494_hfns_2 1 0 6211 6208 buf_x4
xcmpt_abc_30082_new_n5494_hfns_1 1 0 6208 6209 buf_x4
xcmpt_abc_30082_new_n5494_hfns_0 1 0 6208 6210 buf_x4
xcmpt_abc_30082_new_n5498_hfns_2 1 0 6202 6199 buf_x4
xcmpt_abc_30082_new_n5498_hfns_1 1 0 6199 6200 buf_x4
xcmpt_abc_30082_new_n5498_hfns_0 1 0 6199 6201 buf_x4
xspare_buffer_198 1 0 2146 2143 buf_x4
xspare_buffer_197 1 0 2146 2144 buf_x4
xspare_buffer_196 1 0 2146 2145 buf_x4
xspare_buffer_192 1 0 2147 2107 buf_x4
xsubckt_2349_nand2_x0 1 0 6019 6020 6023 nand2_x0
xsubckt_683_nand3_x0 1 0 7659 7660 7661 7662 nand3_x0
xsubckt_3572_nand2_x0 1 0 4799 235 754 nand2_x0
xsubckt_4413_mx3_x2 1 0 10152 4181 6291 1253 6225 6230 mx3_x2
xsubckt_4415_mx3_x2 1 0 10150 4181 6291 1281 6206 6209 mx3_x2
xsubckt_4969_oa22_x2 0 9853 1 7886 3897 3899 oa22_x2
xsubckt_5232_nand4_x0 1 0 3662 3703 3903 3906 3909 nand4_x0
xsubckt_5246_nand2_x0 1 0 3649 3650 8294 nand2_x0
xsubckt_5336_nand2_x0 1 0 9817 3566 3572 nand2_x0
xsubckt_5946_mx2_x2 0 3064 1 855 1125 1093 mx2_x2
xsubckt_5948_mx2_x2 0 3062 1 8212 3063 3066 mx2_x2
xsubckt_8747_sff1_x4 1 2150 0 2298 2266 sff1_x4
xsubckt_9124_sff1_x4 1 2195 0 9316 1121 sff1_x4
xsubckt_903_oa22_x2 0 7447 1 7465 7463 7464 oa22_x2
xsubckt_2512_nand2_x0 1 0 5840 6012 8286 nand2_x0
xsubckt_2690_nand2_x0 1 0 5666 5667 8022 nand2_x0
xsubckt_3388_ao22_x2 0 4980 1 5040 5038 5035 ao22_x2
xsubckt_4631_mx2_x2 0 9948 1 4147 6116 1622 mx2_x2
xsubckt_6283_o2_x2 0 2736 1 2737 7931 o2_x2
xsubckt_8224_sff1_x4 1 2132 0 10133 1263 sff1_x4
xsubckt_8298_sff1_x4 1 2251 0 10059 1640 sff1_x4
xsubckt_9198_sff1_x4 1 2204 0 9242 1206 sff1_x4
xcmpt_abc_30082_new_n3305_hfns_4 1 0 8400 8395 buf_x4
xcmpt_abc_30082_new_n3305_hfns_3 1 0 8395 8396 buf_x4
xcmpt_abc_30082_new_n3305_hfns_2 1 0 8395 8397 buf_x4
xcmpt_abc_30082_new_n3305_hfns_1 1 0 8395 8398 buf_x4
xcmpt_abc_30082_new_n3305_hfns_0 1 0 8395 8399 buf_x4
xsubckt_1746_oa22_x2 0 6635 1 6656 6645 6636 oa22_x2
xsubckt_1707_nxr2_x1 6671 1 0 6674 238 nxr2_x1
xsubckt_1484_o2_x2 0 6879 1 6880 6888 o2_x2
xsubckt_3731_nand3_x0 1 0 4642 4652 4656 772 nand3_x0
xsubckt_4103_xr2_x1 4277 0 1 225 744 xr2_x1
xsubckt_4242_mx2_x2 0 10308 1 4209 6188 1759 mx2_x2
xsubckt_4244_mx2_x2 0 10306 1 4209 6169 1757 mx2_x2
xsubckt_4246_mx2_x2 0 10304 1 4209 6151 1755 mx2_x2
xsubckt_4377_mx3_x2 1 0 10184 4188 6292 1701 6226 6229 mx3_x2
xsubckt_4379_mx3_x2 1 0 10182 4188 6292 1729 6205 6210 mx3_x2
xsubckt_4633_mx2_x2 0 9946 1 4147 6097 1620 mx2_x2
xsubckt_4635_mx2_x2 0 9944 1 4147 6081 1618 mx2_x2
xsubckt_4637_mx2_x2 0 9942 1 4147 6062 1616 mx2_x2
xsubckt_4980_mx2_x2 0 3888 1 6445 6105 141 mx2_x2
xsubckt_6908_nand2_x0 1 0 8778 8807 8261 nand2_x0
xsubckt_7171_nand2_x0 1 0 8636 8637 8638 nand2_x0
xsubckt_8132_sff1_x4 1 2119 0 10225 1226 sff1_x4
xsubckt_8655_sff1_x4 1 2185 0 9734 534 sff1_x4
xsubckt_9032_sff1_x4 1 2083 0 9398 382 sff1_x4
xsubckt_2328_nand3_x0 1 0 6046 6047 6049 6292 nand3_x0
xsubckt_818_nor2_x0 1 0 7527 7528 7534 nor2_x0
xsubckt_3034_nand2_x0 1 0 5328 5329 5334 nand2_x0
xsubckt_3711_mx2_x2 0 4662 1 797 1843 1811 mx2_x2
xsubckt_3977_oa22_x2 0 4400 1 4401 4440 5958 oa22_x2
xsubckt_4248_mx2_x2 0 10302 1 4209 6135 1753 mx2_x2
xsubckt_4591_mx2_x2 0 9986 1 4152 6170 1501 mx2_x2
xsubckt_4593_mx2_x2 0 9984 1 4152 6152 1499 mx2_x2
xsubckt_4595_mx2_x2 0 9982 1 4152 6135 1497 mx2_x2
xsubckt_4639_mx2_x2 0 9940 1 4147 6044 1614 mx2_x2
xsubckt_4984_mx2_x2 0 3885 1 6445 6095 140 mx2_x2
xsubckt_5123_nxr2_x1 3763 1 0 3928 722 nxr2_x1
xsubckt_5162_oa22_x2 0 3727 1 3738 3736 3737 oa22_x2
xsubckt_6942_oa22_x2 0 8752 1 8757 8753 8755 oa22_x2
xsubckt_7803_mx3_x2 1 0 9027 8436 6292 928 6197 6200 mx3_x2
xsubckt_9028_sff1_x4 1 2083 0 9402 386 sff1_x4
xsubckt_9463_sff1_x4 1 2123 0 8980 1872 sff1_x4
xsubckt_2230_ao22_x2 0 6172 1 87 6183 6293 ao22_x2
xsubckt_1615_nxr2_x1 6757 1 0 6758 8059 nxr2_x1
xsubckt_1446_nand3_x0 1 0 6915 6926 8066 8416 nand3_x0
xsubckt_676_nand2_x0 1 0 7666 7667 7669 nand2_x0
xsubckt_2554_oa22_x2 0 5799 1 5848 5846 5845 oa22_x2
xsubckt_3551_nand3_x0 1 0 4819 4829 4833 771 nand3_x0
xsubckt_3715_mx2_x2 0 4658 1 797 1427 1395 mx2_x2
xsubckt_3719_mx2_x2 0 4654 1 797 1587 1555 mx2_x2
xsubckt_4597_mx2_x2 0 9980 1 4151 6115 1494 mx2_x2
xsubckt_4599_mx2_x2 0 9978 1 4151 6098 1492 mx2_x2
xsubckt_4988_mx2_x2 0 3882 1 6445 6086 139 mx2_x2
xsubckt_5119_nxr2_x1 3767 1 0 3782 3928 nxr2_x1
xsubckt_7315_oa22_x2 0 8527 1 700 8244 739 oa22_x2
xsubckt_8040_sff1_x4 1 2096 0 10317 1740 sff1_x4
xsubckt_8128_sff1_x4 1 2132 0 10229 1231 sff1_x4
xsubckt_8563_sff1_x4 1 2053 0 9794 2034 sff1_x4
xsubckt_1689_nxr2_x1 6688 1 0 6690 206 nxr2_x1
xsubckt_131_inv_x0 1 0 729 8268 inv_x0
xsubckt_586_nand2_x0 1 0 7752 756 81 nand2_x0
xsubckt_811_a2_x2 0 7534 1 245 1898 a2_x2
xsubckt_831_a2_x2 0 7515 1 244 1898 a2_x2
xsubckt_851_a2_x2 0 7496 1 243 1898 a2_x2
xsubckt_1002_nand2_x0 1 0 7353 7355 7357 nand2_x0
xsubckt_1131_oa22_x2 0 7231 1 7249 7247 7248 oa22_x2
xsubckt_2679_nand2_x0 1 0 5677 5679 5682 nand2_x0
xsubckt_2769_nand2_x0 1 0 5588 5589 8020 nand2_x0
xsubckt_3280_mx2_x2 0 5086 1 789 5087 5088 mx2_x2
xsubckt_3282_mx2_x2 0 5084 1 821 1883 1531 mx2_x2
xsubckt_3284_mx2_x2 0 5082 1 8035 5083 5084 mx2_x2
xsubckt_3371_nand3_x0 1 0 4996 5006 5010 770 nand3_x0
xsubckt_3904_nand2_x0 1 0 4472 4473 782 nand2_x0
xsubckt_7001_a4_x2 0 8703 1 8704 8706 8707 8709 a4_x2
xsubckt_7416_nand4_x0 1 0 8491 4183 6305 6312 7886 nand4_x0
xsubckt_7765_mx3_x2 1 0 9063 8441 6293 934 6235 6239 mx3_x2
xsubckt_8920_sff1_x4 1 2153 0 9505 757 sff1_x4
xsubckt_9371_sff1_x4 1 2136 0 9072 971 sff1_x4
xsubckt_9459_sff1_x4 1 2209 0 8984 1876 sff1_x4
xspare_buffer_309 1 0 2067 2065 buf_x4
xspare_buffer_308 1 0 2067 2066 buf_x4
xspare_buffer_306 1 0 2080 2068 buf_x4
xspare_buffer_305 1 0 2080 2069 buf_x4
xspare_buffer_304 1 0 2080 2070 buf_x4
xspare_buffer_302 1 0 2080 2071 buf_x4
xspare_buffer_301 1 0 2080 2072 buf_x4
xspare_buffer_300 1 0 2080 2073 buf_x4
xsubckt_133_inv_x0 1 0 378 8266 inv_x0
xsubckt_135_inv_x0 1 0 386 8264 inv_x0
xsubckt_137_inv_x0 1 0 715 8262 inv_x0
xsubckt_1127_oa22_x2 0 7234 1 7235 7239 7793 oa22_x2
xsubckt_2751_mx2_x2 0 5606 1 820 1830 1798 mx2_x2
xsubckt_3286_mx2_x2 0 5080 1 820 1723 1691 mx2_x2
xsubckt_3288_mx2_x2 0 5078 1 790 5079 5080 mx2_x2
xsubckt_7065_ao22_x2 0 9602 1 8677 8676 8675 ao22_x2
xsubckt_7243_mx2_x2 0 9508 1 8831 8585 753 mx2_x2
xsubckt_7590_mx2_x2 0 9227 1 8464 6266 1068 mx2_x2
xsubckt_7634_mx2_x2 0 9185 1 8459 6179 1438 mx2_x2
xsubckt_7636_mx2_x2 0 9183 1 8459 6162 1436 mx2_x2
xsubckt_7638_mx2_x2 0 9181 1 8459 6142 1434 mx2_x2
xsubckt_7767_mx3_x2 1 0 9061 8441 6294 932 6216 6220 mx3_x2
xsubckt_7769_mx3_x2 1 0 9059 8441 6294 960 6197 6201 mx3_x2
xsubckt_8036_sff1_x4 1 2119 0 10321 1130 sff1_x4
xsubckt_8471_sff1_x4 1 2047 0 9886 1933 sff1_x4
xsubckt_8559_sff1_x4 1 2047 0 9798 2038 sff1_x4
xsubckt_8994_sff1_x4 1 2145 0 9431 1555 sff1_x4
xsubckt_2155_a3_x2 1 6303 0 8004 8005 553 a3_x2
xsubckt_2131_nand3_x0 1 0 6316 6318 6427 8274 nand3_x0
xsubckt_1960_nand2_x0 1 0 447 6455 6473 nand2_x0
xsubckt_1870_nand2_x0 1 0 6519 6520 6521 nand2_x0
xsubckt_139_inv_x0 1 0 733 8260 inv_x0
xsubckt_604_o2_x2 0 7735 1 745 70 o2_x2
xsubckt_789_oa22_x2 0 7555 1 7556 7557 7617 oa22_x2
xsubckt_2499_nand2_x0 1 0 5853 5865 771 nand2_x0
xsubckt_2755_mx2_x2 0 5602 1 809 966 934 mx2_x2
xsubckt_3191_nand3_x0 1 0 5173 5183 5187 771 nand3_x0
xsubckt_3634_nand2_x0 1 0 4738 4739 4744 nand2_x0
xsubckt_5396_nand2_x0 1 0 9813 3510 3517 nand2_x0
xsubckt_6710_mx2_x2 0 2321 1 8222 2322 2323 mx2_x2
xsubckt_6712_mx2_x2 0 8940 1 827 8941 2327 mx2_x2
xsubckt_7249_mx2_x2 0 9506 1 8832 8581 755 mx2_x2
xsubckt_7592_mx2_x2 0 9225 1 8465 6252 1064 mx2_x2
xsubckt_7824_a4_x2 0 8431 1 4221 6303 6305 7885 a4_x2
xsubckt_8916_sff1_x4 1 2083 0 9509 752 sff1_x4
xsubckt_9367_sff1_x4 1 2129 0 9076 976 sff1_x4
xspare_buffer_318 1 0 2067 2058 buf_x4
xspare_buffer_317 1 0 2067 2059 buf_x4
xspare_buffer_316 1 0 2067 2060 buf_x4
xspare_buffer_314 1 0 2067 2061 buf_x4
xspare_buffer_313 1 0 2067 2062 buf_x4
xspare_buffer_312 1 0 2067 2063 buf_x4
xspare_buffer_310 1 0 2067 2064 buf_x4
xspare_buffer_8 1 0 2254 2200 buf_x4
xspare_buffer_4 1 0 2254 2253 buf_x4
xspare_buffer_0 1 0 2255 2254 buf_x4
xsubckt_2368_mx2_x2 0 5988 1 809 1667 1635 mx2_x2
xsubckt_2366_mx2_x2 0 5990 1 809 1507 1475 mx2_x2
xsubckt_1842_a4_x2 0 6545 1 6593 8048 8049 8050 a4_x2
xsubckt_1715_a3_x2 1 6664 0 6671 6686 6692 a3_x2
xsubckt_1461_a3_x2 1 6901 0 6903 445 8416 a3_x2
xsubckt_1314_a2_x2 0 7051 1 442 223 a2_x2
xsubckt_1035_oa22_x2 0 171 1 7335 7334 7322 oa22_x2
xsubckt_2759_mx2_x2 0 5598 1 809 1158 1062 mx2_x2
xsubckt_4041_a2_x2 0 4337 1 4338 4343 a2_x2
xsubckt_4688_a4_x2 0 4107 1 1915 1914 1975 1974 a4_x2
xsubckt_5218_nand2_x0 1 0 3675 3676 8295 nand2_x0
xsubckt_5371_a3_x2 1 3533 0 46 136 8397 a3_x2
xsubckt_5622_ao22_x2 0 3344 1 3348 1988 46 ao22_x2
xsubckt_6323_mx2_x2 0 2698 1 861 920 888 mx2_x2
xsubckt_6325_mx2_x2 0 2696 1 8222 2697 2698 mx2_x2
xsubckt_6327_mx2_x2 0 2694 1 861 1784 1752 mx2_x2
xsubckt_6670_mx2_x2 0 2360 1 861 1582 1550 mx2_x2
xsubckt_7323_nand2_x0 1 0 8521 726 653 nand2_x0
xsubckt_8467_sff1_x4 1 2057 0 9890 1937 sff1_x4
xsubckt_8824_sff1_x4 1 2079 0 319 561 sff1_x4
xsubckt_9201_sff1_x4 1 2139 0 9239 1203 sff1_x4
xcmpt_abc_30082_new_n5344_hfns_2 1 0 6393 6390 buf_x4
xcmpt_abc_30082_new_n5344_hfns_1 1 0 6390 6391 buf_x4
xcmpt_abc_30082_new_n5344_hfns_0 1 0 6390 6392 buf_x4
xsubckt_1775_a3_x2 1 6608 0 6615 6628 6635 a3_x2
xsubckt_558_mx2_x2 0 7779 1 217 400 413 mx2_x2
xsubckt_697_oa22_x2 0 7646 1 7669 7667 7668 oa22_x2
xsubckt_2517_a2_x2 0 5835 1 5836 5841 a2_x2
xsubckt_3971_nand3_x0 1 0 4406 4416 4420 772 nand3_x0
xsubckt_3988_ao22_x2 0 4390 1 4450 4448 4445 ao22_x2
xsubckt_4609_a2_x2 0 4149 1 4165 4194 a2_x2
xsubckt_5264_a2_x2 0 3632 1 3897 732 a2_x2
xsubckt_5854_oa22_x2 0 3154 1 50 1905 440 oa22_x2
xsubckt_6281_mx2_x2 0 2738 1 8206 2739 2754 mx2_x2
xsubckt_6329_mx2_x2 0 2692 1 8212 2693 2696 mx2_x2
xsubckt_6672_mx2_x2 0 2358 1 839 1486 1454 mx2_x2
xsubckt_6674_mx2_x2 0 2356 1 8226 2357 2358 mx2_x2
xsubckt_6676_mx2_x2 0 2354 1 828 2355 2362 mx2_x2
xsubckt_6754_oa22_x2 0 8900 1 50 1905 193 oa22_x2
xsubckt_6953_ao22_x2 0 8744 1 707 8276 620 ao22_x2
xsubckt_6995_a4_x2 0 8709 1 8710 8719 8267 375 a4_x2
xsubckt_7319_nand3_x0 1 0 8524 8525 8245 703 nand3_x0
xsubckt_7551_a2_x2 0 8472 1 4212 4218 a2_x2
xsubckt_7924_sff1_x4 1 2224 0 10428 1816 sff1_x4
xsubckt_8301_sff1_x4 1 2229 0 10056 1637 sff1_x4
xsubckt_8375_sff1_x4 1 2247 0 9982 1497 sff1_x4
xsubckt_8898_sff1_x4 1 2103 0 9527 324 sff1_x4
xsubckt_9275_sff1_x4 1 2116 0 9165 1058 sff1_x4
xcmpt_abc_30082_new_n5691_hfns_2 1 0 5951 5948 buf_x4
xcmpt_abc_30082_new_n5691_hfns_1 1 0 5948 5949 buf_x4
xcmpt_abc_30082_new_n5691_hfns_0 1 0 5948 5950 buf_x4
xspare_buffer_329 1 0 2054 2049 buf_x4
xspare_buffer_328 1 0 2054 2050 buf_x4
xspare_buffer_326 1 0 2054 2051 buf_x4
xspare_buffer_325 1 0 2054 2052 buf_x4
xspare_buffer_324 1 0 2054 2053 buf_x4
xspare_buffer_322 1 0 2067 2055 buf_x4
xspare_buffer_321 1 0 2067 2056 buf_x4
xspare_buffer_320 1 0 2067 2057 buf_x4
xsubckt_2214_nand2_x0 1 0 6192 6203 89 nand2_x0
xsubckt_1686_nand3_x0 1 0 6691 6720 8039 8040 nand3_x0
xsubckt_1422_nand2_x0 1 0 6937 6943 6967 nand2_x0
xsubckt_1307_xr2_x1 7058 0 1 440 221 xr2_x1
xsubckt_1303_xr2_x1 7062 0 1 439 220 xr2_x1
xsubckt_1199_a2_x2 0 7166 1 196 228 a2_x2
xsubckt_828_nand2_x0 1 0 7518 7810 426 nand2_x0
xsubckt_3006_nand2_x0 1 0 5355 5356 779 nand2_x0
xsubckt_3274_nand2_x0 1 0 5092 5093 5098 nand2_x0
xsubckt_3613_nand3_x0 1 0 4758 4778 4782 8012 nand3_x0
xsubckt_3791_nand3_x0 1 0 4583 4593 4597 771 nand3_x0
xsubckt_3935_a2_x2 0 4442 1 4443 4450 a2_x2
xsubckt_4669_a2_x2 0 9929 1 4121 53 a2_x2
xsubckt_4804_a2_x2 0 9896 1 4019 53 a2_x2
xsubckt_4844_a2_x2 0 9887 1 3988 53 a2_x2
xsubckt_5012_mx2_x2 0 3864 1 6444 6032 132 mx2_x2
xsubckt_5016_mx2_x2 0 3861 1 6444 6024 131 mx2_x2
xsubckt_5366_nxr2_x1 3537 1 0 3877 730 nxr2_x1
xsubckt_5558_a2_x2 0 9771 1 3390 53 a2_x2
xsubckt_5578_a2_x2 0 9765 1 3376 53 a2_x2
xsubckt_5750_mx2_x2 0 3255 1 839 1251 1219 mx2_x2
xsubckt_6287_mx2_x2 0 2733 1 839 921 889 mx2_x2
xsubckt_6289_mx2_x2 0 2731 1 8226 2732 2733 mx2_x2
xsubckt_6916_a2_x2 0 9651 1 8773 49 a2_x2
xsubckt_6936_a2_x2 0 8757 1 8827 578 a2_x2
xsubckt_7326_ao22_x2 0 9491 1 8522 8520 8519 ao22_x2
xsubckt_7998_sff1_x4 1 2110 0 10359 1777 sff1_x4
xsubckt_8732_sff1_x4 1 2185 0 2314 2282 sff1_x4
xsubckt_1302_o2_x2 0 7063 1 439 220 o2_x2
xsubckt_1265_xr2_x1 7100 0 1 209 242 xr2_x1
xsubckt_5327_oa22_x2 0 3573 1 3574 3589 7881 oa22_x2
xsubckt_5752_mx2_x2 0 3253 1 8224 3254 3255 mx2_x2
xsubckt_5754_mx2_x2 0 3251 1 838 1443 1411 mx2_x2
xsubckt_5756_mx2_x2 0 3249 1 833 3250 3251 mx2_x2
xsubckt_6426_ao22_x2 0 2597 1 574 567 754 ao22_x2
xsubckt_6949_ao22_x2 0 8747 1 707 8278 623 ao22_x2
xsubckt_6956_a2_x2 0 9642 1 8742 52 a2_x2
xsubckt_7880_buf_x1 1 0 1862 8999 buf_x1
xsubckt_7882_buf_x1 1 0 1860 8997 buf_x1
xsubckt_8283_sff1_x4 1 2238 0 10074 1300 sff1_x4
xsubckt_9105_sff1_x4 1 2142 0 9335 883 sff1_x4
xsubckt_9183_sff1_x4 1 2251 0 9257 1192 sff1_x4
xspare_buffer_338 1 0 2054 2042 buf_x4
xspare_buffer_337 1 0 2054 2043 buf_x4
xspare_buffer_336 1 0 2054 2044 buf_x4
xspare_buffer_334 1 0 2054 2045 buf_x4
xspare_buffer_333 1 0 2054 2046 buf_x4
xspare_buffer_332 1 0 2054 2047 buf_x4
xspare_buffer_330 1 0 2054 2048 buf_x4
xsubckt_1269_xr2_x1 7096 0 1 210 243 xr2_x1
xsubckt_53_inv_x0 1 0 67 8358 inv_x0
xsubckt_51_inv_x0 1 0 65 8360 inv_x0
xsubckt_3089_nor2_x0 1 0 5274 244 763 nor2_x0
xsubckt_3433_nand3_x0 1 0 4935 4955 4959 8012 nand3_x0
xsubckt_4618_mx3_x2 1 0 9961 4149 6288 1606 6235 6239 mx3_x2
xsubckt_4862_oa22_x2 0 3975 1 3978 1928 1927 oa22_x2
xsubckt_4963_mx3_x2 1 0 3901 6450 545 8382 8173 8174 mx3_x2
xsubckt_5274_nxr2_x1 3623 1 0 3637 3895 nxr2_x1
xsubckt_5631_nxr2_x1 3338 1 0 3341 8077 nxr2_x1
xsubckt_5758_mx2_x2 0 3247 1 838 1667 1635 mx2_x2
xsubckt_7884_buf_x1 1 0 1888 8995 buf_x1
xsubckt_7886_buf_x1 1 0 1886 8993 buf_x1
xsubckt_7888_buf_x1 1 0 1884 8991 buf_x1
xsubckt_8205_sff1_x4 1 2198 0 10152 1253 sff1_x4
xsubckt_8640_sff1_x4 1 2150 0 167 104 sff1_x4
xsubckt_8728_sff1_x4 1 2185 0 2318 2286 sff1_x4
xsubckt_9179_sff1_x4 1 2126 0 9261 1218 sff1_x4
xsubckt_1600_nxr2_x1 6771 1 0 6773 212 nxr2_x1
xsubckt_454_nand4_x0 1 0 7877 1908 614 41 8421 nand4_x0
xsubckt_55_inv_x0 1 0 1917 8356 inv_x0
xsubckt_57_inv_x0 1 0 1919 8354 inv_x0
xsubckt_59_inv_x0 1 0 1923 8352 inv_x0
xsubckt_1062_nand2_x0 1 0 7296 7297 1894 nand2_x0
xsubckt_2461_nand3_x0 1 0 5890 5891 5892 7857 nand3_x0
xsubckt_3253_nand3_x0 1 0 5112 5132 5136 8013 nand3_x0
xsubckt_4054_mx2_x2 0 4325 1 808 973 941 mx2_x2
xsubckt_4441_mx2_x2 0 10126 1 4174 6273 1687 mx2_x2
xsubckt_4443_mx2_x2 0 10124 1 4174 6259 1673 mx2_x2
xsubckt_4445_mx2_x2 0 10122 1 4174 6244 1671 mx2_x2
xsubckt_4731_nxr2_x1 4073 1 0 4076 8321 nxr2_x1
xsubckt_4967_mx3_x2 1 0 3898 6449 547 8383 8171 8172 mx3_x2
xsubckt_5235_oa22_x2 0 3659 1 3674 3672 3673 oa22_x2
xsubckt_8191_sff1_x4 1 2129 0 10166 1712 sff1_x4
xsubckt_8279_sff1_x4 1 2247 0 10078 1305 sff1_x4
xsubckt_9013_sff1_x4 1 2053 0 9417 372 sff1_x4
xsubckt_9091_sff1_x4 1 2192 0 9349 868 sff1_x4
xcmpt_abc_30082_new_n3460_hfns_2 1 0 8208 8205 buf_x4
xcmpt_abc_30082_new_n3460_hfns_1 1 0 8205 8206 buf_x4
xcmpt_abc_30082_new_n3460_hfns_0 1 0 8205 8207 buf_x4
xsubckt_1932_nand2_x0 1 0 463 6468 6469 nand2_x0
xsubckt_1679_nand2_x0 1 0 6697 6947 7107 nand2_x0
xsubckt_1674_nxr2_x1 6702 1 0 6705 240 nxr2_x1
xsubckt_1589_nand2_x0 1 0 6781 6783 6788 nand2_x0
xsubckt_621_a3_x2 1 7718 0 7719 7720 7721 a3_x2
xsubckt_3435_oa22_x2 0 4933 1 4934 4935 8017 oa22_x2
xsubckt_4056_mx2_x2 0 4323 1 789 4324 4325 mx2_x2
xsubckt_4058_mx2_x2 0 4321 1 808 1869 1517 mx2_x2
xsubckt_4652_nand4_x0 1 0 4133 702 1977 1976 1912 nand4_x0
xsubckt_5104_nxr2_x1 3781 1 0 3789 3931 nxr2_x1
xsubckt_7300_oa22_x2 0 8539 1 702 8244 766 oa22_x2
xsubckt_8113_sff1_x4 1 2248 0 10244 1247 sff1_x4
xsubckt_8636_sff1_x4 1 2156 0 171 108 sff1_x4
xsubckt_9087_sff1_x4 1 2225 0 9353 872 sff1_x4
xspare_feed_13 1 0 decap_w0
xspare_feed_12 1 0 decap_w0
xspare_feed_11 1 0 decap_w0
xspare_feed_10 1 0 decap_w0
xsubckt_1403_ao22_x2 0 6962 1 6963 6969 660 ao22_x2
xsubckt_2898_nand3_x0 1 0 5461 5462 5465 5949 nand3_x0
xsubckt_3073_nand3_x0 1 0 5289 5309 5313 8013 nand3_x0
xsubckt_3523_mx2_x2 0 4847 1 807 1174 1078 mx2_x2
xsubckt_3527_mx2_x2 0 4843 1 807 1782 1750 mx2_x2
xsubckt_5278_nand2_x0 1 0 3619 3895 8268 nand2_x0
xsubckt_8109_sff1_x4 1 2189 0 10248 1221 sff1_x4
xsubckt_8187_sff1_x4 1 2209 0 10170 1716 sff1_x4
xsubckt_9009_sff1_x4 1 2057 0 9421 398 sff1_x4
xsubckt_9444_sff1_x4 1 2189 0 8999 1862 sff1_x4
xspare_feed_19 1 0 decap_w0
xspare_feed_18 1 0 decap_w0
xspare_feed_17 1 0 decap_w0
xspare_feed_16 1 0 decap_w0
xspare_feed_15 1 0 decap_w0
xspare_feed_14 1 0 decap_w0
xsubckt_399_a2_x2 0 7946 1 7947 7948 a2_x2
xsubckt_330_inv_x0 1 0 201 8046 inv_x0
xsubckt_955_a3_x2 1 7397 0 7398 7399 7400 a3_x2
xsubckt_1041_nand3_x0 1 0 7316 7317 7318 1903 nand3_x0
xsubckt_1112_oa22_x2 0 7249 1 7267 7266 7265 oa22_x2
xsubckt_2601_mx2_x2 0 5753 1 8011 5754 5769 mx2_x2
xsubckt_3483_mx2_x2 0 4886 1 806 1144 1112 mx2_x2
xsubckt_5139_oa22_x2 0 3748 1 3750 3753 8295 oa22_x2
xsubckt_7205_nand2_x0 1 0 8612 8613 60 nand2_x0
xsubckt_7293_nand2_x0 1 0 8545 370 577 nand2_x0
xsubckt_7440_mx2_x2 0 9367 1 8490 6089 1363 mx2_x2
xsubckt_7831_mx2_x2 0 8969 1 8429 6252 1832 mx2_x2
xsubckt_8021_sff1_x4 1 2203 0 10336 1147 sff1_x4
xsubckt_8544_sff1_x4 1 2150 0 9813 135 sff1_x4
xsubckt_8901_sff1_x4 1 2123 0 9524 556 sff1_x4
xspare_feed_20 1 0 decap_w0
xsubckt_2212_mx2_x2 0 6194 1 547 120 2284 mx2_x2
xsubckt_357_nand3_x0 1 0 7993 7997 45 503 nand3_x0
xsubckt_336_inv_x0 1 0 207 8040 inv_x0
xsubckt_334_inv_x0 1 0 205 8042 inv_x0
xsubckt_332_inv_x0 1 0 203 8044 inv_x0
xsubckt_978_nand2_x0 1 0 174 7376 7388 nand2_x0
xsubckt_1108_oa22_x2 0 7252 1 7253 7257 7793 oa22_x2
xsubckt_3487_mx2_x2 0 4882 1 810 1304 1272 mx2_x2
xsubckt_3853_nand3_x0 1 0 4522 4542 4546 8012 nand3_x0
xsubckt_3878_mx2_x2 0 4498 1 811 1040 1008 mx2_x2
xsubckt_4038_nand2_x0 1 0 4340 6011 8078 nand2_x0
xsubckt_5058_nor2_x0 1 0 3823 3824 7881 nor2_x0
xsubckt_5351_nand2_x0 1 0 3551 3879 730 nand2_x0
xsubckt_5574_oa22_x2 0 3378 1 3382 2003 8305 oa22_x2
xsubckt_5610_a4_x2 0 3353 1 3360 1991 1992 1993 a4_x2
xsubckt_7053_mx2_x2 0 9605 1 8831 8684 768 mx2_x2
xsubckt_7442_mx2_x2 0 9365 1 8489 6071 1361 mx2_x2
xsubckt_7444_mx2_x2 0 9363 1 8489 6053 1359 mx2_x2
xsubckt_7446_mx2_x2 0 9361 1 8489 6034 1357 mx2_x2
xsubckt_8017_sff1_x4 1 2246 0 10340 1151 sff1_x4
xsubckt_8095_sff1_x4 1 2129 0 10262 1168 sff1_x4
xsubckt_8452_sff1_x4 1 2053 0 9905 1953 sff1_x4
xsubckt_8975_sff1_x4 1 2106 0 9450 1545 sff1_x4
xsubckt_9352_sff1_x4 1 2193 0 9091 992 sff1_x4
xspare_feed_29 1 0 decap_w0
xspare_feed_28 1 0 decap_w0
xspare_feed_27 1 0 decap_w0
xspare_feed_26 1 0 decap_w0
xspare_feed_25 1 0 decap_w0
xspare_feed_24 1 0 decap_w0
xspare_feed_23 1 0 decap_w0
xspare_feed_22 1 0 decap_w0
xspare_feed_21 1 0 decap_w0
xsubckt_2218_mx2_x2 0 6186 1 547 119 2283 mx2_x2
xsubckt_2172_mx2_x2 0 6267 1 6297 6268 6269 mx2_x2
xsubckt_2170_mx2_x2 0 6269 1 547 101 2265 mx2_x2
xsubckt_338_inv_x0 1 0 561 8038 inv_x0
xsubckt_294_inv_x0 1 0 1987 8082 inv_x0
xsubckt_292_inv_x0 1 0 232 8084 inv_x0
xsubckt_290_inv_x0 1 0 1989 8086 inv_x0
xsubckt_888_nand2_x0 1 0 7461 7463 7465 nand2_x0
xsubckt_3098_mx2_x2 0 5265 1 811 990 958 mx2_x2
xsubckt_3673_nand3_x0 1 0 4699 4719 4723 8011 nand3_x0
xsubckt_3693_xr2_x1 4680 0 1 233 752 xr2_x1
xsubckt_4741_a4_x2 0 4066 1 1964 1963 1962 1961 a4_x2
xsubckt_5014_a3_x2 1 3863 0 44 68 8397 a3_x2
xsubckt_5475_a4_x2 0 3446 1 3453 2037 2038 2039 a4_x2
xsubckt_5630_a4_x2 0 3339 1 3346 1984 1986 1987 a4_x2
xsubckt_6520_mx2_x2 0 2506 1 8219 2507 2508 mx2_x2
xsubckt_7057_mx2_x2 0 9604 1 6441 8681 571 mx2_x2
xsubckt_7448_mx2_x2 0 9359 1 8490 6018 1354 mx2_x2
xsubckt_7793_mx2_x2 0 9037 1 8434 6278 930 mx2_x2
xsubckt_7795_mx2_x2 0 9035 1 8434 6266 908 mx2_x2
xsubckt_7839_mx2_x2 0 8961 1 8429 6179 1854 mx2_x2
xsubckt_9348_sff1_x4 1 2193 0 9095 966 sff1_x4
xspare_feed_9 1 0 decap_w0
xspare_feed_8 1 0 decap_w0
xspare_feed_7 1 0 decap_w0
xspare_feed_6 1 0 decap_w0
xspare_feed_5 1 0 decap_w0
xspare_feed_4 1 0 decap_w0
xspare_feed_3 1 0 decap_w0
xspare_feed_2 1 0 decap_w0
xspare_feed_1 1 0 decap_w0
xspare_feed_0 1 0 decap_w0
xsubckt_2358_nor2_x0 1 0 6002 1899 1906 nor2_x0
xsubckt_2178_mx2_x2 0 10443 1 6300 6259 1801 mx2_x2
xsubckt_298_inv_x0 1 0 229 8078 inv_x0
xsubckt_296_inv_x0 1 0 230 8080 inv_x0
xsubckt_682_oa22_x2 0 7660 1 7801 7804 8124 oa22_x2
xsubckt_1037_a2_x2 0 7320 1 751 76 a2_x2
xsubckt_1124_nand2_x0 1 0 7237 1984 638 nand2_x0
xsubckt_2569_mx2_x2 0 10412 1 5993 5785 226 mx2_x2
xsubckt_2793_nor2_x0 1 0 5565 219 738 nor2_x0
xsubckt_3030_a2_x2 0 5332 1 245 764 a2_x2
xsubckt_5122_a2_x2 0 3764 1 3927 722 a2_x2
xsubckt_6131_mx2_x2 0 2884 1 8220 2885 2886 mx2_x2
xsubckt_6133_mx2_x2 0 2882 1 854 1438 1406 mx2_x2
xsubckt_6135_mx2_x2 0 2880 1 8211 2881 2884 mx2_x2
xsubckt_6522_mx2_x2 0 2504 1 854 1138 1106 mx2_x2
xsubckt_6524_mx2_x2 0 2502 1 8211 2503 2506 mx2_x2
xsubckt_6526_mx2_x2 0 2500 1 854 1586 1554 mx2_x2
xsubckt_6833_a4_x2 0 8836 1 9417 8843 9416 9420 a4_x2
xsubckt_7797_mx2_x2 0 9033 1 8434 6251 904 mx2_x2
xsubckt_7799_mx2_x2 0 9031 1 8434 6233 902 mx2_x2
xsubckt_8360_sff1_x4 1 2098 0 9997 1484 sff1_x4
xsubckt_8448_sff1_x4 1 2044 0 9909 1958 sff1_x4
xsubckt_8883_sff1_x4 1 2050 0 9542 353 sff1_x4
xsubckt_9260_sff1_x4 1 2246 0 9180 1433 sff1_x4
xcmpt_abc_30082_new_n5541_hfns_2 1 0 6144 6141 buf_x4
xcmpt_abc_30082_new_n5541_hfns_1 1 0 6141 6142 buf_x4
xcmpt_abc_30082_new_n5541_hfns_0 1 0 6141 6143 buf_x4
xspare_feed_39 1 0 decap_w0
xspare_feed_38 1 0 decap_w0
xspare_feed_37 1 0 decap_w0
xspare_feed_36 1 0 decap_w0
xspare_feed_35 1 0 decap_w0
xspare_feed_34 1 0 decap_w0
xspare_feed_33 1 0 decap_w0
xspare_feed_32 1 0 decap_w0
xspare_feed_31 1 0 decap_w0
xspare_feed_30 1 0 decap_w0
xsubckt_2347_oa22_x2 0 6021 1 6039 69 68 oa22_x2
xsubckt_1738_ao22_x2 0 6642 1 6659 6656 6644 ao22_x2
xsubckt_1653_a3_x2 1 6721 0 6722 6723 6724 a3_x2
xsubckt_1641_nand3_x0 1 0 6733 6760 8059 8060 nand3_x0
xsubckt_1272_a2_x2 0 7093 1 211 244 a2_x2
xsubckt_1252_a2_x2 0 7113 1 208 241 a2_x2
xsubckt_1034_nand2_x0 1 0 7322 7323 7331 nand2_x0
xsubckt_1057_a2_x2 0 7301 1 750 75 a2_x2
xsubckt_3493_nand3_x0 1 0 4876 4896 4900 8012 nand3_x0
xsubckt_3689_nor2_x0 1 0 4684 233 752 nor2_x0
xsubckt_4098_a2_x2 0 4281 1 4282 4286 a2_x2
xsubckt_4674_a3_x2 1 4117 0 4118 4124 4129 a3_x2
xsubckt_4703_ao22_x2 0 4094 1 1971 4097 54 ao22_x2
xsubckt_6091_mx2_x2 0 2923 1 8220 2924 2925 mx2_x2
xsubckt_6137_mx2_x2 0 2878 1 8207 2879 2894 mx2_x2
xsubckt_6212_oa22_x2 0 2805 1 3190 2808 2806 oa22_x2
xsubckt_6480_mx2_x2 0 2545 1 8210 2546 2549 mx2_x2
xsubckt_6482_mx2_x2 0 2543 1 865 1363 1331 mx2_x2
xsubckt_6484_mx2_x2 0 2541 1 8220 2542 2543 mx2_x2
xsubckt_6528_mx2_x2 0 2498 1 865 1490 1458 mx2_x2
xsubckt_6871_mx2_x2 0 8803 1 7917 8241 8259 mx2_x2
xsubckt_6873_mx2_x2 0 8802 1 7917 8240 8261 mx2_x2
xsubckt_7311_ao22_x2 0 9494 1 8534 8532 8531 ao22_x2
xsubckt_7983_sff1_x4 1 2192 0 10374 1793 sff1_x4
xsubckt_8805_sff1_x4 1 2066 0 9617 720 sff1_x4
xsubckt_9256_sff1_x4 1 2247 0 9184 1437 sff1_x4
xcmpt_abc_30082_new_n5547_hfns_2 1 0 6136 6133 buf_x4
xcmpt_abc_30082_new_n5547_hfns_1 1 0 6133 6134 buf_x4
xcmpt_abc_30082_new_n5547_hfns_0 1 0 6133 6135 buf_x4
xsubckt_1904_nand2_x0 1 0 6490 468 330 nand2_x0
xsubckt_1586_a2_x2 0 6784 1 6785 246 a2_x2
xsubckt_590_oa22_x2 0 7748 1 7750 7765 8422 oa22_x2
xsubckt_2904_a2_x2 0 5455 1 5456 5458 a2_x2
xsubckt_4722_a2_x2 0 4080 1 4083 1966 a2_x2
xsubckt_5496_a2_x2 0 9791 1 3432 47 a2_x2
xsubckt_5925_a2_x2 0 9703 1 3085 3119 a2_x2
xsubckt_5951_mx2_x2 0 3059 1 8221 3060 3061 mx2_x2
xsubckt_6093_mx2_x2 0 2921 1 866 1663 1631 mx2_x2
xsubckt_6095_mx2_x2 0 2919 1 8221 2920 2921 mx2_x2
xsubckt_6097_mx2_x2 0 2917 1 866 1439 1407 mx2_x2
xsubckt_6286_oa22_x2 0 2734 1 54 1905 206 oa22_x2
xsubckt_6486_mx2_x2 0 2539 1 866 1139 1107 mx2_x2
xsubckt_6488_mx2_x2 0 2537 1 8213 2538 2541 mx2_x2
xsubckt_6877_mx2_x2 0 9663 1 6441 8800 649 mx2_x2
xsubckt_7307_ao22_x2 0 8534 1 8606 8686 378 ao22_x2
xsubckt_7905_sff1_x4 1 2097 0 10447 1827 sff1_x4
xsubckt_7979_sff1_x4 1 2204 0 10378 1767 sff1_x4
xsubckt_8356_sff1_x4 1 2119 0 10001 1322 sff1_x4
xsubckt_8791_sff1_x4 1 2053 0 9631 631 sff1_x4
xsubckt_8879_sff1_x4 1 2070 0 9546 357 sff1_x4
xspare_feed_49 1 0 decap_w0
xspare_feed_48 1 0 decap_w0
xspare_feed_47 1 0 decap_w0
xspare_feed_46 1 0 decap_w0
xspare_feed_45 1 0 decap_w0
xspare_feed_44 1 0 decap_w0
xspare_feed_43 1 0 decap_w0
xspare_feed_42 1 0 decap_w0
xspare_feed_41 1 0 decap_w0
xspare_feed_40 1 0 decap_w0
xsubckt_1781_a2_x2 0 6602 1 6603 232 a2_x2
xsubckt_1751_nxr2_x1 6630 1 0 6632 202 nxr2_x1
xsubckt_1371_nand3_x0 1 0 6994 7129 204 8092 nand3_x0
xsubckt_513_nand2_x0 1 0 10458 7825 7828 nand2_x0
xsubckt_691_nand2_x0 1 0 7651 633 1921 nand2_x0
xsubckt_2964_a2_x2 0 5396 1 5397 5402 a2_x2
xsubckt_4782_a2_x2 0 4035 1 1951 1950 a2_x2
xsubckt_5953_mx2_x2 0 3057 1 866 1413 1381 mx2_x2
xsubckt_5955_mx2_x2 0 3055 1 8214 3056 3059 mx2_x2
xsubckt_6099_mx2_x2 0 2915 1 8214 2916 2919 mx2_x2
xsubckt_8713_sff1_x4 1 2153 0 9677 548 sff1_x4
xsubckt_9164_sff1_x4 1 2246 0 9276 1401 sff1_x4
xcmpt_instr_rdinstr_hfns_2 1 0 635 632 buf_x4
xcmpt_instr_rdinstr_hfns_1 1 0 632 633 buf_x4
xcmpt_instr_rdinstr_hfns_0 1 0 632 634 buf_x4
xsubckt_1878_oa22_x2 0 6511 1 6521 6520 6512 oa22_x2
xsubckt_1319_o2_x2 0 7046 1 456 237 o2_x2
xsubckt_508_oa22_x2 0 10464 1 7829 7832 7836 oa22_x2
xsubckt_365_nor4_x0 1 0 7983 657 665 612 663 nor4_x0
xsubckt_2694_nand2_x0 1 0 5662 5663 781 nand2_x0
xsubckt_3915_nand3_x0 1 0 4461 4462 4465 5949 nand3_x0
xsubckt_4380_mx3_x2 1 0 10181 4188 6294 1728 6197 6200 mx3_x2
xsubckt_5060_nand3_x0 1 0 3822 47 129 8399 nand3_x0
xsubckt_5227_nor2_x0 1 0 3666 3667 7881 nor2_x0
xsubckt_5957_mx2_x2 0 3053 1 8207 3054 3069 mx2_x2
xsubckt_6607_o2_x2 0 2421 1 2422 7930 o2_x2
xsubckt_8264_sff1_x4 1 2106 0 10093 1292 sff1_x4
xsubckt_8709_sff1_x4 1 2123 0 9681 195 sff1_x4
xsubckt_8787_sff1_x4 1 2073 0 9635 640 sff1_x4
xspare_feed_59 1 0 decap_w0
xspare_feed_58 1 0 decap_w0
xspare_feed_57 1 0 decap_w0
xspare_feed_56 1 0 decap_w0
xspare_feed_55 1 0 decap_w0
xspare_feed_54 1 0 decap_w0
xspare_feed_53 1 0 decap_w0
xspare_feed_52 1 0 decap_w0
xspare_feed_51 1 0 decap_w0
xspare_feed_50 1 0 decap_w0
xsubckt_1544_nand2_x0 1 0 6823 6825 6830 nand2_x0
xsubckt_4251_mx2_x2 0 10299 1 4209 6108 1749 mx2_x2
xsubckt_4253_mx2_x2 0 10297 1 4209 6089 1747 mx2_x2
xsubckt_4640_mx2_x2 0 9939 1 4147 6034 1613 mx2_x2
xsubckt_4642_mx2_x2 0 9937 1 4147 6018 1610 mx2_x2
xsubckt_6750_ao22_x2 0 8903 1 574 567 744 ao22_x2
xsubckt_6838_ao22_x2 0 8829 1 707 8278 661 ao22_x2
xsubckt_6993_nor2_x0 1 0 8711 8720 8723 nor2_x0
xsubckt_8621_sff1_x4 1 2169 0 157 94 sff1_x4
xsubckt_8695_sff1_x4 1 2172 0 9695 209 sff1_x4
xsubckt_9072_sff1_x4 1 2066 0 317 59 sff1_x4
xcmpt_instr_rdinstrh_hfns_2 1 0 631 628 buf_x4
xcmpt_instr_rdinstrh_hfns_1 1 0 628 629 buf_x4
xcmpt_instr_rdinstrh_hfns_0 1 0 628 630 buf_x4
xsubckt_1454_nand2_x0 1 0 6907 6943 7045 nand2_x0
xsubckt_1298_nxr2_x1 7067 1 0 191 218 nxr2_x1
xsubckt_858_nor2_x0 1 0 7489 7490 7496 nor2_x0
xsubckt_3720_mx2_x2 0 4653 1 8036 4654 4655 mx2_x2
xsubckt_4255_mx2_x2 0 10295 1 4209 6071 1745 mx2_x2
xsubckt_4257_mx2_x2 0 10293 1 4209 6053 1743 mx2_x2
xsubckt_4259_mx2_x2 0 10291 1 4208 6034 1741 mx2_x2
xsubckt_5587_nand3_x0 1 0 3369 3375 1999 2000 nand3_x0
xsubckt_5850_ao22_x2 0 3157 1 573 567 741 ao22_x2
xsubckt_8172_sff1_x4 1 2172 0 10185 1702 sff1_x4
xsubckt_8617_sff1_x4 1 2163 0 161 98 sff1_x4
xsubckt_9068_sff1_x4 1 2136 0 9362 1358 sff1_x4
xspare_feed_69 1 0 decap_w0
xspare_feed_68 1 0 decap_w0
xspare_feed_67 1 0 decap_w0
xspare_feed_66 1 0 decap_w0
xspare_feed_65 1 0 decap_w0
xspare_feed_64 1 0 decap_w0
xspare_feed_63 1 0 decap_w0
xspare_feed_62 1 0 decap_w0
xspare_feed_61 1 0 decap_w0
xspare_feed_60 1 0 decap_w0
xsubckt_412_a2_x2 0 7933 1 1906 55 a2_x2
xsubckt_3722_mx2_x2 0 4651 1 816 1235 1203 mx2_x2
xsubckt_3724_mx2_x2 0 4649 1 8036 4650 4651 mx2_x2
xsubckt_3726_mx2_x2 0 4647 1 816 1363 1331 mx2_x2
xsubckt_5520_nxr2_x1 3415 1 0 3419 8081 nxr2_x1
xsubckt_6904_oa22_x2 0 8781 1 8794 8785 8782 oa22_x2
xsubckt_8168_sff1_x4 1 2095 0 10189 1708 sff1_x4
xsubckt_9425_sff1_x4 1 2216 0 9018 918 sff1_x4
xsubckt_706_a2_x2 0 7637 1 7638 7641 a2_x2
xsubckt_901_a2_x2 0 7448 1 7449 7457 a2_x2
xsubckt_933_nand2_x0 1 0 7418 629 1931 nand2_x0
xsubckt_3291_mx2_x2 0 5075 1 793 1851 1819 mx2_x2
xsubckt_3339_mx2_x2 0 5028 1 793 1050 1018 mx2_x2
xsubckt_3728_mx2_x2 0 4645 1 8029 4646 4647 mx2_x2
xsubckt_3908_nand2_x0 1 0 4468 4469 8022 nand2_x0
xsubckt_7425_mx3_x2 1 0 9382 8492 6290 1349 6225 6230 mx3_x2
xsubckt_7427_mx3_x2 1 0 9380 8492 6287 1377 6206 6209 mx3_x2
xsubckt_8002_sff1_x4 1 2111 0 10355 1773 sff1_x4
xsubckt_8080_sff1_x4 1 2189 0 10277 1184 sff1_x4
xsubckt_8525_sff1_x4 1 2179 0 9832 125 sff1_x4
xsubckt_8960_sff1_x4 1 2223 0 9465 1589 sff1_x4
xsubckt_9499_sff1_x4 1 2139 0 8944 1835 sff1_x4
xcmpt_abc_30082_new_n7586_hfns_2 1 0 4200 4197 buf_x4
xcmpt_abc_30082_new_n7586_hfns_1 1 0 4197 4198 buf_x4
xcmpt_abc_30082_new_n7586_hfns_0 1 0 4197 4199 buf_x4
xspare_feed_79 1 0 decap_w0
xspare_feed_78 1 0 decap_w0
xspare_feed_77 1 0 decap_w0
xspare_feed_76 1 0 decap_w0
xspare_feed_75 1 0 decap_w0
xspare_feed_74 1 0 decap_w0
xspare_feed_73 1 0 decap_w0
xspare_feed_72 1 0 decap_w0
xspare_feed_71 1 0 decap_w0
xspare_feed_70 1 0 decap_w0
xsubckt_2312_a4_x2 0 6066 1 6093 76 75 74 a4_x2
xsubckt_2022_mx2_x2 0 6426 1 848 1303 1271 mx2_x2
xsubckt_1563_nxr2_x1 6805 1 0 6808 8113 nxr2_x1
xsubckt_140_inv_x0 1 0 394 8259 inv_x0
xsubckt_142_inv_x0 1 0 735 8257 inv_x0
xsubckt_144_inv_x0 1 0 723 8255 inv_x0
xsubckt_597_ao22_x2 0 7741 1 7742 7746 7795 ao22_x2
xsubckt_961_a2_x2 0 7392 1 755 80 a2_x2
xsubckt_981_a2_x2 0 7373 1 754 79 a2_x2
xsubckt_1167_oa22_x2 0 163 1 7210 7209 7197 oa22_x2
xsubckt_2789_ao22_x2 0 10408 1 5618 5570 5569 ao22_x2
xsubckt_2802_mx2_x2 0 5556 1 819 1029 997 mx2_x2
xsubckt_2806_mx2_x2 0 5552 1 819 1157 1061 mx2_x2
xsubckt_3021_nand2_x0 1 0 5340 6011 8110 nand2_x0
xsubckt_3152_xr2_x1 5212 0 1 243 762 xr2_x1
xsubckt_3295_mx2_x2 0 5071 1 818 1435 1403 mx2_x2
xsubckt_3324_oa22_x2 0 5042 1 5043 5090 5994 oa22_x2
xsubckt_4081_nand2_x0 1 0 4298 4299 780 nand2_x0
xsubckt_5032_oa22_x2 0 3847 1 3848 3849 3853 oa22_x2
xsubckt_5049_nand3_x0 1 0 3832 3833 3834 8294 nand3_x0
xsubckt_5067_nxr2_x1 3815 1 0 3940 726 nxr2_x1
xsubckt_7641_mx2_x2 0 9178 1 8460 6116 1430 mx2_x2
xsubckt_7643_mx2_x2 0 9176 1 8460 6098 1428 mx2_x2
xsubckt_7645_mx2_x2 0 9174 1 8460 6080 1426 mx2_x2
xsubckt_8076_sff1_x4 1 2189 0 10281 1158 sff1_x4
xsubckt_8599_sff1_x4 1 2047 0 9758 1994 sff1_x4
xsubckt_9333_sff1_x4 1 2126 0 9107 1007 sff1_x4
xsubckt_2419_mx2_x2 0 5932 1 817 1730 1698 mx2_x2
xsubckt_2417_mx2_x2 0 5934 1 817 930 898 mx2_x2
xsubckt_2371_mx2_x2 0 5985 1 783 5986 5989 mx2_x2
xsubckt_2028_mx2_x2 0 6420 1 8210 6421 6424 mx2_x2
xsubckt_2026_mx2_x2 0 6422 1 852 1143 1111 mx2_x2
xsubckt_2024_mx2_x2 0 6424 1 833 6425 6426 mx2_x2
xsubckt_1964_nand2_x0 1 0 444 6453 6465 nand2_x0
xsubckt_1343_nand3_x0 1 0 7022 7061 440 8123 nand3_x0
xsubckt_146_inv_x0 1 0 396 8253 inv_x0
xsubckt_148_inv_x0 1 0 397 8251 inv_x0
xsubckt_663_nand2_x0 1 0 7678 222 1898 nand2_x0
xsubckt_2760_mx2_x2 0 5597 1 8030 5598 5599 mx2_x2
xsubckt_2762_mx2_x2 0 5595 1 818 1222 1190 mx2_x2
xsubckt_2764_mx2_x2 0 5593 1 8030 5594 5595 mx2_x2
xsubckt_3017_nand3_x0 1 0 5344 5345 5348 5949 nand3_x0
xsubckt_3299_mx2_x2 0 5067 1 818 1595 1563 mx2_x2
xsubckt_4854_ao22_x2 0 9884 1 3981 3982 52 ao22_x2
xsubckt_5424_nxr2_x1 3483 1 0 3865 730 nxr2_x1
xsubckt_6721_mx2_x2 0 8932 1 8223 8933 8934 mx2_x2
xsubckt_7647_mx2_x2 0 9172 1 8460 6062 1424 mx2_x2
xsubckt_7649_mx2_x2 0 9170 1 8460 6044 1422 mx2_x2
xsubckt_8433_sff1_x4 1 2057 0 9924 1974 sff1_x4
xsubckt_8956_sff1_x4 1 2246 0 9469 1594 sff1_x4
xspare_feed_89 1 0 decap_w0
xspare_feed_88 1 0 decap_w0
xspare_feed_87 1 0 decap_w0
xspare_feed_86 1 0 decap_w0
xspare_feed_85 1 0 decap_w0
xspare_feed_84 1 0 decap_w0
xspare_feed_83 1 0 decap_w0
xspare_feed_82 1 0 decap_w0
xspare_feed_81 1 0 decap_w0
xspare_feed_80 1 0 decap_w0
xsubckt_2377_mx2_x2 0 5979 1 8031 5980 5981 mx2_x2
xsubckt_2375_mx2_x2 0 5981 1 796 1251 1219 mx2_x2
xsubckt_2373_mx2_x2 0 5983 1 796 1315 1283 mx2_x2
xsubckt_1971_mx3_x2 1 0 475 8002 6449 223 98 130 mx3_x2
xsubckt_1723_ao22_x2 0 6656 1 6664 6663 6658 ao22_x2
xsubckt_1606_nand2_x0 1 0 6765 6948 7087 nand2_x0
xsubckt_609_mx2_x2 0 7730 1 217 428 411 mx2_x2
xsubckt_659_nand3_x0 1 0 7682 7683 7684 7686 nand3_x0
xsubckt_2666_nand2_x0 1 0 5689 5690 7856 nand2_x0
xsubckt_2766_mx2_x2 0 5591 1 817 1350 1318 mx2_x2
xsubckt_2768_mx2_x2 0 5589 1 8031 5590 5591 mx2_x2
xsubckt_3202_a2_x2 0 5162 1 5163 5165 a2_x2
xsubckt_5040_a2_x2 0 3840 1 3945 3948 a2_x2
xsubckt_5382_nor2_x0 1 0 3522 3523 3525 nor2_x0
xsubckt_6330_mx2_x2 0 2691 1 851 1880 1528 mx2_x2
xsubckt_6332_mx2_x2 0 2689 1 8224 2690 2691 mx2_x2
xsubckt_6334_mx2_x2 0 2687 1 851 1048 1016 mx2_x2
xsubckt_6723_mx2_x2 0 8930 1 851 1771 1739 mx2_x2
xsubckt_6725_mx2_x2 0 8928 1 8210 8929 8932 mx2_x2
xsubckt_7327_nand2_x0 1 0 8518 8686 382 nand2_x0
xsubckt_8429_sff1_x4 1 2060 0 9928 1916 sff1_x4
xsubckt_9241_sff1_x4 1 2136 0 9199 1066 sff1_x4
xsubckt_9329_sff1_x4 1 2136 0 9111 1011 sff1_x4
xsubckt_2379_mx2_x2 0 5977 1 8016 5978 5985 mx2_x2
xsubckt_2201_nxr2_x1 6217 1 0 6232 8363 nxr2_x1
xsubckt_2158_a2_x2 0 6297 1 541 8409 a2_x2
xsubckt_1977_mx3_x2 1 0 499 8001 6448 247 122 154 mx3_x2
xsubckt_1975_mx3_x2 1 0 471 8001 6448 219 94 126 mx3_x2
xsubckt_1973_mx3_x2 1 0 473 8001 6448 221 96 128 mx3_x2
xsubckt_1516_nand2_x0 1 0 6849 6943 7059 nand2_x0
xsubckt_1424_a2_x2 0 6935 1 6936 6937 a2_x2
xsubckt_1229_a2_x2 0 7136 1 202 234 a2_x2
xsubckt_1209_a2_x2 0 7156 1 198 230 a2_x2
xsubckt_1190_a2_x2 0 7175 1 194 225 a2_x2
xsubckt_2627_xr2_x1 5728 0 1 222 741 xr2_x1
xsubckt_2974_xr2_x1 5387 0 1 246 765 xr2_x1
xsubckt_3262_a2_x2 0 5103 1 5104 5106 a2_x2
xsubckt_5286_a3_x2 1 3612 0 41 142 8397 a3_x2
xsubckt_5332_nxr2_x1 3569 1 0 3883 730 nxr2_x1
xsubckt_5801_mx2_x2 0 3205 1 830 3206 3209 mx2_x2
xsubckt_6290_mx2_x2 0 2730 1 857 1721 1689 mx2_x2
xsubckt_6336_mx2_x2 0 2685 1 8213 2686 2689 mx2_x2
xsubckt_6338_mx2_x2 0 2683 1 857 1368 1336 mx2_x2
xsubckt_6683_mx2_x2 0 2348 1 857 909 877 mx2_x2
xsubckt_6716_oa22_x2 0 8936 1 3191 8939 8937 oa22_x2
xsubckt_6727_mx2_x2 0 8926 1 857 1163 1067 mx2_x2
xsubckt_6729_mx2_x2 0 8924 1 857 971 939 mx2_x2
xsubckt_7192_a2_x2 0 8620 1 720 8422 a2_x2
xsubckt_7964_sff1_x4 1 2092 0 10393 234 sff1_x4
xsubckt_8341_sff1_x4 1 2203 0 10016 1339 sff1_x4
xsubckt_8864_sff1_x4 1 2060 0 9561 365 sff1_x4
xspare_feed_99 1 0 decap_w0
xspare_feed_98 1 0 decap_w0
xspare_feed_97 1 0 decap_w0
xspare_feed_96 1 0 decap_w0
xspare_feed_95 1 0 decap_w0
xspare_feed_94 1 0 decap_w0
xspare_feed_93 1 0 decap_w0
xspare_feed_92 1 0 decap_w0
xspare_feed_91 1 0 decap_w0
xspare_feed_90 1 0 decap_w0
xsubckt_2360_o4_x2 0 6000 1 1899 1908 1895 1906 o4_x2
xsubckt_2308_nand2_x0 1 0 6072 6073 6077 nand2_x0
xsubckt_1979_mx3_x2 1 0 497 8002 6449 245 120 152 mx3_x2
xsubckt_1312_xr2_x1 7053 0 1 441 222 xr2_x1
xsubckt_2607_a2_x2 0 5747 1 223 742 a2_x2
xsubckt_2798_nxr2_x1 5560 1 0 5561 5567 nxr2_x1
xsubckt_4036_oa22_x2 0 4342 1 224 6014 6012 oa22_x2
xsubckt_4680_a2_x2 0 9926 1 4113 40 a2_x2
xsubckt_4719_a2_x2 0 4082 1 4084 8319 a2_x2
xsubckt_5179_a2_x2 0 3711 1 3915 734 a2_x2
xsubckt_5205_nand2_x0 1 0 3687 3688 3689 nand2_x0
xsubckt_5648_a2_x2 0 3325 1 6012 1897 a2_x2
xsubckt_5803_mx2_x2 0 3203 1 855 1058 1026 mx2_x2
xsubckt_5805_mx2_x2 0 3201 1 856 1186 1090 mx2_x2
xsubckt_5807_mx2_x2 0 3199 1 836 3200 3201 mx2_x2
xsubckt_6292_mx2_x2 0 2728 1 835 2729 2730 mx2_x2
xsubckt_6294_mx2_x2 0 2726 1 856 1881 1529 mx2_x2
xsubckt_6296_mx2_x2 0 2724 1 8225 2725 2726 mx2_x2
xsubckt_6537_a2_x2 0 9686 1 2490 2524 a2_x2
xsubckt_6685_mx2_x2 0 2346 1 8225 2347 2348 mx2_x2
xsubckt_6687_mx2_x2 0 2344 1 856 1773 1741 mx2_x2
xsubckt_6689_mx2_x2 0 2342 1 8214 2343 2346 mx2_x2
xsubckt_8337_sff1_x4 1 2246 0 10020 1343 sff1_x4
xsubckt_8772_sff1_x4 1 2076 0 9650 663 sff1_x4
xsubckt_9237_sff1_x4 1 2123 0 9203 1071 sff1_x4
xsubckt_2292_nand4_x0 1 0 6092 6120 79 78 77 nand4_x0
xsubckt_1778_a2_x2 0 6605 1 6606 8416 a2_x2
xsubckt_1316_xr2_x1 7049 0 1 442 223 xr2_x1
xsubckt_3210_o2_x2 0 5155 1 242 761 o2_x2
xsubckt_4621_mx3_x2 1 0 9958 4149 6291 1633 6205 6210 mx3_x2
xsubckt_5688_a2_x2 0 3286 1 8300 45 a2_x2
xsubckt_5761_mx2_x2 0 3244 1 825 3245 3252 mx2_x2
xsubckt_5763_mx2_x2 0 3242 1 855 1731 1699 mx2_x2
xsubckt_5809_mx2_x2 0 3197 1 825 3198 3205 mx2_x2
xsubckt_6211_o2_x2 0 2806 1 2807 7931 o2_x2
xsubckt_6298_mx2_x2 0 2722 1 855 1049 1017 mx2_x2
xsubckt_7220_nand2_x0 1 0 8600 7976 377 nand2_x0
xsubckt_9145_sff1_x4 1 2119 0 9295 1098 sff1_x4
xsubckt_1732_nxr2_x1 6648 1 0 6649 8044 nxr2_x1
xsubckt_1412_o2_x2 0 6953 1 6958 6962 o2_x2
xsubckt_1278_xr2_x1 7087 0 1 212 245 xr2_x1
xsubckt_1274_xr2_x1 7091 0 1 211 244 xr2_x1
xsubckt_60_inv_x0 1 0 1925 8351 inv_x0
xsubckt_1156_nand2_x0 1 0 7207 7208 1895 nand2_x0
xsubckt_2671_oa22_x2 0 5684 1 5685 5726 5995 oa22_x2
xsubckt_4721_nor3_x0 1 0 9917 4081 4082 8305 nor3_x0
xsubckt_5025_nand2_x0 1 0 3854 3949 8276 nand2_x0
xsubckt_5765_mx2_x2 0 3240 1 855 1859 1827 mx2_x2
xsubckt_5767_mx2_x2 0 3238 1 834 3239 3240 mx2_x2
xsubckt_5769_mx2_x2 0 3236 1 855 995 963 mx2_x2
xsubckt_7891_buf_x1 1 0 1881 8988 buf_x1
xsubckt_7893_buf_x1 1 0 1878 8986 buf_x1
xsubckt_7895_buf_x1 1 0 1876 8984 buf_x1
xsubckt_8245_sff1_x4 1 2203 0 10112 1691 sff1_x4
xsubckt_8680_sff1_x4 1 2086 0 9710 468 sff1_x4
xsubckt_8768_sff1_x4 1 2070 0 9654 622 sff1_x4
xcmpt_resetn_hfns_15 1 0 56 48 buf_x4
xcmpt_resetn_hfns_14 1 0 48 49 buf_x4
xcmpt_resetn_hfns_13 1 0 48 50 buf_x4
xcmpt_resetn_hfns_12 1 0 48 51 buf_x4
xcmpt_resetn_hfns_11 1 0 48 52 buf_x4
xcmpt_resetn_hfns_10 1 0 48 53 buf_x4
xsubckt_1277_o2_x2 0 7088 1 212 245 o2_x2
xsubckt_1257_o2_x2 0 7108 1 207 240 o2_x2
xsubckt_62_inv_x0 1 0 1928 8349 inv_x0
xsubckt_64_inv_x0 1 0 1930 8347 inv_x0
xsubckt_66_inv_x0 1 0 1933 8345 inv_x0
xsubckt_815_nand2_x0 1 0 7530 2002 637 nand2_x0
xsubckt_1066_nand2_x0 1 0 7292 630 1924 nand2_x0
xsubckt_2628_nxr2_x1 5727 1 0 5728 5734 nxr2_x1
xsubckt_2908_nand2_x0 1 0 5452 5994 247 nand2_x0
xsubckt_4107_mx2_x2 0 4273 1 799 971 939 mx2_x2
xsubckt_4109_mx2_x2 0 4271 1 789 4272 4273 mx2_x2
xsubckt_4139_nand3_x0 1 0 4241 4266 4270 8013 nand3_x0
xsubckt_4238_mx3_x2 1 0 10312 4211 6292 1733 6226 6230 mx3_x2
xsubckt_4452_mx2_x2 0 10115 1 4174 6179 1694 mx2_x2
xsubckt_4585_mx3_x2 1 0 9992 4154 6292 1477 6226 6230 mx3_x2
xsubckt_4660_nand3_x0 1 0 4127 4129 4142 1943 nand3_x0
xsubckt_5851_o2_x2 0 3156 1 3157 7931 o2_x2
xsubckt_7126_nand3_x0 1 0 8650 8652 8654 8656 nand3_x0
xsubckt_7897_buf_x1 1 0 1874 8982 buf_x1
xsubckt_7899_buf_x1 1 0 1872 8980 buf_x1
xsubckt_8602_sff1_x4 1 2044 0 9755 1991 sff1_x4
xsubckt_9053_sff1_x4 1 2251 0 9377 1374 sff1_x4
xcmpt_cpuregs_rdreg_1_q_0_hfns_9 1 0 802 793 buf_x4
xcmpt_cpuregs_rdreg_1_q_0_hfns_8 1 0 802 794 buf_x4
xcmpt_cpuregs_rdreg_1_q_0_hfns_7 1 0 802 795 buf_x4
xcmpt_cpuregs_rdreg_1_q_0_hfns_6 1 0 802 796 buf_x4
xcmpt_cpuregs_rdreg_1_q_0_hfns_5 1 0 802 797 buf_x4
xcmpt_cpuregs_rdreg_1_q_0_hfns_4 1 0 802 798 buf_x4
xcmpt_cpuregs_rdreg_1_q_0_hfns_3 1 0 802 799 buf_x4
xcmpt_cpuregs_rdreg_1_q_0_hfns_2 1 0 802 809 buf_x4
xcmpt_cpuregs_rdreg_1_q_0_hfns_1 1 0 802 820 buf_x4
xcmpt_cpuregs_rdreg_1_q_0_hfns_0 1 0 802 821 buf_x4
xcmpt_cpuregs_rdreg_1_q_2_hfns_6 1 0 785 778 buf_x4
xcmpt_cpuregs_rdreg_1_q_2_hfns_5 1 0 778 779 buf_x4
xcmpt_cpuregs_rdreg_1_q_2_hfns_4 1 0 778 780 buf_x4
xcmpt_cpuregs_rdreg_1_q_2_hfns_3 1 0 778 781 buf_x4
xcmpt_cpuregs_rdreg_1_q_2_hfns_2 1 0 778 782 buf_x4
xcmpt_cpuregs_rdreg_1_q_2_hfns_1 1 0 778 783 buf_x4
xcmpt_cpuregs_rdreg_1_q_2_hfns_0 1 0 778 784 buf_x4
xcmpt_cpuregs_rdreg_1_q_4_hfns_3 1 0 773 769 buf_x4
xcmpt_cpuregs_rdreg_1_q_4_hfns_2 1 0 769 770 buf_x4
xcmpt_cpuregs_rdreg_1_q_4_hfns_1 1 0 769 771 buf_x4
xcmpt_cpuregs_rdreg_1_q_4_hfns_0 1 0 769 772 buf_x4
xsubckt_2021_nand2_x0 1 0 6427 6429 6431 nand2_x0
xsubckt_1936_nand2_x0 1 0 6464 7810 210 nand2_x0
xsubckt_1279_nxr2_x1 7086 1 0 212 245 nxr2_x1
xsubckt_68_inv_x0 1 0 1935 8343 inv_x0
xsubckt_998_oa22_x2 0 7357 1 7375 7374 7373 oa22_x2
xsubckt_2728_nand2_x0 1 0 5628 5629 5634 nand2_x0
xsubckt_4051_ao22_x2 0 4328 1 4330 4333 7905 ao22_x2
xsubckt_4063_mx2_x2 0 4316 1 798 1773 1741 mx2_x2
xsubckt_4067_mx2_x2 0 4312 1 798 1837 1805 mx2_x2
xsubckt_4454_mx2_x2 0 10113 1 4173 6161 1692 mx2_x2
xsubckt_4456_mx2_x2 0 10111 1 4174 6143 1690 mx2_x2
xsubckt_4458_mx2_x2 0 10109 1 4174 6125 1688 mx2_x2
xsubckt_4587_mx3_x2 1 0 9990 4154 6292 1505 6206 6209 mx3_x2
xsubckt_5362_nand3_x0 1 0 3541 43 137 8399 nand3_x0
xsubckt_7182_ao22_x2 0 9526 1 8628 8629 8630 ao22_x2
xsubckt_8153_sff1_x4 1 2216 0 10204 1462 sff1_x4
xsubckt_8676_sff1_x4 1 2063 0 9713 504 sff1_x4
xsubckt_9410_sff1_x4 1 2245 0 9033 904 sff1_x4
xsubckt_2285_nand3_x0 1 0 6101 6120 79 78 nand3_x0
xsubckt_1636_nxr2_x1 6737 1 0 6740 243 nxr2_x1
xsubckt_455_nand2_x0 1 0 7876 7877 7878 nand2_x0
xsubckt_3530_mx2_x2 0 4840 1 797 918 886 mx2_x2
xsubckt_3532_mx2_x2 0 4838 1 8034 4839 4840 mx2_x2
xsubckt_3534_mx2_x2 0 4836 1 797 1494 1462 mx2_x2
xsubckt_4767_nxr2_x1 4046 1 0 4048 8329 nxr2_x1
xsubckt_6282_ao22_x2 0 2737 1 574 567 759 ao22_x2
xsubckt_6963_oa22_x2 0 8736 1 8759 8737 8738 oa22_x2
xsubckt_8510_sff1_x4 1 2150 0 9847 75 sff1_x4
xsubckt_9049_sff1_x4 1 2235 0 9381 1348 sff1_x4
xsubckt_9484_sff1_x4 1 2206 0 8959 1852 sff1_x4
xsubckt_2251_ao22_x2 0 6145 1 84 6156 6293 ao22_x2
xsubckt_1666_nand2_x0 1 0 6709 6943 7113 nand2_x0
xsubckt_469_a2_x2 0 7868 1 577 1903 a2_x2
xsubckt_624_a2_x2 0 7715 1 7716 7732 a2_x2
xsubckt_701_nxr2_x1 7642 1 0 7643 7646 nxr2_x1
xsubckt_740_oa22_x2 0 157 1 1903 7622 7602 oa22_x2
xsubckt_3536_mx2_x2 0 4834 1 8035 4835 4836 mx2_x2
xsubckt_3538_mx2_x2 0 4832 1 821 1654 1622 mx2_x2
xsubckt_3881_mx2_x2 0 4495 1 821 1872 1520 mx2_x2
xsubckt_4032_nand3_x0 1 0 4346 4351 4355 771 nand3_x0
xsubckt_6959_oa22_x2 0 8739 1 8750 8740 8741 oa22_x2
xsubckt_7100_mx2_x2 0 9575 1 8666 6088 1523 mx2_x2
xsubckt_7102_mx2_x2 0 9573 1 8666 6070 1521 mx2_x2
xsubckt_7104_mx2_x2 0 9571 1 8666 6054 1519 mx2_x2
xsubckt_7209_nand2_x0 1 0 8609 8686 374 nand2_x0
xsubckt_7628_mx3_x2 1 0 9191 8462 6293 1414 6235 6239 mx3_x2
xsubckt_8061_sff1_x4 1 2142 0 10296 1746 sff1_x4
xsubckt_8149_sff1_x4 1 2203 0 10208 1467 sff1_x4
xsubckt_8506_sff1_x4 1 2159 0 9851 79 sff1_x4
xsubckt_8584_sff1_x4 1 2060 0 9773 2011 sff1_x4
xsubckt_9406_sff1_x4 1 2106 0 9037 930 sff1_x4
xsubckt_343_inv_x0 1 0 576 8009 inv_x0
xsubckt_341_inv_x0 1 0 775 8018 inv_x0
xsubckt_938_a2_x2 0 7413 1 7414 7420 a2_x2
xsubckt_2614_mx2_x2 0 5740 1 6011 222 226 mx2_x2
xsubckt_3883_mx2_x2 0 4493 1 8035 4494 4495 mx2_x2
xsubckt_3885_mx2_x2 0 4491 1 820 1712 1680 mx2_x2
xsubckt_3887_mx2_x2 0 4489 1 789 4490 4491 mx2_x2
xsubckt_5231_a4_x2 0 3663 1 3703 3903 3906 3909 a4_x2
xsubckt_5290_ao22_x2 0 3608 1 3624 3891 8294 ao22_x2
xsubckt_5378_ao22_x2 0 3526 1 3876 3879 729 ao22_x2
xsubckt_5536_oa22_x2 0 3404 1 3407 2016 8305 oa22_x2
xsubckt_7106_mx2_x2 0 9569 1 8666 6035 1517 mx2_x2
xsubckt_7108_mx2_x2 0 9567 1 8666 6018 1514 mx2_x2
xsubckt_7451_mx2_x2 0 9358 1 8485 6283 899 mx2_x2
xsubckt_7453_mx2_x2 0 9356 1 8485 6273 887 mx2_x2
xsubckt_7840_mx2_x2 0 8960 1 8429 6170 1853 mx2_x2
xsubckt_7842_mx2_x2 0 8958 1 8429 6152 1851 mx2_x2
xsubckt_7844_mx2_x2 0 8956 1 8429 6135 1849 mx2_x2
xsubckt_8057_sff1_x4 1 2206 0 10300 1750 sff1_x4
xsubckt_8941_sff1_x4 1 2098 0 9484 1591 sff1_x4
xsubckt_9392_sff1_x4 1 2222 0 9051 952 sff1_x4
xsubckt_2270_a4_x2 0 6120 1 6147 83 82 80 a4_x2
xsubckt_2225_mx2_x2 0 10434 1 6300 6178 1822 mx2_x2
xsubckt_1825_nand3_x0 1 0 6561 6562 6563 6564 nand3_x0
xsubckt_347_inv_x0 1 0 552 8005 inv_x0
xsubckt_345_inv_x0 1 0 556 8007 inv_x0
xsubckt_2840_oa22_x2 0 5518 1 5519 5558 5958 oa22_x2
xsubckt_3413_nand2_x0 1 0 4955 4956 8023 nand2_x0
xsubckt_3504_ao22_x2 0 4865 1 4914 4913 4866 ao22_x2
xsubckt_3889_mx2_x2 0 4487 1 809 912 880 mx2_x2
xsubckt_4473_nand2_x0 1 0 4169 4171 4183 nand2_x0
xsubckt_5013_oa22_x2 0 9842 1 7885 3864 3866 oa22_x2
xsubckt_5483_nxr2_x1 3440 1 0 3444 8103 nxr2_x1
xsubckt_7455_mx2_x2 0 9354 1 8485 6258 873 mx2_x2
xsubckt_7457_mx2_x2 0 9352 1 8485 6245 871 mx2_x2
xsubckt_7846_mx2_x2 0 8954 1 8429 6115 1846 mx2_x2
xsubckt_7848_mx2_x2 0 8952 1 8429 6097 1844 mx2_x2
xsubckt_8414_sff1_x4 1 2116 0 9943 1617 sff1_x4
xsubckt_8492_sff1_x4 1 2169 0 9865 64 sff1_x4
xsubckt_8937_sff1_x4 1 2083 0 9488 756 sff1_x4
xsubckt_9314_sff1_x4 1 2235 0 9126 997 sff1_x4
xsubckt_9388_sff1_x4 1 2212 0 9055 956 sff1_x4
xcmpt_abc_30082_new_n10909_hfns_2 1 0 8461 8458 buf_x4
xcmpt_abc_30082_new_n10909_hfns_1 1 0 8458 8459 buf_x4
xcmpt_abc_30082_new_n10909_hfns_0 1 0 8458 8460 buf_x4
xsubckt_2398_nor2_x0 1 0 5955 713 732 nor2_x0
xsubckt_2185_mx2_x2 0 6248 1 544 96 2260 mx2_x2
xsubckt_2183_mx2_x2 0 10442 1 6299 6252 1800 mx2_x2
xsubckt_1655_a4_x2 0 6720 1 6760 8059 8060 8061 a4_x2
xsubckt_1505_oa22_x2 0 6860 1 6872 6868 6869 oa22_x2
xsubckt_515_nor4_x0 1 0 7823 7937 7943 8274 8305 nor4_x0
xsubckt_2572_mx2_x2 0 5782 1 809 1769 1737 mx2_x2
xsubckt_2574_mx2_x2 0 5780 1 809 1833 1801 mx2_x2
xsubckt_2576_mx2_x2 0 5778 1 791 5779 5780 mx2_x2
xsubckt_5009_oa22_x2 0 9843 1 7884 3867 3869 oa22_x2
xsubckt_6531_mx2_x2 0 2495 1 8215 2496 2499 mx2_x2
xsubckt_6533_mx2_x2 0 2493 1 8206 2494 2509 mx2_x2
xsubckt_7068_mx2_x2 0 9601 1 6441 8673 564 mx2_x2
xsubckt_7109_a2_x2 0 8663 1 8683 8839 a2_x2
xsubckt_8488_sff1_x4 1 2169 0 9869 70 sff1_x4
xsubckt_9222_sff1_x4 1 2242 0 9218 1087 sff1_x4
xsubckt_2351_nand2_x0 1 0 6015 7893 7910 nand2_x0
xsubckt_2187_mx2_x2 0 6246 1 6297 6247 6248 mx2_x2
xsubckt_2098_nand2_x0 1 0 6349 6350 7818 nand2_x0
xsubckt_497_o2_x2 0 7839 1 569 574 o2_x2
xsubckt_408_ao22_x2 0 7937 1 7938 7940 7941 ao22_x2
xsubckt_875_nand2_x0 1 0 7473 7991 2034 nand2_x0
xsubckt_1147_a2_x2 0 7215 1 7216 7222 a2_x2
xsubckt_2578_mx2_x2 0 5776 1 799 969 937 mx2_x2
xsubckt_3233_nand2_x0 1 0 5132 5133 8022 nand2_x0
xsubckt_3319_nand3_x0 1 0 5047 5048 5223 6391 nand3_x0
xsubckt_4718_nand4_x0 1 0 4083 4085 4091 4143 1967 nand4_x0
xsubckt_5037_a2_x2 0 3843 1 3945 709 a2_x2
xsubckt_6141_a2_x2 0 9697 1 2875 2909 a2_x2
xsubckt_6144_mx2_x2 0 2872 1 861 1853 1821 mx2_x2
xsubckt_6146_mx2_x2 0 2870 1 861 1725 1693 mx2_x2
xsubckt_6148_mx2_x2 0 2868 1 836 2869 2870 mx2_x2
xsubckt_6491_mx2_x2 0 2534 1 8223 2535 2536 mx2_x2
xsubckt_6539_mx2_x2 0 2488 1 861 913 881 mx2_x2
xsubckt_8322_sff1_x4 1 2111 0 10035 1645 sff1_x4
xsubckt_8845_sff1_x4 1 2232 0 9580 1529 sff1_x4
xsubckt_9296_sff1_x4 1 2209 0 9144 1044 sff1_x4
xsubckt_1908_nand2_x0 1 0 6487 191 328 nand2_x0
xsubckt_1831_a2_x2 0 6555 1 6556 229 a2_x2
xsubckt_607_nand2_x0 1 0 7732 7733 1902 nand2_x0
xsubckt_785_nand2_x0 1 0 7559 7560 7563 nand2_x0
xsubckt_3053_nand2_x0 1 0 5309 5310 8022 nand2_x0
xsubckt_3139_nand3_x0 1 0 5224 5225 5399 6392 nand3_x0
xsubckt_4812_a2_x2 0 9895 1 4012 4014 a2_x2
xsubckt_4901_oa22_x2 0 9870 1 7885 3948 3950 oa22_x2
xsubckt_6493_mx2_x2 0 2532 1 840 1427 1395 mx2_x2
xsubckt_6495_mx2_x2 0 2530 1 8212 2531 2534 mx2_x2
xsubckt_6497_mx2_x2 0 2528 1 8206 2529 2544 mx2_x2
xsubckt_6837_nand2_x0 1 0 8833 8245 702 nand2_x0
xsubckt_6876_a3_x2 1 8800 0 8801 8837 8845 a3_x2
xsubckt_6974_ao22_x2 0 8728 1 8749 8729 8730 ao22_x2
xsubckt_7945_sff1_x4 1 2086 0 10412 226 sff1_x4
xsubckt_8396_sff1_x4 1 2229 0 9961 1606 sff1_x4
xsubckt_9130_sff1_x4 1 2203 0 9310 1115 sff1_x4
xsubckt_9218_sff1_x4 1 2189 0 9222 1061 sff1_x4
xsubckt_1818_nand2_x0 1 0 6567 6943 7156 nand2_x0
xsubckt_1409_oa22_x2 0 6956 1 6964 7103 656 oa22_x2
xsubckt_587_xr2_x1 7751 0 1 756 81 xr2_x1
xsubckt_1021_nand2_x0 1 0 7335 7336 7339 nand2_x0
xsubckt_2663_nor2_x0 1 0 5692 5693 5725 nor2_x0
xsubckt_2788_nand2_x0 1 0 5569 5993 8118 nand2_x0
xsubckt_3195_oa22_x2 0 5169 1 5170 5171 8017 oa22_x2
xsubckt_3513_nxr2_x1 4857 1 0 236 755 nxr2_x1
xsubckt_3983_a2_x2 0 4394 1 4395 4400 a2_x2
xsubckt_4697_a2_x2 0 4099 1 4105 8315 a2_x2
xsubckt_4892_a2_x2 0 9873 1 3954 53 a2_x2
xsubckt_5200_o2_x2 0 9827 1 3692 3704 o2_x2
xsubckt_5226_mx2_x2 0 3667 1 8279 3668 3907 mx2_x2
xsubckt_6248_oa22_x2 0 2770 1 3191 2773 2771 oa22_x2
xsubckt_6789_a2_x2 0 9679 1 8866 8900 a2_x2
xsubckt_6964_a2_x2 0 9640 1 8736 53 a2_x2
xsubckt_7060_oa22_x2 0 8678 1 8679 8763 8784 oa22_x2
xsubckt_8230_sff1_x4 1 2126 0 10127 1698 sff1_x4
xsubckt_8318_sff1_x4 1 2116 0 10039 1649 sff1_x4
xsubckt_8753_sff1_x4 1 2070 0 9669 661 sff1_x4
xsubckt_1737_nor3_x0 1 0 6643 6644 6656 6659 nor3_x0
xsubckt_1576_o3_x2 0 6793 1 6794 6795 6939 o3_x2
xsubckt_427_nand2_x0 1 0 7914 7921 7996 nand2_x0
xsubckt_1115_o2_x2 0 7246 1 7247 7249 o2_x2
xsubckt_2698_nand2_x0 1 0 5658 5659 8021 nand2_x0
xsubckt_3552_oa22_x2 0 4818 1 4819 4820 776 oa22_x2
xsubckt_3833_nand2_x0 1 0 4542 4543 8021 nand2_x0
xsubckt_4300_mx2_x2 0 10254 1 4199 6273 1239 mx2_x2
xsubckt_4302_mx2_x2 0 10252 1 4199 6259 1225 mx2_x2
xsubckt_4304_mx2_x2 0 10250 1 4199 6244 1223 mx2_x2
xsubckt_5964_mx2_x2 0 3047 1 838 1828 1796 mx2_x2
xsubckt_5966_mx2_x2 0 3045 1 838 1700 1668 mx2_x2
xsubckt_5968_mx2_x2 0 3043 1 833 3044 3045 mx2_x2
xsubckt_6882_ao22_x2 0 8796 1 707 8278 646 ao22_x2
xsubckt_8749_sff1_x4 1 2150 0 2295 2263 sff1_x4
xsubckt_9126_sff1_x4 1 2247 0 9314 1119 sff1_x4
xsubckt_2240_nand3_x0 1 0 6158 6159 540 8409 nand3_x0
xsubckt_1548_nand2_x0 1 0 6819 7073 7971 nand2_x0
xsubckt_1195_o2_x2 0 7170 1 195 227 o2_x2
xsubckt_521_a4_x2 0 7817 1 7818 7936 7942 50 a4_x2
xsubckt_3025_oa22_x2 0 5336 1 5337 5384 5995 oa22_x2
xsubckt_4092_nand3_x0 1 0 4287 4288 4291 5950 nand3_x0
xsubckt_4260_mx2_x2 0 10290 1 4209 6026 1739 mx2_x2
xsubckt_5217_nxr2_x1 3676 1 0 3690 3907 nxr2_x1
xsubckt_6463_o2_x2 0 2561 1 2562 7931 o2_x2
xsubckt_6878_ao22_x2 0 8799 1 707 8278 648 ao22_x2
xsubckt_7269_nand2_x0 1 0 8564 8565 8577 nand2_x0
xsubckt_8226_sff1_x4 1 2119 0 10131 1261 sff1_x4
xsubckt_8661_sff1_x4 1 2182 0 9728 528 sff1_x4
xcmpt_abc_30082_new_n3714_hfns_2 1 0 7919 7916 buf_x4
xcmpt_abc_30082_new_n3714_hfns_1 1 0 7916 7917 buf_x4
xcmpt_abc_30082_new_n3714_hfns_0 1 0 7916 7918 buf_x4
xsubckt_1711_nand2_x0 1 0 6667 6942 7122 nand2_x0
xsubckt_456_oa22_x2 0 7875 1 7910 7876 7886 oa22_x2
xsubckt_979_oa22_x2 0 7375 1 7393 7391 7392 oa22_x2
xsubckt_3653_nand2_x0 1 0 4719 4720 8020 nand2_x0
xsubckt_3739_nand3_x0 1 0 4634 4635 4810 6392 nand3_x0
xsubckt_4264_mx2_x2 0 10288 1 4203 6283 1187 mx2_x2
xsubckt_4266_mx2_x2 0 10286 1 4203 6273 1175 mx2_x2
xsubckt_5313_nand4_x0 1 0 3587 3624 3885 3888 3891 nand4_x0
xsubckt_6929_nor3_x0 1 0 8762 8764 8784 8822 nor3_x0
xsubckt_7179_nand2_x0 1 0 8630 8631 8637 nand2_x0
xsubckt_8134_sff1_x4 1 2100 0 10223 1474 sff1_x4
xsubckt_8657_sff1_x4 1 2185 0 9732 532 sff1_x4
xsubckt_9034_sff1_x4 1 2079 0 9396 380 sff1_x4
xsubckt_1621_nand2_x0 1 0 6751 6948 7091 nand2_x0
xsubckt_3340_mx2_x2 0 5027 1 789 5028 5029 mx2_x2
xsubckt_3456_oa22_x2 0 4913 1 4916 4921 7907 oa22_x2
xsubckt_3473_nand2_x0 1 0 4896 4897 8025 nand2_x0
xsubckt_3559_nand3_x0 1 0 4811 4812 4987 6392 nand3_x0
xsubckt_4268_mx2_x2 0 10284 1 4204 6259 1161 mx2_x2
xsubckt_6786_ao22_x2 0 8868 1 574 569 743 ao22_x2
xsubckt_7342_nand2_x0 1 0 8506 8686 385 nand2_x0
xsubckt_9465_sff1_x4 1 2110 0 8978 1870 sff1_x4
xsubckt_2409_nand3_x0 1 0 5941 5942 5943 7905 nand3_x0
xsubckt_3205_nand2_x0 1 0 10401 5160 5217 nand2_x0
xsubckt_3293_nand2_x0 1 0 5073 5074 8025 nand2_x0
xsubckt_3342_mx2_x2 0 5025 1 808 1882 1530 mx2_x2
xsubckt_3344_mx2_x2 0 5023 1 8032 5024 5025 mx2_x2
xsubckt_3346_mx2_x2 0 5021 1 808 1722 1690 mx2_x2
xsubckt_5886_ao22_x2 0 3122 1 573 568 740 ao22_x2
xsubckt_7248_nand3_x0 1 0 8581 8582 8604 8609 nand3_x0
xsubckt_8042_sff1_x4 1 2245 0 10315 1736 sff1_x4
xsubckt_8565_sff1_x4 1 2053 0 9792 2032 sff1_x4
xsubckt_2422_mx2_x2 0 5929 1 8024 5930 5933 mx2_x2
xsubckt_2420_mx2_x2 0 5931 1 806 1794 1762 mx2_x2
xsubckt_1855_ao22_x2 0 6533 1 6544 196 8415 ao22_x2
xsubckt_151_inv_x0 1 0 369 8248 inv_x0
xsubckt_809_oa22_x2 0 7536 1 7537 7538 7617 oa22_x2
xsubckt_847_nand2_x0 1 0 7500 7663 328 nand2_x0
xsubckt_2497_nand3_x0 1 0 5855 5856 5857 8017 nand3_x0
xsubckt_2811_mx2_x2 0 5547 1 791 5548 5549 mx2_x2
xsubckt_2813_mx2_x2 0 5545 1 807 901 869 mx2_x2
xsubckt_3348_mx2_x2 0 5019 1 791 5020 5021 mx2_x2
xsubckt_3379_nand3_x0 1 0 4988 4989 5164 6392 nand3_x0
xsubckt_4085_nand2_x0 1 0 4294 4295 8023 nand2_x0
xsubckt_5072_oa22_x2 0 3810 1 3811 3821 7881 oa22_x2
xsubckt_6852_oa22_x2 0 8817 1 8826 8819 8820 oa22_x2
xsubckt_6973_nand4_x0 1 0 8729 8765 8767 8806 8269 nand4_x0
xsubckt_7390_mx3_x2 1 0 9447 8497 6289 1542 6235 6239 mx3_x2
xsubckt_7392_mx3_x2 1 0 9445 8497 6289 1540 6215 6219 mx3_x2
xsubckt_7394_mx3_x2 1 0 9443 8497 6289 1568 6196 6200 mx3_x2
xsubckt_7650_mx2_x2 0 9169 1 8459 6035 1421 mx2_x2
xsubckt_7652_mx2_x2 0 9167 1 8459 6017 1418 mx2_x2
xsubckt_8922_sff1_x4 1 2079 0 9503 759 sff1_x4
xsubckt_9373_sff1_x4 1 2103 0 9070 963 sff1_x4
xsubckt_2428_mx2_x2 0 5923 1 8033 5924 5925 mx2_x2
xsubckt_2426_mx2_x2 0 5925 1 811 1058 1026 mx2_x2
xsubckt_2424_mx2_x2 0 5927 1 811 1890 1538 mx2_x2
xsubckt_2035_mx2_x2 0 6413 1 830 6414 6417 mx2_x2
xsubckt_2033_mx2_x2 0 6415 1 841 1655 1623 mx2_x2
xsubckt_2031_mx2_x2 0 6417 1 836 6418 6419 mx2_x2
xsubckt_1968_nand2_x0 1 0 6446 540 559 nand2_x0
xsubckt_1599_nxr2_x1 6772 1 0 6773 8058 nxr2_x1
xsubckt_1318_a4_x2 0 7047 1 7048 7052 7057 7061 a4_x2
xsubckt_153_inv_x0 1 0 706 8246 inv_x0
xsubckt_155_inv_x0 1 0 426 8241 inv_x0
xsubckt_157_inv_x0 1 0 431 8239 inv_x0
xsubckt_667_nand2_x0 1 0 7674 634 1932 nand2_x0
xsubckt_717_oa22_x2 0 158 1 1903 7642 7627 oa22_x2
xsubckt_920_nand2_x0 1 0 7430 7431 7439 nand2_x0
xsubckt_2771_mx2_x2 0 5586 1 810 1574 1542 mx2_x2
xsubckt_2815_mx2_x2 0 5543 1 8032 5544 5545 mx2_x2
xsubckt_2817_mx2_x2 0 5541 1 813 1477 1445 mx2_x2
xsubckt_2819_mx2_x2 0 5539 1 8032 5540 5541 mx2_x2
xsubckt_3199_nand3_x0 1 0 5165 5166 5340 6392 nand3_x0
xsubckt_3699_mx2_x2 0 4674 1 813 1043 1011 mx2_x2
xsubckt_5002_a3_x2 1 3872 0 53 72 8397 a3_x2
xsubckt_5029_nxr2_x1 3850 1 0 3949 710 nxr2_x1
xsubckt_5517_oa22_x2 0 3417 1 3421 2023 8305 oa22_x2
xsubckt_7265_mx2_x2 0 9503 1 8832 8568 759 mx2_x2
xsubckt_7656_mx2_x2 0 9166 1 8454 6283 1059 mx2_x2
xsubckt_7658_mx2_x2 0 9164 1 8454 6273 1047 mx2_x2
xsubckt_7689_nand2_x0 1 0 8450 8457 4194 nand2_x0
xsubckt_8038_sff1_x4 1 2126 0 10319 1762 sff1_x4
xsubckt_8473_sff1_x4 1 2044 0 9884 1930 sff1_x4
xsubckt_8996_sff1_x4 1 2116 0 9429 1553 sff1_x4
xsubckt_2384_mx2_x2 0 5972 1 812 1187 1091 mx2_x2
xsubckt_2382_mx2_x2 0 5974 1 789 5975 5976 mx2_x2
xsubckt_2380_mx2_x2 0 5976 1 811 995 963 mx2_x2
xsubckt_2039_mx2_x2 0 6409 1 8219 6410 6411 mx2_x2
xsubckt_2037_mx2_x2 0 6411 1 844 1783 1751 mx2_x2
xsubckt_1763_ao22_x2 0 6619 1 6633 202 8415 ao22_x2
xsubckt_375_o2_x2 0 7973 1 641 642 o2_x2
xsubckt_159_inv_x0 1 0 387 8237 inv_x0
xsubckt_804_o2_x2 0 7541 1 7542 7544 o2_x2
xsubckt_1081_nand2_x0 1 0 7278 7279 1893 nand2_x0
xsubckt_2775_mx2_x2 0 5582 1 811 1414 1382 mx2_x2
xsubckt_3795_oa22_x2 0 4579 1 4580 4581 8017 oa22_x2
xsubckt_3805_nand2_x0 1 0 10391 4570 4627 nand2_x0
xsubckt_5126_nand3_x0 1 0 3760 3761 3762 652 nand3_x0
xsubckt_5511_a3_x2 1 9786 0 3422 3423 44 a3_x2
xsubckt_5531_a3_x2 1 9780 0 3408 3409 44 a3_x2
xsubckt_6341_mx2_x2 0 2680 1 843 1240 1208 mx2_x2
xsubckt_6730_mx2_x2 0 8923 1 843 1035 1003 mx2_x2
xsubckt_6732_mx2_x2 0 8921 1 8212 8922 8925 mx2_x2
xsubckt_7790_a4_x2 0 8436 1 6303 6305 6312 7886 a4_x2
xsubckt_8830_sff1_x4 1 2097 0 9595 1516 sff1_x4
xsubckt_8918_sff1_x4 1 2089 0 9507 754 sff1_x4
xsubckt_9281_sff1_x4 1 2198 0 9159 1030 sff1_x4
xsubckt_9369_sff1_x4 1 2116 0 9074 974 sff1_x4
xcmpt_abc_30082_new_n10671_hfns_2 1 0 8496 8493 buf_x4
xcmpt_abc_30082_new_n10671_hfns_1 1 0 8493 8494 buf_x4
xcmpt_abc_30082_new_n10671_hfns_0 1 0 8493 8495 buf_x4
xsubckt_2388_mx2_x2 0 5968 1 812 1731 1699 mx2_x2
xsubckt_2386_mx2_x2 0 5970 1 783 5971 5974 mx2_x2
xsubckt_1984_mx3_x2 1 0 492 8002 6450 240 115 147 mx3_x2
xsubckt_1982_mx3_x2 1 0 494 8002 6450 242 117 149 mx3_x2
xsubckt_1980_mx3_x2 1 0 496 8002 6449 244 119 151 mx3_x2
xsubckt_1788_nand2_x0 1 0 6595 7151 7972 nand2_x0
xsubckt_629_o2_x2 0 7711 1 7712 7714 o2_x2
xsubckt_844_o2_x2 0 7503 1 7504 7506 o2_x2
xsubckt_2570_a3_x2 1 5784 0 567 8290 67 a3_x2
xsubckt_3979_nand3_x0 1 0 4398 4399 4574 6392 nand3_x0
xsubckt_4662_a3_x2 1 9931 0 4126 4127 43 a3_x2
xsubckt_4682_a3_x2 1 4111 0 4112 4116 1975 a3_x2
xsubckt_4868_a4_x2 0 3971 1 3978 1928 1927 1926 a4_x2
xsubckt_6343_mx2_x2 0 2678 1 8220 2679 2680 mx2_x2
xsubckt_6345_mx2_x2 0 2676 1 854 1656 1624 mx2_x2
xsubckt_6347_mx2_x2 0 2674 1 8220 2675 2676 mx2_x2
xsubckt_6690_mx2_x2 0 2341 1 865 1869 1517 mx2_x2
xsubckt_6734_mx2_x2 0 8919 1 854 1355 1323 mx2_x2
xsubckt_6736_mx2_x2 0 8917 1 8220 8918 8919 mx2_x2
xsubckt_6738_mx2_x2 0 8915 1 854 1131 1099 mx2_x2
xsubckt_7067_a2_x2 0 8673 1 8674 8683 a2_x2
xsubckt_7262_a2_x2 0 8570 1 714 652 a2_x2
xsubckt_7930_sff1_x4 1 2110 0 10422 1809 sff1_x4
xsubckt_8381_sff1_x4 1 2217 0 9976 1490 sff1_x4
xsubckt_8469_sff1_x4 1 2047 0 9888 1935 sff1_x4
xsubckt_8826_sff1_x4 1 2053 0 9599 577 sff1_x4
xsubckt_9203_sff1_x4 1 2137 0 9237 1201 sff1_x4
xsubckt_1988_mx3_x2 1 0 487 8002 6449 235 110 142 mx3_x2
xsubckt_1986_mx3_x2 1 0 490 8002 6449 238 113 145 mx3_x2
xsubckt_1951_nand2_x0 1 0 6459 7809 200 nand2_x0
xsubckt_1722_nor3_x0 1 0 6657 6658 6663 6664 nor3_x0
xsubckt_1359_a2_x2 0 7006 1 7007 7008 a2_x2
xsubckt_1321_xr2_x1 7044 0 1 456 237 xr2_x1
xsubckt_578_mx2_x2 0 7760 1 216 429 412 mx2_x2
xsubckt_736_nand3_x0 1 0 7605 7606 7607 7608 nand3_x0
xsubckt_824_xr2_x1 7522 0 1 763 88 xr2_x1
xsubckt_4724_ao22_x2 0 9916 1 4079 4080 54 ao22_x2
xsubckt_4750_a2_x2 0 4059 1 1960 1959 a2_x2
xsubckt_5464_a2_x2 0 9801 1 3454 54 a2_x2
xsubckt_5484_a2_x2 0 9795 1 3440 54 a2_x2
xsubckt_5730_nand2_x0 1 0 3272 3273 3275 nand2_x0
xsubckt_5810_mx2_x2 0 3196 1 823 3197 3212 mx2_x2
xsubckt_6349_mx2_x2 0 2672 1 865 1432 1400 mx2_x2
xsubckt_6393_a2_x2 0 9690 1 2630 2664 a2_x2
xsubckt_6692_mx2_x2 0 2339 1 8221 2340 2341 mx2_x2
xsubckt_6694_mx2_x2 0 2337 1 865 1037 1005 mx2_x2
xsubckt_6696_mx2_x2 0 2335 1 8210 2336 2339 mx2_x2
xsubckt_7282_a2_x2 0 8554 1 734 653 a2_x2
xsubckt_7926_sff1_x4 1 2218 0 10426 1813 sff1_x4
xsubckt_8303_sff1_x4 1 2229 0 10054 1665 sff1_x4
xsubckt_9277_sff1_x4 1 2103 0 9163 1036 sff1_x4
xsubckt_1828_a2_x2 0 6558 1 6559 8415 a2_x2
xsubckt_1771_nand2_x0 1 0 6611 6942 7141 nand2_x0
xsubckt_1380_oa22_x2 0 6985 1 6986 6987 7153 oa22_x2
xsubckt_1325_xr2_x1 7040 0 1 445 226 xr2_x1
xsubckt_470_nand2_x0 1 0 7867 7868 7912 nand2_x0
xsubckt_784_xr2_x1 7560 0 1 765 90 xr2_x1
xsubckt_2563_nand2_x0 1 0 5790 6012 8137 nand2_x0
xsubckt_2972_a2_x2 0 5389 1 246 765 a2_x2
xsubckt_3445_nand2_x0 1 0 10397 4924 4981 nand2_x0
xsubckt_3799_nand3_x0 1 0 4575 4576 4751 6391 nand3_x0
xsubckt_5738_a2_x2 0 3264 1 3265 3267 a2_x2
xsubckt_5770_mx2_x2 0 3235 1 866 1059 1027 mx2_x2
xsubckt_5778_a2_x2 0 3227 1 3228 6427 a2_x2
xsubckt_6698_mx2_x2 0 2333 1 866 1357 1325 mx2_x2
xsubckt_8211_sff1_x4 1 2238 0 10146 1277 sff1_x4
xsubckt_8377_sff1_x4 1 2215 0 9980 1494 sff1_x4
xsubckt_8734_sff1_x4 1 2182 0 2312 2280 sff1_x4
xsubckt_9111_sff1_x4 1 2112 0 9329 877 sff1_x4
xcmpt_pcpi_rs1_bit1_hfns_2 1 0 248 215 buf_x4
xcmpt_pcpi_rs1_bit1_hfns_1 1 0 215 216 buf_x4
xcmpt_pcpi_rs1_bit1_hfns_0 1 0 215 217 buf_x4
xsubckt_1681_nand2_x0 1 0 6695 7108 7971 nand2_x0
xsubckt_466_nand3_x0 1 0 7870 7912 47 8402 nand3_x0
xsubckt_3145_o2_x2 0 5218 1 5219 5994 o2_x2
xsubckt_4241_mx3_x2 1 0 10309 4211 6294 1760 6196 6200 mx3_x2
xsubckt_4501_mx2_x2 0 10069 1 4168 6054 1295 mx2_x2
xsubckt_4503_mx2_x2 0 10067 1 4168 6035 1293 mx2_x2
xsubckt_4889_a2_x2 0 9874 1 3956 3959 a2_x2
xsubckt_5460_nand2_x0 1 0 3456 3459 1980 nand2_x0
xsubckt_5772_mx2_x2 0 3233 1 866 1187 1091 mx2_x2
xsubckt_5774_mx2_x2 0 3231 1 835 3232 3233 mx2_x2
xsubckt_5776_mx2_x2 0 3229 1 828 3230 3237 mx2_x2
xsubckt_8285_sff1_x4 1 2145 0 10072 1298 sff1_x4
xsubckt_9107_sff1_x4 1 2100 0 9333 881 sff1_x4
xsubckt_9185_sff1_x4 1 2194 0 9255 1190 sff1_x4
xsubckt_1591_nand2_x0 1 0 6779 6948 7081 nand2_x0
xsubckt_71_inv_x0 1 0 1939 8340 inv_x0
xsubckt_73_inv_x0 1 0 1944 8338 inv_x0
xsubckt_3084_oa22_x2 0 5278 1 5279 5326 5993 oa22_x2
xsubckt_4057_nand2_x0 1 0 4322 4323 781 nand2_x0
xsubckt_4105_ao22_x2 0 4275 1 4277 4279 7905 ao22_x2
xsubckt_4112_mx2_x2 0 4268 1 814 1163 1067 mx2_x2
xsubckt_4116_mx2_x2 0 4264 1 814 1771 1739 mx2_x2
xsubckt_4505_mx2_x2 0 10065 1 4168 6017 1290 mx2_x2
xsubckt_4509_mx2_x2 0 10064 1 4162 6283 1667 mx2_x2
xsubckt_4983_mx3_x2 1 0 3886 6448 546 8387 8163 8164 mx3_x2
xsubckt_5370_nand2_x0 1 0 9815 3534 3541 nand2_x0
xsubckt_6572_oa22_x2 0 2455 1 3190 2458 2456 oa22_x2
xsubckt_8207_sff1_x4 1 2198 0 10150 1281 sff1_x4
xsubckt_8642_sff1_x4 1 2076 0 165 102 sff1_x4
xsubckt_2011_nand4_x0 1 0 6436 7912 55 504 1903 nand4_x0
xsubckt_1840_nand3_x0 1 0 6547 6548 6549 6550 nand3_x0
xsubckt_1768_nxr2_x1 6614 1 0 6615 6620 nxr2_x1
xsubckt_75_inv_x0 1 0 1946 8336 inv_x0
xsubckt_77_inv_x0 1 0 1948 8334 inv_x0
xsubckt_79_inv_x0 1 0 1950 8332 inv_x0
xsubckt_639_nand2_x0 1 0 7701 7702 7704 nand2_x0
xsubckt_3085_nand2_x0 1 0 10403 5278 5335 nand2_x0
xsubckt_4070_mx2_x2 0 4309 1 815 1485 1453 mx2_x2
xsubckt_4072_mx2_x2 0 4307 1 8036 4308 4309 mx2_x2
xsubckt_4074_mx2_x2 0 4305 1 816 1645 1613 mx2_x2
xsubckt_4461_mx2_x2 0 10106 1 4174 6098 1684 mx2_x2
xsubckt_4463_mx2_x2 0 10104 1 4173 6081 1682 mx2_x2
xsubckt_4465_mx2_x2 0 10102 1 4174 6062 1680 mx2_x2
xsubckt_4987_mx3_x2 1 0 3883 6450 545 8388 8161 8162 mx3_x2
xsubckt_5190_nand2_x0 1 0 3701 3702 8295 nand2_x0
xsubckt_6859_ao22_x2 0 8812 1 707 8278 657 ao22_x2
xsubckt_8193_sff1_x4 1 2108 0 10164 1710 sff1_x4
xsubckt_9015_sff1_x4 1 2063 0 9415 370 sff1_x4
xsubckt_9093_sff1_x4 1 2189 0 9347 896 sff1_x4
xsubckt_9450_sff1_x4 1 2245 0 8993 1886 sff1_x4
xsubckt_1602_nxr2_x1 6769 1 0 6772 245 nxr2_x1
xsubckt_549_nand2_x0 1 0 7787 630 1951 nand2_x0
xsubckt_1143_nand2_x0 1 0 7219 1983 638 nand2_x0
xsubckt_3437_oa22_x2 0 4931 1 4932 4971 5958 oa22_x2
xsubckt_4076_mx2_x2 0 4303 1 8029 4304 4305 mx2_x2
xsubckt_4078_mx2_x2 0 4301 1 793 1229 1197 mx2_x2
xsubckt_4130_nand2_x0 1 0 4250 4251 8024 nand2_x0
xsubckt_4467_mx2_x2 0 10100 1 4174 6043 1678 mx2_x2
xsubckt_4469_mx2_x2 0 10098 1 4174 6026 1675 mx2_x2
xsubckt_8115_sff1_x4 1 2238 0 10242 1245 sff1_x4
xsubckt_8550_sff1_x4 1 2060 0 9807 2029 sff1_x4
xsubckt_8638_sff1_x4 1 2150 0 169 106 sff1_x4
xsubckt_9089_sff1_x4 1 2172 0 9351 870 sff1_x4
xcmpt_abc_30082_new_n7445_hfns_2 1 0 4225 4222 buf_x4
xcmpt_abc_30082_new_n7445_hfns_1 1 0 4222 4223 buf_x4
xcmpt_abc_30082_new_n7445_hfns_0 1 0 4222 4224 buf_x4
xsubckt_1656_nand4_x0 1 0 6719 6760 8059 8060 8061 nand4_x0
xsubckt_3543_mx2_x2 0 4827 1 819 1142 1110 mx2_x2
xsubckt_3938_mx2_x2 0 4439 1 819 975 943 mx2_x2
xsubckt_5092_nxr2_x1 3792 1 0 3793 3796 nxr2_x1
xsubckt_5096_nand3_x0 1 0 3788 3820 3933 3936 nand3_x0
xsubckt_7500_mx2_x2 0 9311 1 8480 6161 1116 mx2_x2
xsubckt_7502_mx2_x2 0 9309 1 8480 6143 1114 mx2_x2
xsubckt_7631_mx3_x2 1 0 9188 8462 6290 1441 6206 6209 mx3_x2
xsubckt_8189_sff1_x4 1 2142 0 10168 1714 sff1_x4
xsubckt_9446_sff1_x4 1 2192 0 8997 1860 sff1_x4
xsubckt_1923_nand2_x0 1 0 6475 212 327 nand2_x0
xsubckt_1584_nxr2_x1 6786 1 0 6787 8057 nxr2_x1
xsubckt_702_oa22_x2 0 7641 1 7806 7939 8120 oa22_x2
xsubckt_3158_mx2_x2 0 5206 1 819 989 957 mx2_x2
xsubckt_3547_mx2_x2 0 4823 1 819 1302 1270 mx2_x2
xsubckt_3890_mx2_x2 0 4486 1 819 1840 1808 mx2_x2
xsubckt_3894_mx2_x2 0 4482 1 819 1424 1392 mx2_x2
xsubckt_7504_mx2_x2 0 9307 1 8479 6125 1112 mx2_x2
xsubckt_7506_mx2_x2 0 9305 1 8479 6108 1109 mx2_x2
xsubckt_7508_mx2_x2 0 9303 1 8479 6089 1107 mx2_x2
xsubckt_7851_mx2_x2 0 8949 1 8429 6071 1841 mx2_x2
xsubckt_8023_sff1_x4 1 2246 0 10334 1145 sff1_x4
xsubckt_8546_sff1_x4 1 2150 0 9811 132 sff1_x4
xsubckt_8903_sff1_x4 1 2129 0 9522 554 sff1_x4
xsubckt_8981_sff1_x4 1 2235 0 9444 1569 sff1_x4
xsubckt_2232_mx2_x2 0 10433 1 6300 6169 1821 mx2_x2
xsubckt_1390_nand3_x0 1 0 6975 7177 194 8070 nand3_x0
xsubckt_528_nand3_x0 1 0 7812 7824 7870 1895 nand3_x0
xsubckt_796_nand3_x0 1 0 7548 7549 7550 7551 nand3_x0
xsubckt_1050_a3_x2 1 7307 0 7308 7309 7310 a3_x2
xsubckt_3214_nxr2_x1 5151 1 0 242 761 nxr2_x1
xsubckt_3417_nand2_x0 1 0 4951 4952 783 nand2_x0
xsubckt_3507_nand2_x0 1 0 4863 5993 236 nand2_x0
xsubckt_3685_nand2_x0 1 0 10393 4688 4745 nand2_x0
xsubckt_3898_mx2_x2 0 4478 1 818 1584 1552 mx2_x2
xsubckt_5019_a3_x2 1 3859 0 711 701 653 a3_x2
xsubckt_5146_a4_x2 0 3742 1 3782 3921 3924 3927 a4_x2
xsubckt_5359_nand2_x0 1 0 3543 3544 701 nand2_x0
xsubckt_7073_mx2_x2 0 8669 1 6440 8670 577 mx2_x2
xsubckt_7450_nand4_x0 1 0 8486 4212 6303 6305 7885 nand4_x0
xsubckt_7464_mx2_x2 0 9345 1 8485 6178 894 mx2_x2
xsubckt_7466_mx2_x2 0 9343 1 8485 6162 892 mx2_x2
xsubckt_7595_mx3_x2 1 0 9222 8467 6287 1061 6225 6230 mx3_x2
xsubckt_7597_mx3_x2 1 0 9220 8467 6287 1089 6206 6209 mx3_x2
xsubckt_7853_mx2_x2 0 8947 1 8428 6054 1839 mx2_x2
xsubckt_7855_mx2_x2 0 8945 1 8428 6034 1837 mx2_x2
xsubckt_7857_mx2_x2 0 8943 1 8428 6017 1834 mx2_x2
xsubckt_8019_sff1_x4 1 2238 0 10338 1149 sff1_x4
xsubckt_8097_sff1_x4 1 2110 0 10260 1166 sff1_x4
xsubckt_8977_sff1_x4 1 2218 0 9448 1543 sff1_x4
xsubckt_9354_sff1_x4 1 2245 0 9089 990 sff1_x4
xsubckt_2445_nand2_x0 1 0 5906 5908 771 nand2_x0
xsubckt_2238_mx2_x2 0 10432 1 6300 6162 1820 mx2_x2
xsubckt_2213_a3_x2 1 6193 0 6194 540 8409 a3_x2
xsubckt_2192_mx2_x2 0 6233 1 6297 6235 6239 mx2_x2
xsubckt_2190_mx2_x2 0 6241 1 545 95 2259 mx2_x2
xsubckt_358_inv_x0 1 0 7993 436 inv_x0
xsubckt_2581_mx2_x2 0 5773 1 817 1161 1065 mx2_x2
xsubckt_2583_mx2_x2 0 5771 1 788 5772 5773 mx2_x2
xsubckt_4726_nand3_x0 1 0 4077 4078 4091 4143 nand3_x0
xsubckt_5410_oa22_x2 0 3496 1 3502 3500 3498 oa22_x2
xsubckt_5508_a3_x2 1 3424 0 3427 2025 2026 a3_x2
xsubckt_6540_mx2_x2 0 2487 1 851 1841 1809 mx2_x2
xsubckt_7077_mx2_x2 0 9598 1 8665 6282 1539 mx2_x2
xsubckt_7079_mx2_x2 0 9596 1 8665 6272 1527 mx2_x2
xsubckt_7284_nand2_x0 1 0 8552 8553 8577 nand2_x0
xsubckt_7468_mx2_x2 0 9341 1 8484 6142 890 mx2_x2
xsubckt_8454_sff1_x4 1 2057 0 9903 1951 sff1_x4
xsubckt_8811_sff1_x4 1 2083 0 9611 714 sff1_x4
xcmpt_instr_rdcycleh_hfns_0 1 0 636 638 buf_x4
xsubckt_1902_nand3_x0 1 0 432 6492 7804 7807 nand3_x0
xsubckt_1237_a2_x2 0 7128 1 204 236 a2_x2
xsubckt_1217_a2_x2 0 7148 1 199 231 a2_x2
xsubckt_448_ao22_x2 0 7890 1 7899 7895 7891 ao22_x2
xsubckt_782_o2_x2 0 7562 1 765 90 o2_x2
xsubckt_969_nand2_x0 1 0 7384 236 1897 nand2_x0
xsubckt_2585_mx2_x2 0 5769 1 775 5770 5777 mx2_x2
xsubckt_2587_mx2_x2 0 5767 1 795 1129 1097 mx2_x2
xsubckt_2589_mx2_x2 0 5765 1 796 1289 1257 mx2_x2
xsubckt_2962_nand3_x0 1 0 5398 5399 5615 7857 nand3_x0
xsubckt_3147_nand2_x0 1 0 5217 5995 243 nand2_x0
xsubckt_3237_nand2_x0 1 0 5128 5129 782 nand2_x0
xsubckt_5011_mx3_x2 1 0 3865 6449 547 8394 8149 8150 mx3_x2
xsubckt_5089_nand2_x0 1 0 3795 3934 8254 nand2_x0
xsubckt_5107_a2_x2 0 3778 1 3930 723 a2_x2
xsubckt_5528_a3_x2 1 3410 0 3414 2019 2020 a3_x2
xsubckt_5743_a3_x2 1 3261 0 7913 42 503 a3_x2
xsubckt_6151_mx2_x2 0 2865 1 850 1181 1085 mx2_x2
xsubckt_6153_mx2_x2 0 2863 1 850 989 957 mx2_x2
xsubckt_6155_mx2_x2 0 2861 1 834 2862 2863 mx2_x2
xsubckt_6542_mx2_x2 0 2485 1 850 1713 1681 mx2_x2
xsubckt_6544_mx2_x2 0 2483 1 834 2484 2485 mx2_x2
xsubckt_6546_mx2_x2 0 2481 1 850 1873 1521 mx2_x2
xsubckt_7016_nand2_x0 1 0 8691 8692 8827 nand2_x0
xsubckt_7911_sff1_x4 1 2132 0 10441 1799 sff1_x4
xsubckt_8362_sff1_x4 1 2251 0 9995 1480 sff1_x4
xsubckt_8885_sff1_x4 1 2050 0 9540 350 sff1_x4
xsubckt_9262_sff1_x4 1 2214 0 9178 1430 sff1_x4
xcmpt_instr_rdcycleh_hfns_2 1 0 639 636 buf_x4
xcmpt_instr_rdcycleh_hfns_1 1 0 636 637 buf_x4
xsubckt_1706_a2_x2 0 6672 1 6673 238 a2_x2
xsubckt_1698_a3_x2 1 6679 0 6680 6681 6682 a3_x2
xsubckt_511_nand3_x0 1 0 7826 7909 7910 626 nand3_x0
xsubckt_2782_nand3_x0 1 0 5575 5604 5608 8013 nand3_x0
xsubckt_3057_nand2_x0 1 0 5305 5306 781 nand2_x0
xsubckt_3095_a2_x2 0 5268 1 5269 5276 a2_x2
xsubckt_3270_a2_x2 0 5096 1 241 760 a2_x2
xsubckt_3684_oa22_x2 0 4688 1 4689 4736 5994 oa22_x2
xsubckt_4659_a3_x2 1 4128 0 4129 4143 1943 a3_x2
xsubckt_4707_a2_x2 0 4092 1 1971 1970 a2_x2
xsubckt_4874_a3_x2 1 9878 0 3967 3969 40 a3_x2
xsubckt_4941_oa22_x2 0 9860 1 7885 3918 3920 oa22_x2
xsubckt_5015_mx3_x2 1 0 3862 6448 546 8401 8147 8148 mx3_x2
xsubckt_5353_nxr2_x1 3549 1 0 3880 8268 nxr2_x1
xsubckt_5568_a3_x2 1 9768 0 3383 3384 41 a3_x2
xsubckt_5616_a2_x2 0 9754 1 3349 3350 a2_x2
xsubckt_5811_a2_x2 0 3195 1 3196 6427 a2_x2
xsubckt_6157_mx2_x2 0 2859 1 827 2860 2867 mx2_x2
xsubckt_6159_mx2_x2 0 2857 1 856 1309 1277 mx2_x2
xsubckt_6214_oa22_x2 0 2804 1 41 1905 208 oa22_x2
xsubckt_6548_mx2_x2 0 2479 1 8225 2480 2481 mx2_x2
xsubckt_7985_sff1_x4 1 2222 0 10372 1791 sff1_x4
xsubckt_8807_sff1_x4 1 2066 0 9615 718 sff1_x4
xsubckt_9258_sff1_x4 1 2205 0 9182 1435 sff1_x4
xsubckt_1884_oa22_x2 0 2296 1 6511 6510 6506 oa22_x2
xsubckt_1845_nxr2_x1 6542 1 0 6543 8051 nxr2_x1
xsubckt_1766_a2_x2 0 6616 1 6617 233 a2_x2
xsubckt_1449_oa22_x2 0 6912 1 6915 6916 237 oa22_x2
xsubckt_1379_nand3_x0 1 0 6986 7145 200 8084 nand3_x0
xsubckt_1322_nxr2_x1 7043 1 0 456 237 nxr2_x1
xsubckt_421_nand3_x0 1 0 7923 366 365 504 nand3_x0
xsubckt_599_nor2_x0 1 0 7739 7740 7741 nor2_x0
xsubckt_952_nand2_x0 1 0 7400 629 1930 nand2_x0
xsubckt_2675_a2_x2 0 5681 1 221 740 a2_x2
xsubckt_2784_oa22_x2 0 5573 1 5574 5577 5947 oa22_x2
xsubckt_2797_xr2_x1 5561 0 1 219 738 xr2_x1
xsubckt_5368_mx3_x2 1 0 3535 701 653 3877 3536 3539 mx3_x2
xsubckt_6986_a3_x2 1 8718 0 8719 8267 375 a3_x2
xsubckt_7907_sff1_x4 1 2097 0 10445 1815 sff1_x4
xsubckt_8270_sff1_x4 1 2235 0 10087 1284 sff1_x4
xsubckt_8358_sff1_x4 1 2110 0 9999 1506 sff1_x4
xsubckt_8793_sff1_x4 1 2089 0 9629 726 sff1_x4
xsubckt_9170_sff1_x4 1 2145 0 9270 1394 sff1_x4
xsubckt_1753_nxr2_x1 6628 1 0 6631 234 nxr2_x1
xsubckt_1648_ao22_x2 0 6726 1 6738 6735 6728 ao22_x2
xsubckt_1225_o2_x2 0 7140 1 201 233 o2_x2
xsubckt_1205_o2_x2 0 7160 1 197 229 o2_x2
xsubckt_2625_nor2_x0 1 0 5730 222 741 nor2_x0
xsubckt_3837_nand2_x0 1 0 4538 4539 780 nand2_x0
xsubckt_4311_mx2_x2 0 10243 1 4199 6178 1246 mx2_x2
xsubckt_4937_oa22_x2 0 9861 1 7886 3921 3923 oa22_x2
xsubckt_5115_o2_x2 0 9833 1 3771 3783 o2_x2
xsubckt_5441_xr2_x1 3469 0 1 2040 2041 xr2_x1
xsubckt_5689_nand2_x0 1 0 3285 8300 45 nand2_x0
xsubckt_5971_mx2_x2 0 3040 1 855 1156 1060 mx2_x2
xsubckt_5973_mx2_x2 0 3038 1 855 964 932 mx2_x2
xsubckt_5975_mx2_x2 0 3036 1 836 3037 3038 mx2_x2
xsubckt_6844_ao22_x2 0 8824 1 706 8277 656 ao22_x2
xsubckt_8715_sff1_x4 1 2063 0 9675 708 sff1_x4
xsubckt_9166_sff1_x4 1 2214 0 9274 1398 sff1_x4
xsubckt_2408_o2_x2 0 5942 1 768 249 o2_x2
xsubckt_2244_nand3_x0 1 0 6154 6155 6157 6292 nand3_x0
xsubckt_367_nor4_x0 1 0 7981 645 616 624 618 nor4_x0
xsubckt_3747_nand2_x0 1 0 4627 5994 232 nand2_x0
xsubckt_4096_nand3_x0 1 0 4283 4284 4459 7857 nand3_x0
xsubckt_4313_mx2_x2 0 10241 1 4199 6161 1244 mx2_x2
xsubckt_4315_mx2_x2 0 10239 1 4199 6143 1242 mx2_x2
xsubckt_4446_mx3_x2 1 0 10121 4176 6292 1670 6236 6240 mx3_x2
xsubckt_4448_mx3_x2 1 0 10119 4176 6292 1668 6216 6220 mx3_x2
xsubckt_5977_mx2_x2 0 3034 1 828 3035 3042 mx2_x2
xsubckt_5979_mx2_x2 0 3032 1 855 1284 1252 mx2_x2
xsubckt_8266_sff1_x4 1 2251 0 10091 1288 sff1_x4
xsubckt_8789_sff1_x4 1 2053 0 9633 635 sff1_x4
xsubckt_9000_sff1_x4 1 2111 0 9425 1549 sff1_x4
xcmpt_decoded_imm_j_20_hfns_2 1 0 731 728 buf_x4
xcmpt_decoded_imm_j_20_hfns_1 1 0 728 729 buf_x4
xcmpt_decoded_imm_j_20_hfns_0 1 0 728 730 buf_x4
xsubckt_1661_nxr2_x1 6714 1 0 6717 241 nxr2_x1
xsubckt_3036_nand3_x0 1 0 5326 5327 5328 7905 nand3_x0
xsubckt_3264_ao22_x2 0 5101 1 5150 5149 5102 ao22_x2
xsubckt_3657_nand2_x0 1 0 4715 4716 779 nand2_x0
xsubckt_4317_mx2_x2 0 10237 1 4199 6124 1240 mx2_x2
xsubckt_4319_mx2_x2 0 10235 1 4198 6107 1237 mx2_x2
xsubckt_4702_nand2_x0 1 0 4095 4097 1971 nand2_x0
xsubckt_5296_oa22_x2 0 3602 1 3604 3606 8294 oa22_x2
xsubckt_8100_sff1_x4 1 2136 0 10257 1162 sff1_x4
xsubckt_8623_sff1_x4 1 2159 0 185 122 sff1_x4
xsubckt_9074_sff1_x4 1 2066 0 315 57 sff1_x4
xsubckt_1625_nand2_x0 1 0 2315 6748 6752 nand2_x0
xsubckt_524_a3_x2 1 7815 0 564 8274 1906 a3_x2
xsubckt_418_oa22_x2 0 10467 1 7944 7928 7926 oa22_x2
xsubckt_678_nand3_x0 1 0 7664 7665 7666 1903 nand3_x0
xsubckt_3000_mx2_x2 0 5361 1 798 1600 1568 mx2_x2
xsubckt_3004_mx2_x2 0 5357 1 798 1152 1120 mx2_x2
xsubckt_3477_nand2_x0 1 0 4892 4893 779 nand2_x0
xsubckt_3814_nxr2_x1 4561 1 0 231 750 nxr2_x1
xsubckt_4277_mx2_x2 0 10275 1 4203 6178 1182 mx2_x2
xsubckt_4279_mx2_x2 0 10273 1 4203 6162 1180 mx2_x2
xsubckt_4714_nxr2_x1 4086 1 0 4089 8318 nxr2_x1
xsubckt_4753_oa22_x2 0 4056 1 4059 4064 1958 oa22_x2
xsubckt_5165_nxr2_x1 3724 1 0 3919 735 nxr2_x1
xsubckt_8174_sff1_x4 1 2189 0 10183 1700 sff1_x4
xsubckt_8619_sff1_x4 1 2169 0 159 96 sff1_x4
xsubckt_8697_sff1_x4 1 2172 0 9693 207 sff1_x4
xsubckt_9431_sff1_x4 1 2129 0 9012 912 sff1_x4
xcmpt_abc_30082_new_n3294_hfns_2 1 0 8417 8414 buf_x4
xcmpt_abc_30082_new_n3294_hfns_1 1 0 8414 8415 buf_x4
xcmpt_abc_30082_new_n3294_hfns_0 1 0 8414 8416 buf_x4
xsubckt_2313_nand4_x0 1 0 6065 6093 76 75 74 nand4_x0
xsubckt_2272_ao22_x2 0 6118 1 80 6129 6293 ao22_x2
xsubckt_2211_mx3_x2 1 0 10436 6302 6293 1824 6197 6201 mx3_x2
xsubckt_200_inv_x0 1 0 115 8176 inv_x0
xsubckt_722_nxr2_x1 7622 1 0 7623 7626 nxr2_x1
xsubckt_2914_nxr2_x1 5446 1 0 247 766 nxr2_x1
xsubckt_3008_mx2_x2 0 5353 1 797 1312 1280 mx2_x2
xsubckt_3351_mx2_x2 0 5016 1 797 1850 1818 mx2_x2
xsubckt_3387_nand2_x0 1 0 4981 5993 239 nand2_x0
xsubckt_7703_mx2_x2 0 9121 1 8448 6179 1022 mx2_x2
xsubckt_7834_mx3_x2 1 0 8966 8431 6293 1829 6226 6230 mx3_x2
xsubckt_7836_mx3_x2 1 0 8964 8431 6293 1857 6206 6210 mx3_x2
xsubckt_8531_sff1_x4 1 2179 0 9826 149 sff1_x4
xsubckt_9427_sff1_x4 1 2172 0 9016 916 sff1_x4
xcmpt_abc_30082_new_n3298_hfns_2 1 0 8410 8407 buf_x4
xcmpt_abc_30082_new_n3298_hfns_1 1 0 8407 8408 buf_x4
xcmpt_abc_30082_new_n3298_hfns_0 1 0 8407 8409 buf_x4
xsubckt_1895_ao22_x2 0 6496 1 217 8285 7806 ao22_x2
xsubckt_202_inv_x0 1 0 114 8174 inv_x0
xsubckt_204_inv_x0 1 0 113 8172 inv_x0
xsubckt_206_inv_x0 1 0 111 8170 inv_x0
xsubckt_761_oa22_x2 0 7582 1 7601 7599 7600 oa22_x2
xsubckt_849_oa22_x2 0 7498 1 7499 7500 7617 oa22_x2
xsubckt_898_a3_x2 1 7451 0 7452 7453 7454 a3_x2
xsubckt_2844_nand3_x0 1 0 5514 5515 5688 7857 nand3_x0
xsubckt_2953_oa22_x2 0 5407 1 5408 5409 776 oa22_x2
xsubckt_3297_nand2_x0 1 0 5069 5070 782 nand2_x0
xsubckt_3355_mx2_x2 0 5012 1 821 1434 1402 mx2_x2
xsubckt_3359_mx2_x2 0 5008 1 821 1594 1562 mx2_x2
xsubckt_3636_nand3_x0 1 0 4736 4737 4738 7905 nand3_x0
xsubckt_4661_oa22_x2 0 4126 1 4129 4143 1943 oa22_x2
xsubckt_7705_mx2_x2 0 9119 1 8449 6162 1020 mx2_x2
xsubckt_7707_mx2_x2 0 9117 1 8449 6143 1018 mx2_x2
xsubckt_7709_mx2_x2 0 9115 1 8449 6124 1016 mx2_x2
xsubckt_8004_sff1_x4 1 2108 0 10353 1770 sff1_x4
xsubckt_8082_sff1_x4 1 2245 0 10275 1182 sff1_x4
xsubckt_8527_sff1_x4 1 2179 0 9830 153 sff1_x4
xsubckt_8962_sff1_x4 1 2145 0 9463 1587 sff1_x4
xsubckt_2435_mx2_x2 0 5916 1 790 5917 5918 mx2_x2
xsubckt_2433_mx2_x2 0 5918 1 820 1154 1122 mx2_x2
xsubckt_2431_mx2_x2 0 5920 1 820 1378 1346 mx2_x2
xsubckt_2042_mx2_x2 0 6406 1 835 6407 6408 mx2_x2
xsubckt_2040_mx2_x2 0 6408 1 858 1847 1815 mx2_x2
xsubckt_160_inv_x0 1 0 419 8236 inv_x0
xsubckt_162_inv_x0 1 0 408 8234 inv_x0
xsubckt_164_inv_x0 1 0 405 8232 inv_x0
xsubckt_208_inv_x0 1 0 110 8168 inv_x0
xsubckt_2822_mx2_x2 0 5536 1 820 1573 1541 mx2_x2
xsubckt_2826_mx2_x2 0 5532 1 820 1125 1093 mx2_x2
xsubckt_3273_nxr2_x1 5093 1 0 241 760 nxr2_x1
xsubckt_4155_a4_x2 0 4226 1 6304 6306 6312 551 a4_x2
xsubckt_5044_nand2_x0 1 0 9838 3837 3846 nand2_x0
xsubckt_7009_a3_x2 1 8697 0 8722 8264 385 a3_x2
xsubckt_7270_mx2_x2 0 9502 1 8832 8564 760 mx2_x2
xsubckt_7661_mx2_x2 0 9161 1 8454 6252 1032 mx2_x2
xsubckt_8078_sff1_x4 1 2192 0 10279 1156 sff1_x4
xsubckt_9335_sff1_x4 1 2113 0 9105 1005 sff1_x4
xsubckt_2439_mx2_x2 0 5912 1 791 5913 5914 mx2_x2
xsubckt_2437_mx2_x2 0 5914 1 809 1602 1570 mx2_x2
xsubckt_2391_mx2_x2 0 5965 1 809 1859 1827 mx2_x2
xsubckt_2048_mx2_x2 0 6400 1 863 1879 1527 mx2_x2
xsubckt_2046_mx2_x2 0 6402 1 836 6403 6404 mx2_x2
xsubckt_2044_mx2_x2 0 6404 1 863 983 951 mx2_x2
xsubckt_1514_nand3_x0 1 0 6851 6852 6853 6940 nand3_x0
xsubckt_1175_nand2_x0 1 0 7189 224 1897 nand2_x0
xsubckt_166_inv_x0 1 0 404 8230 inv_x0
xsubckt_168_inv_x0 1 0 403 8228 inv_x0
xsubckt_757_oa22_x2 0 7585 1 7586 7587 7617 oa22_x2
xsubckt_834_nand2_x0 1 0 7512 629 1937 nand2_x0
xsubckt_1085_nand2_x0 1 0 7274 630 1923 nand2_x0
xsubckt_3987_nand2_x0 1 0 4391 5994 228 nand2_x0
xsubckt_5233_ao22_x2 0 3661 1 3677 3903 8295 ao22_x2
xsubckt_6001_mx2_x2 0 3011 1 8222 3012 3013 mx2_x2
xsubckt_6003_mx2_x2 0 3009 1 863 1793 1761 mx2_x2
xsubckt_6005_mx2_x2 0 3007 1 8214 3008 3011 mx2_x2
xsubckt_7669_mx2_x2 0 9153 1 8454 6178 1054 mx2_x2
xsubckt_8435_sff1_x4 1 2047 0 9922 1972 sff1_x4
xsubckt_8870_sff1_x4 1 2076 0 9555 336 sff1_x4
xsubckt_8958_sff1_x4 1 2251 0 9467 1592 sff1_x4
xsubckt_2395_mx2_x2 0 5961 1 771 5962 5977 mx2_x2
xsubckt_2393_mx2_x2 0 5963 1 784 5964 5967 mx2_x2
xsubckt_2306_nand3_x0 1 0 6074 6093 76 75 nand3_x0
xsubckt_1991_mx3_x2 1 0 484 8001 6450 232 107 139 mx3_x2
xsubckt_1830_nxr2_x1 6556 1 0 6558 197 nxr2_x1
xsubckt_1799_ao22_x2 0 6585 1 6602 6599 6586 ao22_x2
xsubckt_1556_a3_x2 1 6812 0 6845 8054 8065 a3_x2
xsubckt_1330_a2_x2 0 7035 1 467 217 a2_x2
xsubckt_1310_a2_x2 0 7055 1 441 222 a2_x2
xsubckt_719_o2_x2 0 7625 1 738 63 o2_x2
xsubckt_3276_nand3_x0 1 0 5090 5091 5092 7904 nand3_x0
xsubckt_5220_a2_x2 0 3673 1 3906 715 a2_x2
xsubckt_5426_a3_x2 1 3481 0 3482 3496 3499 a3_x2
xsubckt_5446_a3_x2 1 9807 0 3466 3467 46 a3_x2
xsubckt_6007_mx2_x2 0 3005 1 862 1185 1089 mx2_x2
xsubckt_6009_mx2_x2 0 3003 1 862 993 961 mx2_x2
xsubckt_6350_mx2_x2 0 2671 1 8222 2672 2673 mx2_x2
xsubckt_6352_mx2_x2 0 2669 1 826 2670 2677 mx2_x2
xsubckt_6741_mx2_x2 0 8912 1 862 1643 1611 mx2_x2
xsubckt_6743_mx2_x2 0 8910 1 8222 8911 8912 mx2_x2
xsubckt_6745_mx2_x2 0 8908 1 862 1419 1387 mx2_x2
xsubckt_7117_a2_x2 0 8658 1 8002 8421 a2_x2
xsubckt_7173_oa22_x2 0 8635 1 46 8300 8145 oa22_x2
xsubckt_7970_sff1_x4 1 2092 0 10387 228 sff1_x4
xsubckt_9243_sff1_x4 1 2106 0 9197 1442 sff1_x4
xsubckt_2010_ao22_x2 0 6437 1 6953 6954 577 ao22_x2
xsubckt_1997_mx3_x2 1 0 477 8002 6449 225 100 132 mx3_x2
xsubckt_1995_mx3_x2 1 0 480 8002 6449 228 103 135 mx3_x2
xsubckt_1993_mx3_x2 1 0 482 8002 6449 230 105 137 mx3_x2
xsubckt_1955_nand2_x0 1 0 6457 7809 198 nand2_x0
xsubckt_1469_nxr2_x1 6893 1 0 6894 6905 nxr2_x1
xsubckt_3442_a2_x2 0 4926 1 4927 4929 a2_x2
xsubckt_4820_a2_x2 0 9893 1 4007 4008 a2_x2
xsubckt_5514_a2_x2 0 9785 1 3420 50 a2_x2
xsubckt_5534_a2_x2 0 9779 1 3406 50 a2_x2
xsubckt_5821_mx2_x2 0 3186 1 8223 3187 3188 mx2_x2
xsubckt_6717_a2_x2 0 9681 1 8936 2349 a2_x2
xsubckt_6718_oa22_x2 0 8935 1 50 1905 194 oa22_x2
xsubckt_6747_mx2_x2 0 8906 1 8213 8907 8910 mx2_x2
xsubckt_6749_mx2_x2 0 8904 1 8207 8905 8920 mx2_x2
xsubckt_7966_sff1_x4 1 2092 0 10391 232 sff1_x4
xsubckt_8343_sff1_x4 1 2238 0 10014 1337 sff1_x4
xsubckt_8866_sff1_x4 1 2076 0 9559 362 sff1_x4
xsubckt_2012_o2_x2 0 6435 1 6436 6437 o2_x2
xsubckt_1865_nand2_x0 1 0 6523 7170 7971 nand2_x0
xsubckt_3864_ao22_x2 0 4511 1 4560 4559 4512 ao22_x2
xsubckt_3931_a2_x2 0 4446 1 229 748 a2_x2
xsubckt_4665_a2_x2 0 4124 1 1943 1932 a2_x2
xsubckt_5041_mx2_x2 0 3839 1 652 3840 3841 mx2_x2
xsubckt_5823_mx2_x2 0 3184 1 839 1768 1736 mx2_x2
xsubckt_5825_mx2_x2 0 3182 1 8212 3183 3186 mx2_x2
xsubckt_5827_mx2_x2 0 3180 1 839 1160 1064 mx2_x2
xsubckt_6917_ao22_x2 0 8772 1 707 8279 663 ao22_x2
xsubckt_6952_a2_x2 0 9643 1 8745 49 a2_x2
xsubckt_7169_oa22_x2 0 8638 1 49 8300 8146 oa22_x2
xsubckt_7318_nand2_x0 1 0 8525 725 652 nand2_x0
xsubckt_8339_sff1_x4 1 2238 0 10018 1341 sff1_x4
xsubckt_8700_sff1_x4 1 2166 0 9690 204 sff1_x4
xsubckt_9151_sff1_x4 1 2251 0 9289 1384 sff1_x4
xsubckt_9239_sff1_x4 1 2111 0 9201 1069 sff1_x4
xsubckt_930_oa22_x2 0 7421 1 7614 7478 7422 oa22_x2
xsubckt_2820_nand2_x0 1 0 5538 5539 779 nand2_x0
xsubckt_3880_nand2_x0 1 0 4496 4497 779 nand2_x0
xsubckt_4510_mx2_x2 0 10063 1 4162 6278 1666 mx2_x2
xsubckt_4672_ao22_x2 0 9928 1 4119 4120 52 ao22_x2
xsubckt_5554_nand2_x0 1 0 3392 3395 2010 nand2_x0
xsubckt_5781_mx2_x2 0 3225 1 839 1378 1346 mx2_x2
xsubckt_5783_mx2_x2 0 3223 1 839 1250 1218 mx2_x2
xsubckt_5829_mx2_x2 0 3178 1 839 968 936 mx2_x2
xsubckt_7124_nand4_x0 1 0 8652 8653 7918 8300 53 nand4_x0
xsubckt_8251_sff1_x4 1 2209 0 10106 1684 sff1_x4
xsubckt_8774_sff1_x4 1 2070 0 9648 624 sff1_x4
xsubckt_1595_nand2_x0 1 0 2317 6776 6780 nand2_x0
xsubckt_1211_nxr2_x1 7154 1 0 198 230 nxr2_x1
xsubckt_80_inv_x0 1 0 1951 8331 inv_x0
xsubckt_3450_o2_x2 0 4919 1 238 757 o2_x2
xsubckt_3876_nand3_x0 1 0 4500 566 8290 74 nand3_x0
xsubckt_4121_mx2_x2 0 4259 1 8030 4260 4261 mx2_x2
xsubckt_4123_mx2_x2 0 4257 1 804 1483 1451 mx2_x2
xsubckt_4404_nand2_x0 1 0 4180 4182 4183 nand2_x0
xsubckt_4512_mx2_x2 0 10061 1 4162 6266 1644 mx2_x2
xsubckt_4514_mx2_x2 0 10059 1 4162 6252 1640 mx2_x2
xsubckt_4516_mx2_x2 0 10057 1 4162 6233 1638 mx2_x2
xsubckt_5281_oa22_x2 0 3616 1 3618 3621 8295 oa22_x2
xsubckt_5374_nand2_x0 1 0 3530 3540 3873 nand2_x0
xsubckt_5644_xr2_x1 3329 0 1 224 743 xr2_x1
xsubckt_5785_mx2_x2 0 3221 1 8224 3222 3223 mx2_x2
xsubckt_5787_mx2_x2 0 3219 1 838 1442 1410 mx2_x2
xsubckt_5789_mx2_x2 0 3217 1 833 3218 3219 mx2_x2
xsubckt_7276_ao22_x2 0 8559 1 662 644 393 ao22_x2
xsubckt_8247_sff1_x4 1 2212 0 10110 1689 sff1_x4
xsubckt_8682_sff1_x4 1 2086 0 9708 456 sff1_x4
xsubckt_9147_sff1_x4 1 2106 0 9293 1410 sff1_x4
xsubckt_2400_nor3_x0 1 0 5953 716 715 714 nor3_x0
xsubckt_1692_nor2_x0 1 0 6685 6686 6692 nor2_x0
xsubckt_1497_o2_x2 0 6867 1 6868 6872 o2_x2
xsubckt_1285_nxr2_x1 7080 1 0 213 246 nxr2_x1
xsubckt_402_a3_x2 1 7943 0 51 92 504 a3_x2
xsubckt_82_inv_x0 1 0 1953 8329 inv_x0
xsubckt_84_inv_x0 1 0 1956 8327 inv_x0
xsubckt_86_inv_x0 1 0 1959 8325 inv_x0
xsubckt_543_nand3_x0 1 0 7796 7797 7800 7805 nand3_x0
xsubckt_2855_o2_x2 0 5504 1 218 737 o2_x2
xsubckt_4125_mx2_x2 0 4255 1 8031 4256 4257 mx2_x2
xsubckt_4127_mx2_x2 0 4253 1 803 1643 1611 mx2_x2
xsubckt_4129_mx2_x2 0 4251 1 8031 4252 4253 mx2_x2
xsubckt_4470_mx2_x2 0 10097 1 4174 6018 1674 mx2_x2
xsubckt_4518_mx2_x2 0 10055 1 4161 6213 1636 mx2_x2
xsubckt_8604_sff1_x4 1 2044 0 9753 1989 sff1_x4
xsubckt_9055_sff1_x4 1 2206 0 9375 1372 sff1_x4
xsubckt_2093_nxr2_x1 6353 1 0 58 59 nxr2_x1
xsubckt_1207_nxr2_x1 7158 1 0 197 229 nxr2_x1
xsubckt_88_inv_x0 1 0 1961 8323 inv_x0
xsubckt_2460_nand2_x0 1 0 5891 6008 8137 nand2_x0
xsubckt_3873_nxr2_x1 4503 1 0 230 749 nxr2_x1
xsubckt_4083_mx2_x2 0 4296 1 808 1293 1261 mx2_x2
xsubckt_4134_nand2_x0 1 0 4246 4247 782 nand2_x0
xsubckt_4474_mx2_x2 0 10096 1 4168 6283 1315 mx2_x2
xsubckt_4476_mx2_x2 0 10094 1 4167 6273 1303 mx2_x2
xsubckt_4478_mx2_x2 0 10092 1 4167 6259 1289 mx2_x2
xsubckt_5111_oa22_x2 0 3774 1 3776 3779 8294 oa22_x2
xsubckt_6210_ao22_x2 0 2807 1 574 569 761 ao22_x2
xsubckt_8155_sff1_x4 1 2238 0 10202 1460 sff1_x4
xsubckt_8590_sff1_x4 1 2057 0 9767 2004 sff1_x4
xsubckt_8678_sff1_x4 1 2063 0 9711 503 sff1_x4
xsubckt_9412_sff1_x4 1 2172 0 9031 902 sff1_x4
xsubckt_9490_sff1_x4 1 2219 0 8953 1845 sff1_x4
xsubckt_716_nand2_x0 1 0 7627 7628 7636 nand2_x0
xsubckt_894_nand2_x0 1 0 7455 7990 2033 nand2_x0
xsubckt_3943_mx2_x2 0 4434 1 808 1167 1071 mx2_x2
xsubckt_4044_nand2_x0 1 0 10387 4335 4391 nand2_x0
xsubckt_5185_oa22_x2 0 3705 1 3706 3717 7881 oa22_x2
xsubckt_5384_ao22_x2 0 3520 1 3521 3522 3528 ao22_x2
xsubckt_8512_sff1_x4 1 2153 0 9845 73 sff1_x4
xsubckt_9486_sff1_x4 1 2224 0 8957 1850 sff1_x4
xsubckt_1927_nand2_x0 1 0 464 6472 6473 nand2_x0
xsubckt_570_a2_x2 0 7767 1 1897 217 a2_x2
xsubckt_3163_mx2_x2 0 5201 1 807 1181 1085 mx2_x2
xsubckt_3167_mx2_x2 0 5197 1 807 1789 1757 mx2_x2
xsubckt_3501_nand3_x0 1 0 4868 4869 5048 7856 nand3_x0
xsubckt_3947_mx2_x2 0 4430 1 807 1775 1743 mx2_x2
xsubckt_5577_nxr2_x1 3376 1 0 3380 8108 nxr2_x1
xsubckt_7511_mx2_x2 0 9300 1 8479 6061 1104 mx2_x2
xsubckt_7513_mx2_x2 0 9298 1 8479 6043 1102 mx2_x2
xsubckt_7515_mx2_x2 0 9296 1 8480 6026 1099 mx2_x2
xsubckt_8063_sff1_x4 1 2129 0 10294 1744 sff1_x4
xsubckt_8508_sff1_x4 1 2159 0 9849 77 sff1_x4
xsubckt_8586_sff1_x4 1 2060 0 9771 2009 sff1_x4
xsubckt_9320_sff1_x4 1 2232 0 9120 1021 sff1_x4
xsubckt_9408_sff1_x4 1 2096 0 9035 908 sff1_x4
xsubckt_1837_nand2_x0 1 0 6550 6948 7165 nand2_x0
xsubckt_1521_a4_x2 0 6845 1 6887 8062 8063 8064 a4_x2
xsubckt_446_nand2_x0 1 0 7892 1895 505 nand2_x0
xsubckt_1040_nand2_x0 1 0 7317 7319 7321 nand2_x0
xsubckt_2629_nand2_x0 1 0 5726 5727 7904 nand2_x0
xsubckt_2632_mx2_x2 0 5723 1 806 1768 1736 mx2_x2
xsubckt_2634_mx2_x2 0 5721 1 806 1832 1800 mx2_x2
xsubckt_3321_nand3_x0 1 0 5045 5046 5225 7857 nand3_x0
xsubckt_4677_nxr2_x1 4114 1 0 4116 8312 nxr2_x1
xsubckt_5010_a3_x2 1 3866 0 40 69 8399 a3_x2
xsubckt_5093_oa22_x2 0 3791 1 3936 3820 3933 oa22_x2
xsubckt_6870_inv_x0 1 0 8804 9410 inv_x0
xsubckt_7054_a4_x2 0 8683 1 8846 8847 9422 9421 a4_x2
xsubckt_7080_mx2_x2 0 9595 1 8666 6266 1516 mx2_x2
xsubckt_7471_mx2_x2 0 9338 1 8485 6116 886 mx2_x2
xsubckt_7473_mx2_x2 0 9336 1 8485 6098 884 mx2_x2
xsubckt_7519_mx2_x2 0 9294 1 8475 6283 1411 mx2_x2
xsubckt_7864_mx2_x2 0 9620 1 6440 9403 732 mx2_x2
xsubckt_8420_sff1_x4 1 2108 0 9937 1610 sff1_x4
xsubckt_8943_sff1_x4 1 2106 0 9482 1577 sff1_x4
xsubckt_9394_sff1_x4 1 2218 0 9049 949 sff1_x4
xsubckt_2247_mx2_x2 0 6149 1 547 115 2279 mx2_x2
xsubckt_1784_ao22_x2 0 6599 1 6608 6607 6601 ao22_x2
xsubckt_1404_nor3_x0 1 0 6961 560 561 656 nor3_x0
xsubckt_1180_a3_x2 1 7184 0 7185 7186 7187 a3_x2
xsubckt_2590_mx2_x2 0 5764 1 811 1353 1321 mx2_x2
xsubckt_2636_mx2_x2 0 5719 1 790 5720 5721 mx2_x2
xsubckt_2638_mx2_x2 0 5717 1 811 968 936 mx2_x2
xsubckt_2981_mx2_x2 0 5380 1 790 5381 5382 mx2_x2
xsubckt_2983_mx2_x2 0 5378 1 811 1888 1536 mx2_x2
xsubckt_4367_a4_x2 0 4188 1 4221 6304 6306 551 a4_x2
xsubckt_4644_nand2_x0 1 0 4139 703 1912 nand2_x0
xsubckt_4816_a4_x2 0 4009 1 4010 4016 4028 4142 a4_x2
xsubckt_5083_nand3_x0 1 0 3800 3801 3802 653 nand3_x0
xsubckt_6200_mx2_x2 0 2817 1 8213 2818 2821 mx2_x2
xsubckt_6202_mx2_x2 0 2815 1 841 1596 1564 mx2_x2
xsubckt_6204_mx2_x2 0 2813 1 841 1500 1468 mx2_x2
xsubckt_6872_inv_x0 1 0 8803 9409 inv_x0
xsubckt_6874_inv_x0 1 0 8802 9408 inv_x0
xsubckt_7082_mx2_x2 0 9593 1 8665 6251 1512 mx2_x2
xsubckt_7475_mx2_x2 0 9334 1 8484 6081 882 mx2_x2
xsubckt_7477_mx2_x2 0 9332 1 8484 6061 880 mx2_x2
xsubckt_7479_mx2_x2 0 9330 1 8485 6043 878 mx2_x2
xsubckt_7866_mx2_x2 0 9612 1 6441 9406 715 mx2_x2
xsubckt_7868_mx2_x2 0 9610 1 6441 9404 713 mx2_x2
xsubckt_8059_sff1_x4 1 2209 0 10298 1748 sff1_x4
xsubckt_8416_sff1_x4 1 2132 0 9941 1615 sff1_x4
xsubckt_8494_sff1_x4 1 2169 0 9863 62 sff1_x4
xsubckt_8939_sff1_x4 1 2099 0 9486 1603 sff1_x4
xsubckt_9316_sff1_x4 1 2235 0 9124 1025 sff1_x4
xcmpt_abc_30082_new_n5610_hfns_2 1 0 6055 6052 buf_x4
xcmpt_abc_30082_new_n5610_hfns_1 1 0 6052 6053 buf_x4
xcmpt_abc_30082_new_n5610_hfns_0 1 0 6052 6054 buf_x4
xsubckt_1033_a2_x2 0 7323 1 7324 7330 a2_x2
xsubckt_1053_a2_x2 0 7304 1 7305 7313 a2_x2
xsubckt_2592_mx2_x2 0 5762 1 779 5763 5766 mx2_x2
xsubckt_2594_mx2_x2 0 5760 1 812 1641 1609 mx2_x2
xsubckt_2596_mx2_x2 0 5758 1 812 1481 1449 mx2_x2
xsubckt_2702_nand2_x0 1 0 5654 5655 779 nand2_x0
xsubckt_2985_mx2_x2 0 5376 1 8033 5377 5378 mx2_x2
xsubckt_2987_mx2_x2 0 5374 1 811 1728 1696 mx2_x2
xsubckt_2989_mx2_x2 0 5372 1 790 5373 5374 mx2_x2
xsubckt_3141_nand3_x0 1 0 5222 5223 5401 7857 nand3_x0
xsubckt_6160_mx2_x2 0 2856 1 8219 2857 2858 mx2_x2
xsubckt_6162_mx2_x2 0 2854 1 844 1149 1117 mx2_x2
xsubckt_6206_mx2_x2 0 2811 1 8219 2812 2813 mx2_x2
xsubckt_6208_mx2_x2 0 2809 1 828 2810 2817 mx2_x2
xsubckt_6321_a2_x2 0 9692 1 2700 2734 a2_x2
xsubckt_6551_mx2_x2 0 2476 1 832 2477 2478 mx2_x2
xsubckt_6553_mx2_x2 0 2474 1 828 2475 2482 mx2_x2
xsubckt_7210_a2_x2 0 8608 1 730 652 a2_x2
xsubckt_7951_sff1_x4 1 2166 0 10406 218 sff1_x4
xsubckt_8851_sff1_x4 1 2145 0 9574 1522 sff1_x4
xcmpt_abc_30082_new_n5618_hfns_2 1 0 6045 6042 buf_x4
xcmpt_abc_30082_new_n5618_hfns_1 1 0 6042 6043 buf_x4
xcmpt_abc_30082_new_n5618_hfns_0 1 0 6042 6044 buf_x4
xsubckt_2315_oa22_x2 0 6063 1 6064 6065 6067 oa22_x2
xsubckt_1816_nand3_x0 1 0 6569 6570 6571 6940 nand3_x0
xsubckt_1811_nxr2_x1 6574 1 0 6576 198 nxr2_x1
xsubckt_1728_a3_x2 1 6651 0 6652 6653 6654 a3_x2
xsubckt_1493_oa22_x2 0 6871 1 6887 8062 615 oa22_x2
xsubckt_1327_a2_x2 0 7038 1 7039 7043 a2_x2
xsubckt_646_oa22_x2 0 7694 1 7695 7699 7793 oa22_x2
xsubckt_677_o2_x2 0 7665 1 7667 7669 o2_x2
xsubckt_2598_mx2_x2 0 5756 1 8034 5757 5758 mx2_x2
xsubckt_2790_nand2_x0 1 0 5568 5993 219 nand2_x0
xsubckt_2838_oa22_x2 0 5520 1 5521 5522 8017 oa22_x2
xsubckt_4981_oa22_x2 0 9850 1 7884 3888 3890 oa22_x2
xsubckt_5277_a2_x2 0 3620 1 3894 730 a2_x2
xsubckt_5393_nxr2_x1 3512 1 0 3513 3514 nxr2_x1
xsubckt_6164_mx2_x2 0 2852 1 8211 2853 2856 mx2_x2
xsubckt_6166_mx2_x2 0 2850 1 854 1597 1565 mx2_x2
xsubckt_6168_mx2_x2 0 2848 1 854 1501 1469 mx2_x2
xsubckt_6555_mx2_x2 0 2472 1 854 1297 1265 mx2_x2
xsubckt_6557_mx2_x2 0 2470 1 854 1233 1201 mx2_x2
xsubckt_6559_mx2_x2 0 2468 1 8220 2469 2470 mx2_x2
xsubckt_6810_a2_x2 0 8849 1 1894 648 a2_x2
xsubckt_6902_ao22_x2 0 9655 1 8783 8786 43 ao22_x2
xsubckt_8324_sff1_x4 1 2112 0 10033 1642 sff1_x4
xsubckt_8847_sff1_x4 1 2204 0 9578 1526 sff1_x4
xsubckt_9224_sff1_x4 1 2232 0 9216 1085 sff1_x4
xsubckt_9298_sff1_x4 1 2145 0 9142 1042 sff1_x4
xcmpt_abc_30082_new_n5576_hfns_2 1 0 6099 6096 buf_x4
xcmpt_abc_30082_new_n5576_hfns_1 1 0 6096 6097 buf_x4
xcmpt_abc_30082_new_n5576_hfns_0 1 0 6096 6098 buf_x4
xsubckt_1640_nand2_x0 1 0 2314 6734 6744 nand2_x0
xsubckt_1550_nand2_x0 1 0 2290 6818 6822 nand2_x0
xsubckt_1001_o2_x2 0 7354 1 7355 7357 o2_x2
xsubckt_1119_nand2_x0 1 0 7242 7243 1895 nand2_x0
xsubckt_4850_nxr2_x1 3983 1 0 3985 8346 nxr2_x1
xsubckt_5961_a2_x2 0 9702 1 3050 3084 a2_x2
xsubckt_6830_a2_x2 0 8838 1 8839 8845 a2_x2
xsubckt_6850_a2_x2 0 8819 1 8828 393 a2_x2
xsubckt_6976_ao22_x2 0 8727 1 707 8278 618 ao22_x2
xsubckt_6991_nor4_x0 1 0 8713 387 392 391 390 nor4_x0
xsubckt_7947_sff1_x4 1 2092 0 10410 222 sff1_x4
xsubckt_8398_sff1_x4 1 2235 0 9959 1604 sff1_x4
xsubckt_9132_sff1_x4 1 2246 0 9308 1113 sff1_x4
xsubckt_753_ao22_x2 0 7589 1 7590 7594 7795 ao22_x2
xsubckt_1029_nand2_x0 1 0 7327 1990 638 nand2_x0
xsubckt_3197_oa22_x2 0 5167 1 5168 5207 5958 oa22_x2
xsubckt_3741_nand3_x0 1 0 4632 4633 4812 7857 nand3_x0
xsubckt_4194_nand2_x0 1 0 4216 4218 4221 nand2_x0
xsubckt_4709_nand4_x0 1 0 4090 4092 4098 4107 4117 nand4_x0
xsubckt_4887_nand4_x0 1 0 3957 3966 1922 1920 1919 nand4_x0
xsubckt_4977_oa22_x2 0 9851 1 7886 3891 3893 oa22_x2
xsubckt_5980_mx2_x2 0 3031 1 8221 3032 3033 mx2_x2
xsubckt_5982_mx2_x2 0 3029 1 866 1124 1092 mx2_x2
xsubckt_6989_a2_x2 0 8715 1 8716 8718 a2_x2
xsubckt_7261_ao22_x2 0 8571 1 662 644 390 ao22_x2
xsubckt_8232_sff1_x4 1 2095 0 10125 1676 sff1_x4
xsubckt_8755_sff1_x4 1 2070 0 9667 658 sff1_x4
xsubckt_1370_nand2_x0 1 0 6995 203 8091 nand2_x0
xsubckt_1315_o2_x2 0 7050 1 442 223 o2_x2
xsubckt_1270_nxr2_x1 7095 1 0 210 243 nxr2_x1
xsubckt_911_oa22_x2 0 7439 1 7614 7478 7440 oa22_x2
xsubckt_985_oa22_x2 0 7369 1 417 7809 7618 oa22_x2
xsubckt_2959_nand2_x0 1 0 5401 6007 8102 nand2_x0
xsubckt_3911_oa22_x2 0 4465 1 4466 4467 776 oa22_x2
xsubckt_4320_mx2_x2 0 10234 1 4199 6098 1236 mx2_x2
xsubckt_4322_mx2_x2 0 10232 1 4199 6080 1234 mx2_x2
xsubckt_5285_o2_x2 0 9821 1 3613 3625 o2_x2
xsubckt_5984_mx2_x2 0 3027 1 8213 3028 3031 mx2_x2
xsubckt_5986_mx2_x2 0 3025 1 866 1572 1540 mx2_x2
xsubckt_5988_mx2_x2 0 3023 1 866 1476 1444 mx2_x2
xsubckt_6884_ao22_x2 0 8795 1 707 8279 643 ao22_x2
xsubckt_7058_oa22_x2 0 8680 1 703 8245 8274 oa22_x2
xsubckt_9040_sff1_x4 1 2103 0 9390 1379 sff1_x4
xsubckt_9128_sff1_x4 1 2238 0 9312 1117 sff1_x4
xsubckt_1395_o2_x2 0 6970 1 6971 7003 o2_x2
xsubckt_1266_nxr2_x1 7099 1 0 209 242 nxr2_x1
xsubckt_506_a4_x2 0 7830 1 8270 8273 8274 1906 a4_x2
xsubckt_686_nand2_x0 1 0 7656 7657 7659 nand2_x0
xsubckt_1102_nand2_x0 1 0 7258 229 1897 nand2_x0
xsubckt_2501_nand3_x0 1 0 5851 5852 5855 5950 nand3_x0
xsubckt_2558_o2_x2 0 5795 1 226 745 o2_x2
xsubckt_3561_nand3_x0 1 0 4809 4810 4989 7856 nand3_x0
xsubckt_4280_mx2_x2 0 10272 1 4204 6151 1179 mx2_x2
xsubckt_4324_mx2_x2 0 10230 1 4198 6061 1232 mx2_x2
xsubckt_4326_mx2_x2 0 10228 1 4198 6043 1230 mx2_x2
xsubckt_4328_mx2_x2 0 10226 1 4198 6027 1227 mx2_x2
xsubckt_6070_oa22_x2 0 2944 1 47 1905 212 oa22_x2
xsubckt_6643_o2_x2 0 2386 1 2387 7930 o2_x2
xsubckt_8140_sff1_x4 1 2193 0 10217 1446 sff1_x4
xsubckt_8228_sff1_x4 1 2119 0 10129 1258 sff1_x4
xsubckt_8663_sff1_x4 1 2182 0 9726 525 sff1_x4
xsubckt_1647_nor3_x0 1 0 6727 6728 6735 6738 nor3_x0
xsubckt_2942_nand2_x0 1 0 5418 5419 8024 nand2_x0
xsubckt_3381_nand3_x0 1 0 4986 4987 5166 7857 nand3_x0
xsubckt_3400_mx2_x2 0 4968 1 791 4969 4970 mx2_x2
xsubckt_3402_mx2_x2 0 4966 1 815 1881 1529 mx2_x2
xsubckt_3404_mx2_x2 0 4964 1 8036 4965 4966 mx2_x2
xsubckt_4282_mx2_x2 0 10270 1 4203 6135 1177 mx2_x2
xsubckt_4284_mx2_x2 0 10268 1 4204 6116 1174 mx2_x2
xsubckt_4286_mx2_x2 0 10266 1 4204 6098 1172 mx2_x2
xsubckt_6714_ao22_x2 0 8938 1 574 568 746 ao22_x2
xsubckt_8659_sff1_x4 1 2185 0 9730 530 sff1_x4
xsubckt_9036_sff1_x4 1 2079 0 9394 378 sff1_x4
xsubckt_9471_sff1_x4 1 2097 0 8972 1847 sff1_x4
xsubckt_507_a2_x2 0 7829 1 7830 7831 a2_x2
xsubckt_3360_mx2_x2 0 5007 1 8036 5008 5009 mx2_x2
xsubckt_3406_mx2_x2 0 4962 1 815 1721 1689 mx2_x2
xsubckt_3408_mx2_x2 0 4960 1 791 4961 4962 mx2_x2
xsubckt_4288_mx2_x2 0 10264 1 4204 6081 1170 mx2_x2
xsubckt_7710_mx2_x2 0 9114 1 8448 6116 1014 mx2_x2
xsubckt_8136_sff1_x4 1 2099 0 10221 1452 sff1_x4
xsubckt_8571_sff1_x4 1 2050 0 9786 2025 sff1_x4
xcmpt_abc_30082_new_n7657_hfns_2 1 0 4187 4184 buf_x4
xcmpt_abc_30082_new_n7657_hfns_1 1 0 4184 4185 buf_x4
xcmpt_abc_30082_new_n7657_hfns_0 1 0 4184 4186 buf_x4
xsubckt_1880_nand2_x0 1 0 6509 6948 7174 nand2_x0
xsubckt_1619_nxr2_x1 6753 1 0 6754 6761 nxr2_x1
xsubckt_211_inv_x0 1 0 2273 8165 inv_x0
xsubckt_213_inv_x0 1 0 2272 8163 inv_x0
xsubckt_742_a2_x2 0 7600 1 737 62 a2_x2
xsubckt_762_a2_x2 0 7581 1 766 91 a2_x2
xsubckt_2672_nand2_x0 1 0 10410 5684 5735 nand2_x0
xsubckt_3362_mx2_x2 0 5005 1 816 1242 1210 mx2_x2
xsubckt_3364_mx2_x2 0 5003 1 8036 5004 5005 mx2_x2
xsubckt_3366_mx2_x2 0 5001 1 816 1370 1338 mx2_x2
xsubckt_3759_mx2_x2 0 4615 1 816 1042 1010 mx2_x2
xsubckt_7712_mx2_x2 0 9112 1 8448 6097 1012 mx2_x2
xsubckt_7714_mx2_x2 0 9110 1 8449 6081 1010 mx2_x2
xsubckt_7716_mx2_x2 0 9108 1 8449 6061 1008 mx2_x2
xsubckt_8044_sff1_x4 1 2172 0 10313 1734 sff1_x4
xsubckt_8567_sff1_x4 1 2050 0 9790 2030 sff1_x4
xsubckt_9467_sff1_x4 1 2138 0 8976 1867 sff1_x4
xsubckt_2442_mx2_x2 0 5909 1 8029 5910 5911 mx2_x2
xsubckt_2440_mx2_x2 0 5911 1 819 1506 1474 mx2_x2
xsubckt_1790_nand2_x0 1 0 2303 6594 6598 nand2_x0
xsubckt_1334_ao22_x2 0 7031 1 7032 7037 7038 ao22_x2
xsubckt_219_inv_x0 1 0 2269 8157 inv_x0
xsubckt_217_inv_x0 1 0 2270 8159 inv_x0
xsubckt_215_inv_x0 1 0 2271 8161 inv_x0
xsubckt_171_inv_x0 1 0 823 8208 inv_x0
xsubckt_2831_mx2_x2 0 5527 1 8029 5528 5529 mx2_x2
xsubckt_3368_mx2_x2 0 4999 1 8029 5000 5001 mx2_x2
xsubckt_7333_nand2_x0 1 0 8513 709 652 nand2_x0
xsubckt_7458_mx3_x2 1 0 9351 8487 6290 870 6236 6240 mx3_x2
xsubckt_7670_mx2_x2 0 9152 1 8454 6170 1053 mx2_x2
xsubckt_7672_mx2_x2 0 9150 1 8453 6152 1051 mx2_x2
xsubckt_7718_mx2_x2 0 9106 1 8449 6044 1006 mx2_x2
xsubckt_8401_sff1_x4 1 2247 0 9956 1631 sff1_x4
xsubckt_8924_sff1_x4 1 2153 0 9501 761 sff1_x4
xsubckt_9301_sff1_x4 1 2123 0 9139 1039 sff1_x4
xsubckt_9375_sff1_x4 1 2126 0 9068 951 sff1_x4
xsubckt_2221_a3_x2 1 6183 0 6203 89 88 a3_x2
xsubckt_2051_mx2_x2 0 6397 1 827 6398 6405 mx2_x2
xsubckt_1566_oa22_x2 0 6803 1 6813 6807 6806 oa22_x2
xsubckt_1432_nand2_x0 1 0 6928 468 8285 nand2_x0
xsubckt_1179_nand2_x0 1 0 7185 634 1952 nand2_x0
xsubckt_173_inv_x0 1 0 2265 8203 inv_x0
xsubckt_175_inv_x0 1 0 2262 8201 inv_x0
xsubckt_177_inv_x0 1 0 2261 8199 inv_x0
xsubckt_2668_nand3_x0 1 0 5687 5688 5840 6392 nand3_x0
xsubckt_3981_nand3_x0 1 0 4396 4397 4576 7856 nand3_x0
xsubckt_4734_a4_x2 0 4071 1 4072 4078 4091 4142 a4_x2
xsubckt_6010_mx2_x2 0 3002 1 848 1057 1025 mx2_x2
xsubckt_6012_mx2_x2 0 3000 1 8211 3001 3004 mx2_x2
xsubckt_6401_mx2_x2 0 2622 1 8211 2623 2626 mx2_x2
xsubckt_6403_mx2_x2 0 2620 1 848 1173 1077 mx2_x2
xsubckt_6405_mx2_x2 0 2618 1 848 981 949 mx2_x2
xsubckt_7239_nand3_x0 1 0 8587 8588 8604 8609 nand3_x0
xsubckt_7285_mx2_x2 0 9499 1 8832 8552 763 mx2_x2
xsubckt_7674_mx2_x2 0 9148 1 8454 6135 1049 mx2_x2
xsubckt_7676_mx2_x2 0 9146 1 8453 6116 1046 mx2_x2
xsubckt_7678_mx2_x2 0 9144 1 8453 6098 1044 mx2_x2
xsubckt_8475_sff1_x4 1 2044 0 9882 1928 sff1_x4
xsubckt_8998_sff1_x4 1 2132 0 9427 1551 sff1_x4
xsubckt_2300_oa22_x2 0 6082 1 6083 6084 6085 oa22_x2
xsubckt_2224_nand2_x0 1 0 6180 6181 6185 nand2_x0
xsubckt_2134_a2_x2 0 315 1 6314 6349 a2_x2
xsubckt_1342_nand2_x0 1 0 7023 439 8118 nand2_x0
xsubckt_179_inv_x0 1 0 2260 8197 inv_x0
xsubckt_555_o2_x2 0 7781 1 7782 7785 o2_x2
xsubckt_575_o2_x2 0 7762 1 7763 7768 o2_x2
xsubckt_2741_nand3_x0 1 0 5616 5617 5743 7857 nand3_x0
xsubckt_2897_oa22_x2 0 5462 1 5463 5464 8017 oa22_x2
xsubckt_3023_a2_x2 0 5338 1 5339 5341 a2_x2
xsubckt_3797_oa22_x2 0 4577 1 4578 4617 5957 oa22_x2
xsubckt_4401_a2_x2 0 4183 1 4220 8004 a2_x2
xsubckt_4683_nand3_x0 1 0 4110 4112 4116 1975 nand3_x0
xsubckt_4774_a4_x2 0 4041 1 1956 1955 1953 1952 a4_x2
xsubckt_5087_a3_x2 1 3797 0 52 127 8399 a3_x2
xsubckt_5135_a2_x2 0 3752 1 3924 736 a2_x2
xsubckt_5262_a3_x2 1 3634 0 3635 3636 8295 a3_x2
xsubckt_5269_ao22_x2 0 3627 1 3628 3634 701 ao22_x2
xsubckt_6014_mx2_x2 0 2998 1 852 1377 1345 mx2_x2
xsubckt_6016_mx2_x2 0 2996 1 8224 2997 2998 mx2_x2
xsubckt_6018_mx2_x2 0 2994 1 852 1153 1121 mx2_x2
xsubckt_6361_mx2_x2 0 2661 1 8224 2662 2663 mx2_x2
xsubckt_6407_mx2_x2 0 2616 1 833 2617 2618 mx2_x2
xsubckt_6409_mx2_x2 0 2614 1 827 2615 2622 mx2_x2
xsubckt_8832_sff1_x4 1 2245 0 9593 1512 sff1_x4
xsubckt_9283_sff1_x4 1 2235 0 9157 1028 sff1_x4
xcmpt_abc_30082_new_n10739_hfns_2 1 0 8486 8483 buf_x4
xcmpt_abc_30082_new_n10739_hfns_1 1 0 8483 8484 buf_x4
xcmpt_abc_30082_new_n10739_hfns_0 1 0 8483 8485 buf_x4
xsubckt_2154_a2_x2 0 6304 1 8005 553 a2_x2
xsubckt_1959_nand2_x0 1 0 6455 7809 196 nand2_x0
xsubckt_1474_oa22_x2 0 2297 1 6940 6893 6889 oa22_x2
xsubckt_1460_a2_x2 0 6902 1 6903 8415 a2_x2
xsubckt_1162_nand2_x0 1 0 7201 633 1953 nand2_x0
xsubckt_2623_a2_x2 0 5732 1 222 741 a2_x2
xsubckt_3083_a2_x2 0 5279 1 5280 5285 a2_x2
xsubckt_4842_a3_x2 1 3989 0 3991 4142 1934 a3_x2
xsubckt_5427_oa22_x2 0 3480 1 3483 3486 8294 oa22_x2
xsubckt_5576_a3_x2 1 3377 0 3382 2002 2003 a3_x2
xsubckt_5624_a2_x2 0 3343 1 3346 1987 a2_x2
xsubckt_6363_mx2_x2 0 2659 1 850 1782 1750 mx2_x2
xsubckt_6365_mx2_x2 0 2657 1 8215 2658 2661 mx2_x2
xsubckt_6367_mx2_x2 0 2655 1 850 1174 1078 mx2_x2
xsubckt_6756_mx2_x2 0 8898 1 850 1834 1802 mx2_x2
xsubckt_6758_mx2_x2 0 8896 1 851 1706 1674 mx2_x2
xsubckt_6961_ao22_x2 0 8738 1 706 8277 617 ao22_x2
xsubckt_7267_a2_x2 0 8566 1 715 653 a2_x2
xsubckt_7932_sff1_x4 1 2126 0 10420 1807 sff1_x4
xsubckt_8383_sff1_x4 1 2129 0 9974 1488 sff1_x4
xsubckt_8828_sff1_x4 1 2106 0 9597 1538 sff1_x4
xsubckt_9205_sff1_x4 1 2132 0 9235 1199 sff1_x4
xsubckt_1734_a2_x2 0 6646 1 6647 235 a2_x2
xsubckt_826_ao22_x2 0 7520 1 7522 7525 1902 ao22_x2
xsubckt_1072_nand2_x0 1 0 7286 7287 7295 nand2_x0
xsubckt_4715_a2_x2 0 9918 1 4086 41 a2_x2
xsubckt_5449_a2_x2 0 9806 1 3464 41 a2_x2
xsubckt_5830_mx2_x2 0 3177 1 856 1032 1000 mx2_x2
xsubckt_5832_mx2_x2 0 3175 1 8214 3176 3179 mx2_x2
xsubckt_5834_mx2_x2 0 3173 1 857 1352 1320 mx2_x2
xsubckt_6369_mx2_x2 0 2653 1 857 982 950 mx2_x2
xsubckt_6573_a2_x2 0 9685 1 2455 2489 a2_x2
xsubckt_6807_a2_x2 0 8851 1 1893 646 a2_x2
xsubckt_6827_a2_x2 0 8840 1 8841 8845 a2_x2
xsubckt_6957_ao22_x2 0 8741 1 707 8279 613 ao22_x2
xsubckt_7287_a2_x2 0 8550 1 735 652 a2_x2
xsubckt_7334_ao22_x2 0 8512 1 8251 8607 8513 ao22_x2
xsubckt_7756_a2_x2 0 8441 1 8457 4182 a2_x2
xsubckt_7928_sff1_x4 1 2142 0 10424 1811 sff1_x4
xsubckt_8305_sff1_x4 1 2247 0 10052 1663 sff1_x4
xsubckt_8740_sff1_x4 1 2176 0 2305 2273 sff1_x4
xsubckt_9191_sff1_x4 1 2251 0 9249 1214 sff1_x4
xsubckt_9279_sff1_x4 1 2242 0 9161 1032 sff1_x4
xsubckt_641_nand2_x0 1 0 7699 7991 2007 nand2_x0
xsubckt_1018_o2_x2 0 7338 1 752 77 o2_x2
xsubckt_2824_nand2_x0 1 0 5534 5535 8024 nand2_x0
xsubckt_3574_nxr2_x1 4797 1 0 235 754 nxr2_x1
xsubckt_3884_nand2_x0 1 0 4492 4493 8024 nand2_x0
xsubckt_4145_nand3_x0 1 0 4235 4236 4239 5950 nand3_x0
xsubckt_4305_mx3_x2 1 0 10249 4201 6289 1222 6236 6240 mx3_x2
xsubckt_4307_mx3_x2 1 0 10247 4201 6289 1220 6216 6220 mx3_x2
xsubckt_4795_a2_x2 0 9899 1 4025 40 a2_x2
xsubckt_5143_o2_x2 0 9831 1 3745 3757 o2_x2
xsubckt_5790_mx2_x2 0 3216 1 856 1602 1570 mx2_x2
xsubckt_5836_mx2_x2 0 3171 1 8226 3172 3173 mx2_x2
xsubckt_5838_mx2_x2 0 3169 1 856 1128 1096 mx2_x2
xsubckt_8291_sff1_x4 1 2137 0 10066 1291 sff1_x4
xsubckt_8379_sff1_x4 1 2238 0 9978 1492 sff1_x4
xsubckt_8736_sff1_x4 1 2182 0 2310 2278 sff1_x4
xsubckt_9113_sff1_x4 1 2136 0 9327 874 sff1_x4
xsubckt_1942_nand2_x0 1 0 461 6460 6461 nand2_x0
xsubckt_1459_o3_x2 0 6903 1 456 467 468 o3_x2
xsubckt_1273_o2_x2 0 7092 1 211 244 o2_x2
xsubckt_1253_o2_x2 0 7112 1 208 241 o2_x2
xsubckt_4309_mx3_x2 1 0 10245 4201 6290 1248 6197 6201 mx3_x2
xsubckt_4521_mx2_x2 0 10052 1 4161 6189 1663 mx2_x2
xsubckt_4523_mx2_x2 0 10050 1 4161 6170 1661 mx2_x2
xsubckt_4827_nxr2_x1 4000 1 0 4002 8341 nxr2_x1
xsubckt_4912_mx2_x2 0 3939 1 6445 6255 129 mx2_x2
xsubckt_5792_mx2_x2 0 3214 1 836 3215 3216 mx2_x2
xsubckt_5794_mx2_x2 0 3212 1 827 3213 3220 mx2_x2
xsubckt_5796_mx2_x2 0 3210 1 855 1730 1698 mx2_x2
xsubckt_8213_sff1_x4 1 2205 0 10144 1275 sff1_x4
xsubckt_8287_sff1_x4 1 2204 0 10070 1296 sff1_x4
xsubckt_9109_sff1_x4 1 2123 0 9331 879 sff1_x4
xsubckt_9187_sff1_x4 1 2194 0 9253 1188 sff1_x4
xsubckt_91_inv_x0 1 0 1964 8320 inv_x0
xsubckt_93_inv_x0 1 0 1968 8318 inv_x0
xsubckt_966_oa22_x2 0 7387 1 418 7809 7618 oa22_x2
xsubckt_3385_o2_x2 0 4982 1 4983 5995 o2_x2
xsubckt_4132_mx2_x2 0 4248 1 793 1131 1099 mx2_x2
xsubckt_4136_mx2_x2 0 4244 1 793 1291 1259 mx2_x2
xsubckt_4525_mx2_x2 0 10048 1 4162 6152 1659 mx2_x2
xsubckt_4527_mx2_x2 0 10046 1 4162 6135 1657 mx2_x2
xsubckt_4529_mx2_x2 0 10044 1 4161 6115 1654 mx2_x2
xsubckt_4916_mx2_x2 0 3936 1 6444 6248 128 mx2_x2
xsubckt_5798_mx2_x2 0 3208 1 855 1858 1826 mx2_x2
xsubckt_6500_oa22_x2 0 2525 1 3190 2528 2526 oa22_x2
xsubckt_6574_oa22_x2 0 2454 1 45 1906 198 oa22_x2
xsubckt_8121_sff1_x4 1 2215 0 10236 1238 sff1_x4
xsubckt_8209_sff1_x4 1 2248 0 10148 1279 sff1_x4
xsubckt_8644_sff1_x4 1 2076 0 162 99 sff1_x4
xsubckt_9021_sff1_x4 1 2079 0 9409 394 sff1_x4
xsubckt_1411_ao22_x2 0 6954 1 6957 6956 6955 ao22_x2
xsubckt_95_inv_x0 1 0 1970 8316 inv_x0
xsubckt_97_inv_x0 1 0 1974 8314 inv_x0
xsubckt_99_inv_x0 1 0 1915 8312 inv_x0
xsubckt_800_oa22_x2 0 184 1 7559 7558 7545 oa22_x2
xsubckt_2464_nand2_x0 1 0 5887 5888 5900 nand2_x0
xsubckt_3207_ao22_x2 0 5158 1 5216 5211 5213 ao22_x2
xsubckt_3603_mx2_x2 0 4768 1 799 1141 1109 mx2_x2
xsubckt_4138_nand2_x0 1 0 4242 4243 8022 nand2_x0
xsubckt_5239_oa22_x2 0 3655 1 3657 3659 8294 oa22_x2
xsubckt_6895_o2_x2 0 9657 1 8788 8790 o2_x2
xsubckt_8195_sff1_x4 1 2119 0 10162 1707 sff1_x4
xsubckt_9017_sff1_x4 1 2066 0 9413 368 sff1_x4
xsubckt_9095_sff1_x4 1 2224 0 9345 894 sff1_x4
xsubckt_9452_sff1_x4 1 2212 0 8991 1884 sff1_x4
xsubckt_405_a2_x2 0 7940 1 327 249 a2_x2
xsubckt_988_nand2_x0 1 0 7366 235 1897 nand2_x0
xsubckt_1120_oa22_x2 0 7241 1 7614 7478 7242 oa22_x2
xsubckt_3607_mx2_x2 0 4764 1 799 1301 1269 mx2_x2
xsubckt_3950_mx2_x2 0 4427 1 799 911 879 mx2_x2
xsubckt_3952_mx2_x2 0 4425 1 8033 4426 4427 mx2_x2
xsubckt_4487_mx2_x2 0 10083 1 4168 6179 1310 mx2_x2
xsubckt_4489_mx2_x2 0 10081 1 4168 6162 1308 mx2_x2
xsubckt_5361_nand2_x0 1 0 9816 3542 3565 nand2_x0
xsubckt_7299_nand3_x0 1 0 8540 8541 8244 702 nand3_x0
xsubckt_8117_sff1_x4 1 2203 0 10240 1243 sff1_x4
xsubckt_8552_sff1_x4 1 2060 0 9805 2007 sff1_x4
xcmpt_abc_30082_new_n11114_hfns_2 1 0 8430 8427 buf_x4
xcmpt_abc_30082_new_n11114_hfns_1 1 0 8427 8428 buf_x4
xcmpt_abc_30082_new_n11114_hfns_0 1 0 8427 8429 buf_x4
xsubckt_2451_oa22_x2 0 5900 1 5901 5936 5958 oa22_x2
xsubckt_2293_ao22_x2 0 6091 1 77 6102 6293 ao22_x2
xsubckt_2016_nand2_x0 1 0 321 6432 6435 nand2_x0
xsubckt_472_o4_x2 0 7865 1 640 633 638 630 o4_x2
xsubckt_445_a2_x2 0 7893 1 1894 505 a2_x2
xsubckt_3170_mx2_x2 0 5194 1 798 925 893 mx2_x2
xsubckt_3172_mx2_x2 0 5192 1 8034 5193 5194 mx2_x2
xsubckt_3174_mx2_x2 0 5190 1 798 1501 1469 mx2_x2
xsubckt_3218_mx2_x2 0 5147 1 798 988 956 mx2_x2
xsubckt_3813_xr2_x1 4562 0 1 231 750 xr2_x1
xsubckt_3954_mx2_x2 0 4423 1 798 1487 1455 mx2_x2
xsubckt_3956_mx2_x2 0 4421 1 8034 4422 4423 mx2_x2
xsubckt_3958_mx2_x2 0 4419 1 798 1647 1615 mx2_x2
xsubckt_6246_ao22_x2 0 2772 1 573 568 760 ao22_x2
xsubckt_7520_mx2_x2 0 9293 1 8475 6277 1410 mx2_x2
xsubckt_7522_mx2_x2 0 9291 1 8475 6265 1388 mx2_x2
xsubckt_9360_sff1_x4 1 2222 0 9083 984 sff1_x4
xsubckt_9448_sff1_x4 1 2198 0 8995 1888 sff1_x4
xsubckt_2215_ao22_x2 0 6191 1 89 6203 6293 ao22_x2
xsubckt_416_inv_x0 1 0 7927 9936 inv_x0
xsubckt_779_a2_x2 0 7564 1 7565 7573 a2_x2
xsubckt_971_nand2_x0 1 0 7382 629 1929 nand2_x0
xsubckt_2641_mx2_x2 0 5714 1 797 1160 1064 mx2_x2
xsubckt_3176_mx2_x2 0 5188 1 8034 5189 5190 mx2_x2
xsubckt_3178_mx2_x2 0 5186 1 797 1661 1629 mx2_x2
xsubckt_5177_nand3_x0 1 0 3713 3714 3715 8295 nand3_x0
xsubckt_7135_mx2_x2 0 9560 1 8645 363 468 mx2_x2
xsubckt_7137_mx2_x2 0 9558 1 8645 351 456 mx2_x2
xsubckt_7480_mx2_x2 0 9329 1 8485 6034 877 mx2_x2
xsubckt_7524_mx2_x2 0 9289 1 8474 6252 1384 mx2_x2
xsubckt_7871_mx2_x2 0 9607 1 6440 9400 710 mx2_x2
xsubckt_8025_sff1_x4 1 2215 0 10332 1142 sff1_x4
xsubckt_8460_sff1_x4 1 2060 0 9897 1945 sff1_x4
xsubckt_8548_sff1_x4 1 2060 0 9809 2041 sff1_x4
xsubckt_8905_sff1_x4 1 2123 0 9520 552 sff1_x4
xsubckt_8983_sff1_x4 1 2247 0 9442 1567 sff1_x4
xsubckt_2254_mx2_x2 0 6140 1 547 114 2278 mx2_x2
xsubckt_1508_nxr2_x1 6857 1 0 6858 8064 nxr2_x1
xsubckt_385_o3_x2 0 7960 1 645 622 621 o3_x2
xsubckt_2643_mx2_x2 0 5712 1 789 5713 5714 mx2_x2
xsubckt_2645_mx2_x2 0 5710 1 776 5711 5718 mx2_x2
xsubckt_2647_mx2_x2 0 5708 1 821 1128 1096 mx2_x2
xsubckt_5055_oa22_x2 0 3826 1 3828 3831 8293 oa22_x2
xsubckt_5340_nand3_x0 1 0 3562 3588 3879 3882 nand3_x0
xsubckt_5497_nor2_x0 1 0 3431 3433 2030 nor2_x0
xsubckt_5541_a4_x2 0 3401 1 3407 2016 2014 2015 a4_x2
xsubckt_6600_mx2_x2 0 2428 1 859 1488 1456 mx2_x2
xsubckt_6602_mx2_x2 0 2426 1 8221 2427 2428 mx2_x2
xsubckt_6604_mx2_x2 0 2424 1 825 2425 2432 mx2_x2
xsubckt_7091_mx2_x2 0 9584 1 8665 6169 1533 mx2_x2
xsubckt_7093_mx2_x2 0 9582 1 8665 6151 1531 mx2_x2
xsubckt_7139_mx2_x2 0 9556 1 8645 337 442 mx2_x2
xsubckt_7482_mx2_x2 0 9327 1 8484 6018 874 mx2_x2
xsubckt_7486_mx2_x2 0 9325 1 8479 6277 1122 mx2_x2
xsubckt_8099_sff1_x4 1 2137 0 10258 1163 sff1_x4
xsubckt_8979_sff1_x4 1 2229 0 9446 1541 sff1_x4
xsubckt_9356_sff1_x4 1 2212 0 9087 988 sff1_x4
xsubckt_1914_nand2_x0 1 0 6482 456 330 nand2_x0
xsubckt_1824_nand2_x0 1 0 6562 7160 7971 nand2_x0
xsubckt_1524_a3_x2 1 6842 0 6844 439 8416 a3_x2
xsubckt_1494_nxr2_x1 6870 1 0 6871 441 nxr2_x1
xsubckt_2649_mx2_x2 0 5706 1 820 1288 1256 mx2_x2
xsubckt_2706_nand2_x0 1 0 5650 5651 8023 nand2_x0
xsubckt_2992_mx2_x2 0 5369 1 820 1856 1824 mx2_x2
xsubckt_2996_mx2_x2 0 5365 1 820 1440 1408 mx2_x2
xsubckt_3215_a2_x2 0 5150 1 5151 5158 a2_x2
xsubckt_3255_oa22_x2 0 5110 1 5111 5112 8017 oa22_x2
xsubckt_5259_a3_x2 1 3637 0 3663 3897 3900 a3_x2
xsubckt_5412_oa22_x2 0 3494 1 3495 3496 3505 oa22_x2
xsubckt_6215_mx2_x2 0 2803 1 858 923 891 mx2_x2
xsubckt_6217_mx2_x2 0 2801 1 8221 2802 2803 mx2_x2
xsubckt_6560_mx2_x2 0 2467 1 8213 2468 2471 mx2_x2
xsubckt_7095_mx2_x2 0 9580 1 8666 6135 1529 mx2_x2
xsubckt_7097_mx2_x2 0 9578 1 8666 6116 1526 mx2_x2
xsubckt_7099_mx2_x2 0 9576 1 8666 6098 1524 mx2_x2
xsubckt_7125_a2_x2 0 8651 1 8652 8654 a2_x2
xsubckt_7488_mx2_x2 0 9323 1 8480 6266 1100 mx2_x2
xsubckt_7991_sff1_x4 1 2212 0 10366 1785 sff1_x4
xsubckt_8456_sff1_x4 1 2057 0 9901 1949 sff1_x4
xsubckt_8813_sff1_x4 1 2083 0 9609 712 sff1_x4
xsubckt_8891_sff1_x4 1 2050 0 9534 344 sff1_x4
xcmpt_abc_30082_new_n5625_hfns_2 1 0 6036 6033 buf_x4
xcmpt_abc_30082_new_n5625_hfns_1 1 0 6033 6034 buf_x4
xcmpt_abc_30082_new_n5625_hfns_0 1 0 6033 6035 buf_x4
xsubckt_942_o2_x2 0 7410 1 757 82 o2_x2
xsubckt_2616_nand2_x0 1 0 5738 5739 5742 nand2_x0
xsubckt_3612_oa22_x2 0 4759 1 4760 4761 776 oa22_x2
xsubckt_5474_a3_x2 1 9798 0 3447 3448 46 a3_x2
xsubckt_5728_a3_x2 1 3274 0 6002 46 8399 a3_x2
xsubckt_5813_mx3_x2 1 0 9709 7933 7840 467 3195 767 mx3_x2
xsubckt_5815_mx3_x2 1 0 9707 7933 7840 445 6355 745 mx3_x2
xsubckt_6171_mx2_x2 0 2845 1 8214 2846 2849 mx2_x2
xsubckt_6173_mx2_x2 0 2843 1 8207 2844 2859 mx2_x2
xsubckt_6219_mx2_x2 0 2799 1 863 1787 1755 mx2_x2
xsubckt_6562_mx2_x2 0 2465 1 863 1585 1553 mx2_x2
xsubckt_6564_mx2_x2 0 2463 1 863 1489 1457 mx2_x2
xsubckt_6566_mx2_x2 0 2461 1 8222 2462 2463 mx2_x2
xsubckt_6832_a3_x2 1 8837 0 9417 8843 9416 a3_x2
xsubckt_7913_sff1_x4 1 2172 0 10439 1797 sff1_x4
xsubckt_8364_sff1_x4 1 2193 0 9993 1478 sff1_x4
xsubckt_8887_sff1_x4 1 2070 0 9538 348 sff1_x4
xsubckt_9264_sff1_x4 1 2238 0 9176 1428 sff1_x4
xcmpt_abc_30082_new_n5583_hfns_2 1 0 6090 6087 buf_x4
xcmpt_abc_30082_new_n5583_hfns_1 1 0 6087 6088 buf_x4
xcmpt_abc_30082_new_n5583_hfns_0 1 0 6087 6089 buf_x4
xsubckt_2401_o3_x2 0 5952 1 716 715 714 o3_x2
xsubckt_1783_nor3_x0 1 0 6600 6601 6607 6608 nor3_x0
xsubckt_608_oa22_x2 0 7731 1 7806 7939 8234 oa22_x2
xsubckt_3318_nand2_x0 1 0 5048 6007 8092 nand2_x0
xsubckt_4673_a2_x2 0 4118 1 1921 1916 a2_x2
xsubckt_4717_nand3_x0 1 0 4084 4085 4091 4143 nand3_x0
xsubckt_5070_nand3_x0 1 0 3812 3813 3814 653 nand3_x0
xsubckt_5582_a2_x2 0 9764 1 3373 3374 a2_x2
xsubckt_6179_mx2_x2 0 2838 1 862 924 892 mx2_x2
xsubckt_6568_mx2_x2 0 2459 1 826 2460 2467 mx2_x2
xsubckt_7987_sff1_x4 1 2232 0 10370 1789 sff1_x4
xsubckt_8721_sff1_x4 1 2153 0 2297 2265 sff1_x4
xsubckt_8809_sff1_x4 1 2063 0 9613 716 sff1_x4
xcmpt_abc_30082_new_n5589_hfns_2 1 0 6082 6079 buf_x4
xcmpt_abc_30082_new_n5589_hfns_1 1 0 6079 6080 buf_x4
xcmpt_abc_30082_new_n5589_hfns_0 1 0 6079 6081 buf_x4
xcmpt_abc_30082_new_n4705_hfns_2 1 0 6949 6946 buf_x4
xcmpt_abc_30082_new_n4705_hfns_1 1 0 6946 6947 buf_x4
xcmpt_abc_30082_new_n4705_hfns_0 1 0 6946 6948 buf_x4
xcmpt_abc_30082_new_n4707_hfns_2 1 0 6944 6941 buf_x4
xcmpt_abc_30082_new_n4707_hfns_1 1 0 6941 6942 buf_x4
xcmpt_abc_30082_new_n4707_hfns_0 1 0 6941 6943 buf_x4
xsubckt_3138_nand2_x0 1 0 5225 6008 8097 nand2_x0
xsubckt_3807_ao22_x2 0 4568 1 4626 4621 4623 ao22_x2
xsubckt_5316_oa22_x2 0 3584 1 3889 3892 8268 oa22_x2
xsubckt_5509_nand3_x0 1 0 3423 3427 2025 2026 nand3_x0
xsubckt_5779_mx3_x2 1 0 9710 7933 7840 468 3227 768 mx3_x2
xsubckt_6960_a2_x2 0 9641 1 8739 55 a2_x2
xsubckt_7909_sff1_x4 1 2100 0 10443 1801 sff1_x4
xsubckt_8272_sff1_x4 1 2198 0 10085 1312 sff1_x4
xsubckt_8795_sff1_x4 1 2079 0 9627 724 sff1_x4
xsubckt_9172_sff1_x4 1 2129 0 9268 1392 sff1_x4
xsubckt_2256_nand2_x0 1 0 6138 6147 83 nand2_x0
xsubckt_1808_oa22_x2 0 6577 1 6599 6587 6578 oa22_x2
xsubckt_1620_o2_x2 0 6752 1 6753 6939 o2_x2
xsubckt_1562_ao22_x2 0 6806 1 6809 6810 218 ao22_x2
xsubckt_373_nor4_x0 1 0 7975 644 662 622 621 nor4_x0
xsubckt_3301_nand2_x0 1 0 5065 5066 8022 nand2_x0
xsubckt_5081_o2_x2 0 3802 1 3803 3805 o2_x2
xsubckt_5329_nand3_x0 1 0 3572 50 139 8397 nand3_x0
xsubckt_5335_o2_x2 0 3566 1 3567 7881 o2_x2
xsubckt_5991_mx2_x2 0 3020 1 8213 3021 3024 mx2_x2
xsubckt_5993_mx2_x2 0 3018 1 8207 3019 3034 mx2_x2
xsubckt_8717_sff1_x4 1 2053 0 9673 558 sff1_x4
xsubckt_9080_sff1_x4 1 2063 0 10462 1908 sff1_x4
xsubckt_9168_sff1_x4 1 2238 0 9272 1396 sff1_x4
xcmpt_decoder_pseudo_trigger_hfns_2 1 0 708 705 buf_x4
xcmpt_decoder_pseudo_trigger_hfns_1 1 0 705 706 buf_x4
xcmpt_decoder_pseudo_trigger_hfns_0 1 0 705 707 buf_x4
xsubckt_382_a4_x2 0 7963 1 7964 7965 7968 7975 a4_x2
xsubckt_369_nor4_x0 1 0 7979 640 661 656 658 nor4_x0
xsubckt_947_oa22_x2 0 7405 1 420 7809 7618 oa22_x2
xsubckt_1106_nand2_x0 1 0 7254 633 1957 nand2_x0
xsubckt_4335_mx2_x2 0 10224 1 4191 6282 1475 mx2_x2
xsubckt_5224_oa22_x2 0 3669 1 3671 3674 8294 oa22_x2
xsubckt_5395_o2_x2 0 3510 1 3511 7881 o2_x2
xsubckt_5999_mx2_x2 0 3013 1 839 929 897 mx2_x2
xsubckt_6923_nor2_x0 1 0 8768 380 379 nor2_x0
xsubckt_7297_ao22_x2 0 8542 1 8606 8686 375 ao22_x2
xsubckt_8180_sff1_x4 1 2209 0 10177 1724 sff1_x4
xsubckt_8268_sff1_x4 1 2198 0 10089 1286 sff1_x4
xsubckt_9002_sff1_x4 1 2112 0 9423 1546 sff1_x4
xcmpt_abc_30082_new_n3741_hfns_2 1 0 7882 7879 buf_x4
xcmpt_abc_30082_new_n3741_hfns_1 1 0 7879 7880 buf_x4
xcmpt_abc_30082_new_n3741_hfns_0 1 0 7879 7881 buf_x4
xsubckt_2415_nand3_x0 1 0 5936 568 8290 92 nand3_x0
xsubckt_1716_oa22_x2 0 6663 1 6687 6671 6672 oa22_x2
xsubckt_853_nand2_x0 1 0 7494 634 1971 nand2_x0
xsubckt_1016_nand2_x0 1 0 172 7340 7352 nand2_x0
xsubckt_2970_nor2_x0 1 0 5391 246 765 nor2_x0
xsubckt_3121_nand2_x0 1 0 5242 5243 8021 nand2_x0
xsubckt_3411_mx2_x2 0 4957 1 805 1849 1817 mx2_x2
xsubckt_4003_nand2_x0 1 0 4375 4376 8021 nand2_x0
xsubckt_4291_mx2_x2 0 10261 1 4204 6054 1167 mx2_x2
xsubckt_4293_mx2_x2 0 10259 1 4204 6034 1165 mx2_x2
xsubckt_4337_mx2_x2 0 10222 1 4190 6272 1463 mx2_x2
xsubckt_4339_mx2_x2 0 10220 1 4190 6259 1449 mx2_x2
xsubckt_4794_nxr2_x1 4025 1 0 4027 8335 nxr2_x1
xsubckt_6032_oa22_x2 0 2980 1 3190 2983 2981 oa22_x2
xsubckt_7131_ao22_x2 0 8646 1 8647 8649 3286 ao22_x2
xsubckt_8102_sff1_x4 1 2126 0 10255 1250 sff1_x4
xsubckt_8625_sff1_x4 1 2159 0 183 120 sff1_x4
xsubckt_9076_sff1_x4 1 2063 0 10466 1912 sff1_x4
xcmpt_abc_30082_new_n8979_hfns_2 1 0 3284 3281 buf_x4
xcmpt_abc_30082_new_n8979_hfns_1 1 0 3281 3282 buf_x4
xcmpt_abc_30082_new_n8979_hfns_0 1 0 3281 3283 buf_x4
xsubckt_1466_ao22_x2 0 6896 1 6899 6901 226 ao22_x2
xsubckt_2559_nxr2_x1 5794 1 0 226 745 nxr2_x1
xsubckt_2946_nand2_x0 1 0 5414 5415 783 nand2_x0
xsubckt_3031_nand2_x0 1 0 5331 245 764 nand2_x0
xsubckt_3415_mx2_x2 0 4953 1 805 1433 1401 mx2_x2
xsubckt_3738_nand2_x0 1 0 4635 6008 8078 nand2_x0
xsubckt_3760_mx2_x2 0 4614 1 788 4615 4616 mx2_x2
xsubckt_4087_nand3_x0 1 0 4292 4302 4306 770 nand3_x0
xsubckt_4295_mx2_x2 0 10257 1 4203 6018 1162 mx2_x2
xsubckt_4299_mx2_x2 0 10255 1 4199 6278 1250 mx2_x2
xsubckt_4784_nand4_x0 1 0 4033 4035 4042 4054 4065 nand4_x0
xsubckt_6912_oa22_x2 0 8775 1 8819 8785 8776 oa22_x2
xsubckt_8176_sff1_x4 1 2169 0 10181 1728 sff1_x4
xsubckt_8699_sff1_x4 1 2172 0 9691 205 sff1_x4
xsubckt_9433_sff1_x4 1 2116 0 9010 910 sff1_x4
xsubckt_2100_mx2_x2 0 6347 1 838 1353 1321 mx2_x2
xsubckt_1659_nxr2_x1 6716 1 0 6718 208 nxr2_x1
xsubckt_1571_nxr2_x1 6798 1 0 6800 214 nxr2_x1
xsubckt_220_inv_x0 1 0 104 8156 inv_x0
xsubckt_812_a2_x2 0 7533 1 7991 2037 a2_x2
xsubckt_832_a2_x2 0 7514 1 7990 2036 a2_x2
xsubckt_1101_oa22_x2 0 7259 1 7614 7478 7260 oa22_x2
xsubckt_3419_mx2_x2 0 4949 1 804 1593 1561 mx2_x2
xsubckt_3558_nand2_x0 1 0 4812 6008 8084 nand2_x0
xsubckt_3762_mx2_x2 0 4612 1 804 1874 1522 mx2_x2
xsubckt_3764_mx2_x2 0 4610 1 8030 4611 4612 mx2_x2
xsubckt_3766_mx2_x2 0 4608 1 804 1714 1682 mx2_x2
xsubckt_3855_oa22_x2 0 4520 1 4521 4522 8016 oa22_x2
xsubckt_5128_oa22_x2 0 3758 1 3759 3769 7881 oa22_x2
xsubckt_5486_nand4_x0 1 0 3438 3446 2034 2035 2036 nand4_x0
xsubckt_7461_mx3_x2 1 0 9348 8487 6288 897 6206 6210 mx3_x2
xsubckt_7721_mx2_x2 0 9103 1 8448 6018 1002 mx2_x2
xsubckt_8010_sff1_x4 1 2251 0 10347 1128 sff1_x4
xsubckt_8533_sff1_x4 1 2176 0 9824 147 sff1_x4
xsubckt_9429_sff1_x4 1 2214 0 9014 914 sff1_x4
xsubckt_2106_mx2_x2 0 6341 1 864 1417 1385 mx2_x2
xsubckt_2104_mx2_x2 0 6343 1 8225 6344 6345 mx2_x2
xsubckt_2102_mx2_x2 0 6345 1 864 1225 1193 mx2_x2
xsubckt_390_o4_x2 0 7955 1 624 618 657 665 o4_x2
xsubckt_226_inv_x0 1 0 100 8150 inv_x0
xsubckt_224_inv_x0 1 0 102 8152 inv_x0
xsubckt_222_inv_x0 1 0 103 8154 inv_x0
xsubckt_852_a2_x2 0 7495 1 7991 2035 a2_x2
xsubckt_2676_nand2_x0 1 0 5680 221 740 nand2_x0
xsubckt_3721_nand2_x0 1 0 4652 4653 8025 nand2_x0
xsubckt_3768_mx2_x2 0 4606 1 789 4607 4608 mx2_x2
xsubckt_5598_nxr2_x1 3361 1 0 3365 8096 nxr2_x1
xsubckt_7247_nand2_x0 1 0 8582 7976 386 nand2_x0
xsubckt_7278_nor2_x0 1 0 8557 8558 8559 nor2_x0
xsubckt_7336_mx2_x2 0 9489 1 8832 8511 745 mx2_x2
xsubckt_7337_nand2_x0 1 0 8510 8686 384 nand2_x0
xsubckt_7725_mx2_x2 0 9101 1 8444 6278 994 mx2_x2
xsubckt_7727_mx2_x2 0 9099 1 8444 6266 972 mx2_x2
xsubckt_7729_mx2_x2 0 9097 1 8444 6252 968 mx2_x2
xsubckt_8006_sff1_x4 1 2126 0 10351 1154 sff1_x4
xsubckt_8084_sff1_x4 1 2212 0 10273 1180 sff1_x4
xsubckt_8441_sff1_x4 1 2047 0 9916 1966 sff1_x4
xsubckt_8529_sff1_x4 1 2159 0 9828 151 sff1_x4
xsubckt_8964_sff1_x4 1 2116 0 9461 1585 sff1_x4
xsubckt_9341_sff1_x4 1 2103 0 9102 995 sff1_x4
xspare_feed_109 1 0 decap_w0
xspare_feed_108 1 0 decap_w0
xspare_feed_107 1 0 decap_w0
xspare_feed_106 1 0 decap_w0
xspare_feed_105 1 0 decap_w0
xspare_feed_104 1 0 decap_w0
xspare_feed_103 1 0 decap_w0
xspare_feed_102 1 0 decap_w0
xspare_feed_101 1 0 decap_w0
xspare_feed_100 1 0 decap_w0
xsubckt_2311_a3_x2 1 6067 0 6068 541 8409 a3_x2
xsubckt_2193_mx3_x2 1 0 10440 6302 6289 1798 6236 6240 mx3_x2
xsubckt_2108_mx2_x2 0 6339 1 836 6340 6341 mx2_x2
xsubckt_2062_mx2_x2 0 6384 1 836 6385 6386 mx2_x2
xsubckt_2060_mx2_x2 0 6386 1 864 1292 1260 mx2_x2
xsubckt_228_inv_x0 1 0 99 8148 inv_x0
xsubckt_180_inv_x0 1 0 95 8196 inv_x0
xsubckt_182_inv_x0 1 0 94 8194 inv_x0
xsubckt_184_inv_x0 1 0 93 8192 inv_x0
xsubckt_2496_nand2_x0 1 0 5856 5858 772 nand2_x0
xsubckt_3328_oa22_x2 0 5039 1 5097 5094 5096 oa22_x2
xsubckt_3378_nand2_x0 1 0 4989 6008 8091 nand2_x0
xsubckt_3631_nand2_x0 1 0 4741 234 753 nand2_x0
xsubckt_4156_nand4_x0 1 0 4225 6304 6306 6312 551 nand4_x0
xsubckt_6410_mx2_x2 0 2613 1 864 1365 1333 mx2_x2
xsubckt_6412_mx2_x2 0 2611 1 8225 2612 2613 mx2_x2
xsubckt_6570_ao22_x2 0 2457 1 573 568 750 ao22_x2
xsubckt_7290_mx2_x2 0 9498 1 8831 8548 764 mx2_x2
xsubckt_7681_mx2_x2 0 9141 1 8454 6070 1041 mx2_x2
xsubckt_7683_mx2_x2 0 9139 1 8454 6054 1039 mx2_x2
xsubckt_7685_mx2_x2 0 9137 1 8454 6034 1037 mx2_x2
xsubckt_9337_sff1_x4 1 2136 0 9103 1002 sff1_x4
xsubckt_2068_mx2_x2 0 6378 1 841 1484 1452 mx2_x2
xsubckt_2066_mx2_x2 0 6380 1 8215 6381 6384 mx2_x2
xsubckt_2064_mx2_x2 0 6382 1 842 1132 1100 mx2_x2
xsubckt_1440_oa22_x2 0 6920 1 6923 6924 217 oa22_x2
xsubckt_186_inv_x0 1 0 122 8190 inv_x0
xsubckt_188_inv_x0 1 0 121 8188 inv_x0
xsubckt_3198_nand2_x0 1 0 5166 6007 8095 nand2_x0
xsubckt_3541_nand2_x0 1 0 4829 4830 8024 nand2_x0
xsubckt_4824_a4_x2 0 4003 1 1942 1941 1940 1939 a4_x2
xsubckt_5606_a3_x2 1 3356 0 3360 1992 1993 a3_x2
xsubckt_6021_mx2_x2 0 2991 1 840 1665 1633 mx2_x2
xsubckt_6023_mx2_x2 0 2989 1 8226 2990 2991 mx2_x2
xsubckt_6025_mx2_x2 0 2987 1 843 1441 1409 mx2_x2
xsubckt_6414_mx2_x2 0 2609 1 843 1141 1109 mx2_x2
xsubckt_6416_mx2_x2 0 2607 1 8214 2608 2611 mx2_x2
xsubckt_7296_mx2_x2 0 9497 1 8832 8543 765 mx2_x2
xsubckt_7687_mx2_x2 0 9135 1 8453 6018 1034 mx2_x2
xsubckt_8437_sff1_x4 1 2047 0 9920 1970 sff1_x4
xsubckt_8872_sff1_x4 1 2070 0 9553 334 sff1_x4
xspare_feed_119 1 0 decap_w0
xspare_feed_118 1 0 decap_w0
xspare_feed_117 1 0 decap_w0
xspare_feed_116 1 0 decap_w0
xspare_feed_115 1 0 decap_w0
xspare_feed_114 1 0 decap_w0
xspare_feed_113 1 0 decap_w0
xspare_feed_112 1 0 decap_w0
xspare_feed_111 1 0 decap_w0
xspare_feed_110 1 0 decap_w0
xsubckt_2336_oa22_x2 0 6036 1 6037 6038 6040 oa22_x2
xsubckt_1510_a2_x2 0 6855 1 6856 221 a2_x2
xsubckt_1242_nand4_x0 1 0 7123 7125 7129 7134 7138 nand4_x0
xsubckt_915_nand2_x0 1 0 7435 1997 638 nand2_x0
xsubckt_2745_nand3_x0 1 0 5612 569 8290 64 nand3_x0
xsubckt_3361_nand2_x0 1 0 5006 5007 8022 nand2_x0
xsubckt_3622_a2_x2 0 4749 1 4750 4752 a2_x2
xsubckt_5125_nand2_x0 1 0 3761 3763 3765 nand2_x0
xsubckt_5440_a2_x2 0 9809 1 8142 45 a2_x2
xsubckt_6027_mx2_x2 0 2985 1 8213 2986 2989 mx2_x2
xsubckt_6029_mx2_x2 0 2983 1 8207 2984 2999 mx2_x2
xsubckt_6370_mx2_x2 0 2652 1 841 1046 1014 mx2_x2
xsubckt_6372_mx2_x2 0 2650 1 8213 2651 2654 mx2_x2
xsubckt_6374_mx2_x2 0 2648 1 841 1366 1334 mx2_x2
xsubckt_6418_mx2_x2 0 2605 1 841 1589 1557 mx2_x2
xsubckt_6761_mx2_x2 0 8893 1 8215 8894 8897 mx2_x2
xsubckt_6763_mx2_x2 0 8891 1 841 1162 1066 mx2_x2
xsubckt_6765_mx2_x2 0 8889 1 841 970 938 mx2_x2
xsubckt_6829_a3_x2 1 8839 0 8842 9418 8844 a3_x2
xsubckt_7972_sff1_x4 1 2092 0 10385 225 sff1_x4
xsubckt_9245_sff1_x4 1 2098 0 9195 1420 sff1_x4
xsubckt_1375_a2_x2 0 6990 1 6991 6992 a2_x2
xsubckt_825_nand2_x0 1 0 7521 7522 7525 nand2_x0
xsubckt_866_ao22_x2 0 7482 1 7484 7487 1902 ao22_x2
xsubckt_1166_nand2_x0 1 0 7197 7198 7206 nand2_x0
xsubckt_3271_nand2_x0 1 0 5095 241 760 nand2_x0
xsubckt_3978_nand2_x0 1 0 4399 6007 8068 nand2_x0
xsubckt_4805_a2_x2 0 4018 1 1945 1944 a2_x2
xsubckt_5308_nor2_x0 1 0 3591 3592 7881 nor2_x0
xsubckt_5841_mx2_x2 0 3166 1 844 1640 1608 mx2_x2
xsubckt_6376_mx2_x2 0 2646 1 8219 2647 2648 mx2_x2
xsubckt_6378_mx2_x2 0 2644 1 844 1142 1110 mx2_x2
xsubckt_6767_mx2_x2 0 8887 1 832 8888 8889 mx2_x2
xsubckt_6769_mx2_x2 0 8885 1 828 8886 8893 mx2_x2
xsubckt_6798_oa22_x2 0 8858 1 8422 1912 8305 oa22_x2
xsubckt_7968_sff1_x4 1 2092 0 10389 230 sff1_x4
xsubckt_8345_sff1_x4 1 2214 0 10012 1334 sff1_x4
xsubckt_8780_sff1_x4 1 2070 0 9642 620 sff1_x4
xsubckt_8868_sff1_x4 1 2150 0 9557 340 sff1_x4
xspare_feed_129 1 0 decap_w0
xspare_feed_128 1 0 decap_w0
xspare_feed_127 1 0 decap_w0
xspare_feed_126 1 0 decap_w0
xspare_feed_125 1 0 decap_w0
xspare_feed_124 1 0 decap_w0
xspare_feed_123 1 0 decap_w0
xspare_feed_122 1 0 decap_w0
xspare_feed_121 1 0 decap_w0
xspare_feed_120 1 0 decap_w0
xsubckt_1844_a2_x2 0 6543 1 6544 8416 a2_x2
xsubckt_735_nand2_x0 1 0 7606 2006 638 nand2_x0
xsubckt_2828_nand2_x0 1 0 5530 5531 779 nand2_x0
xsubckt_3181_nand2_x0 1 0 5183 5184 8021 nand2_x0
xsubckt_3610_nand3_x0 1 0 4761 4786 4790 8013 nand3_x0
xsubckt_3682_a2_x2 0 4690 1 4691 4693 a2_x2
xsubckt_3888_nand2_x0 1 0 4488 4489 779 nand2_x0
xsubckt_4149_nand3_x0 1 0 4231 4232 4399 7857 nand3_x0
xsubckt_5599_a2_x2 0 9759 1 3361 43 a2_x2
xsubckt_5843_mx2_x2 0 3164 1 8219 3165 3166 mx2_x2
xsubckt_5845_mx2_x2 0 3162 1 844 1416 1384 mx2_x2
xsubckt_5847_mx2_x2 0 3160 1 8212 3161 3164 mx2_x2
xsubckt_6919_ao22_x2 0 9650 1 8771 8772 43 ao22_x2
xsubckt_7757_nand2_x0 1 0 8440 8457 4182 nand2_x0
xsubckt_8702_sff1_x4 1 2166 0 9688 202 sff1_x4
xsubckt_9153_sff1_x4 1 2194 0 9287 1382 sff1_x4
xsubckt_2191_nxr2_x1 6237 1 0 6249 8361 nxr2_x1
xsubckt_1724_o3_x2 0 6655 1 6656 6657 6939 o3_x2
xsubckt_2506_o2_x2 0 5846 1 237 756 o2_x2
xsubckt_3430_nand3_x0 1 0 4938 4963 4967 8011 nand3_x0
xsubckt_3798_nand2_x0 1 0 4576 6008 8075 nand2_x0
xsubckt_4530_mx2_x2 0 10043 1 4162 6108 1653 mx2_x2
xsubckt_4576_nand4_x0 1 0 4153 4196 6306 6312 551 nand4_x0
xsubckt_4832_oa22_x2 0 3997 1 3998 4002 1936 oa22_x2
xsubckt_5849_mx2_x2 0 3158 1 8207 3159 3174 mx2_x2
xsubckt_7204_ao22_x2 0 8613 1 7859 61 1897 ao22_x2
xsubckt_8253_sff1_x4 1 2142 0 10104 1682 sff1_x4
xsubckt_8776_sff1_x4 1 2070 0 9646 666 sff1_x4
xspare_feed_139 1 0 decap_w0
xspare_feed_138 1 0 decap_w0
xspare_feed_137 1 0 decap_w0
xspare_feed_136 1 0 decap_w0
xspare_feed_135 1 0 decap_w0
xspare_feed_134 1 0 decap_w0
xspare_feed_133 1 0 decap_w0
xspare_feed_132 1 0 decap_w0
xspare_feed_131 1 0 decap_w0
xspare_feed_130 1 0 decap_w0
xsubckt_1736_nxr2_x1 6644 1 0 6648 8091 nxr2_x1
xsubckt_3961_nand2_x0 1 0 4416 4417 8020 nand2_x0
xsubckt_4272_mx3_x2 1 0 10280 4206 6293 1157 6226 6229 mx3_x2
xsubckt_4274_mx3_x2 1 0 10278 4206 6293 1185 6205 6210 mx3_x2
xsubckt_4532_mx2_x2 0 10041 1 4162 6089 1651 mx2_x2
xsubckt_4534_mx2_x2 0 10039 1 4162 6071 1649 mx2_x2
xsubckt_4536_mx2_x2 0 10037 1 4161 6053 1647 mx2_x2
xsubckt_5621_nand4_x0 1 0 3345 3353 1988 1989 1990 nand4_x0
xsubckt_6982_nor2_x0 1 0 8722 384 383 nor2_x0
xsubckt_8249_sff1_x4 1 2205 0 10108 1686 sff1_x4
xsubckt_8610_sff1_x4 1 2050 0 9747 1982 sff1_x4
xsubckt_8684_sff1_x4 1 2086 0 9706 442 sff1_x4
xsubckt_9061_sff1_x4 1 2217 0 9369 1365 sff1_x4
xsubckt_9149_sff1_x4 1 2099 0 9291 1388 sff1_x4
xsubckt_840_oa22_x2 0 182 1 7521 7520 7507 oa22_x2
xsubckt_928_oa22_x2 0 7423 1 421 7809 7618 oa22_x2
xsubckt_3250_nand3_x0 1 0 5115 5140 5144 8011 nand3_x0
xsubckt_3690_o2_x2 0 4683 1 233 752 o2_x2
xsubckt_3781_nand2_x0 1 0 4593 4594 8020 nand2_x0
xsubckt_3871_nand2_x0 1 0 4505 230 749 nand2_x0
xsubckt_3924_o2_x2 0 4452 1 4453 5995 o2_x2
xsubckt_4490_mx2_x2 0 10080 1 4167 6152 1307 mx2_x2
xsubckt_4492_mx2_x2 0 10078 1 4167 6135 1305 mx2_x2
xsubckt_4538_mx2_x2 0 10035 1 4162 6035 1645 mx2_x2
xsubckt_5152_nxr2_x1 3736 1 0 3922 712 nxr2_x1
xsubckt_5191_oa22_x2 0 3700 1 3712 3710 3711 oa22_x2
xsubckt_6536_oa22_x2 0 2490 1 3190 2493 2491 oa22_x2
xsubckt_7700_mx3_x2 1 0 9124 8451 6293 1025 6205 6209 mx3_x2
xsubckt_8161_sff1_x4 1 2112 0 10196 1454 sff1_x4
xsubckt_8606_sff1_x4 1 2044 0 9751 1987 sff1_x4
xsubckt_9057_sff1_x4 1 2248 0 9373 1370 sff1_x4
xspare_feed_149 1 0 decap_w0
xspare_feed_148 1 0 decap_w0
xspare_feed_147 1 0 decap_w0
xspare_feed_146 1 0 decap_w0
xspare_feed_145 1 0 decap_w0
xspare_feed_144 1 0 decap_w0
xspare_feed_143 1 0 decap_w0
xspare_feed_142 1 0 decap_w0
xspare_feed_141 1 0 decap_w0
xspare_feed_140 1 0 decap_w0
xsubckt_1644_nxr2_x1 6730 1 0 6732 209 nxr2_x1
xsubckt_487_a3_x2 1 7847 0 7848 7854 7867 a3_x2
xsubckt_3070_nand3_x0 1 0 5292 5317 5321 8013 nand3_x0
xsubckt_3223_mx2_x2 0 5142 1 813 1180 1084 mx2_x2
xsubckt_3928_oa22_x2 0 4449 1 4507 4504 4506 oa22_x2
xsubckt_4494_mx2_x2 0 10076 1 4168 6116 1302 mx2_x2
xsubckt_4496_mx2_x2 0 10074 1 4168 6098 1300 mx2_x2
xsubckt_4498_mx2_x2 0 10072 1 4168 6080 1298 mx2_x2
xsubckt_5365_nand2_x0 1 0 3538 3546 3551 nand2_x0
xsubckt_7186_ao22_x2 0 8624 1 3285 3288 322 ao22_x2
xsubckt_8157_sff1_x4 1 2218 0 10200 1458 sff1_x4
xsubckt_8592_sff1_x4 1 2057 0 9765 2002 sff1_x4
xsubckt_9414_sff1_x4 1 2229 0 9029 900 sff1_x4
xsubckt_9492_sff1_x4 1 2142 0 8951 1843 sff1_x4
xcmpt_abc_30082_new_n7518_hfns_2 1 0 4210 4207 buf_x4
xcmpt_abc_30082_new_n7518_hfns_1 1 0 4207 4208 buf_x4
xcmpt_abc_30082_new_n7518_hfns_0 1 0 4207 4209 buf_x4
xsubckt_936_a3_x2 1 7415 0 7416 7417 7418 a3_x2
xsubckt_2895_nand3_x0 1 0 5464 5484 5488 8013 nand3_x0
xsubckt_3227_mx2_x2 0 5138 1 814 1788 1756 mx2_x2
xsubckt_3963_mx2_x2 0 4414 1 814 1135 1103 mx2_x2
xsubckt_5275_nand2_x0 1 0 3622 3623 8294 nand2_x0
xsubckt_7263_nor2_x0 1 0 8569 8570 8571 nor2_x0
xsubckt_8514_sff1_x4 1 2153 0 9843 71 sff1_x4
xsubckt_9488_sff1_x4 1 2224 0 8955 1848 sff1_x4
xcmpt_abc_30082_new_n7865_hfns_2 1 0 4153 4150 buf_x4
xcmpt_abc_30082_new_n7865_hfns_1 1 0 4150 4151 buf_x4
xcmpt_abc_30082_new_n7865_hfns_0 1 0 4150 4152 buf_x4
xspare_feed_159 1 0 decap_w0
xspare_feed_158 1 0 decap_w0
xspare_feed_157 1 0 decap_w0
xspare_feed_156 1 0 decap_w0
xspare_feed_155 1 0 decap_w0
xspare_feed_154 1 0 decap_w0
xspare_feed_153 1 0 decap_w0
xspare_feed_152 1 0 decap_w0
xspare_feed_151 1 0 decap_w0
xspare_feed_150 1 0 decap_w0
xsubckt_2413_oa22_x2 0 5937 1 5961 5946 5938 oa22_x2
xsubckt_2301_mx2_x2 0 10423 1 6300 6080 1810 mx2_x2
xsubckt_1138_nand2_x0 1 0 7224 7225 1894 nand2_x0
xsubckt_3183_mx2_x2 0 5181 1 815 1149 1117 mx2_x2
xsubckt_3187_mx2_x2 0 5177 1 815 1309 1277 mx2_x2
xsubckt_3578_mx2_x2 0 4793 1 815 981 949 mx2_x2
xsubckt_3850_nand3_x0 1 0 4525 4550 4554 8013 nand3_x0
xsubckt_3967_mx2_x2 0 4410 1 814 1295 1263 mx2_x2
xsubckt_4818_nand4_x0 1 0 4007 4017 1942 1941 1940 nand4_x0
xsubckt_7140_mx2_x2 0 9555 1 8645 336 441 mx2_x2
xsubckt_7142_mx2_x2 0 9553 1 8645 334 439 mx2_x2
xsubckt_7144_mx2_x2 0 9551 1 8643 437 332 mx2_x2
xsubckt_7531_mx2_x2 0 9282 1 8475 6189 1407 mx2_x2
xsubckt_7533_mx2_x2 0 9280 1 8475 6170 1405 mx2_x2
xsubckt_7535_mx2_x2 0 9278 1 8475 6152 1403 mx2_x2
xsubckt_7664_mx3_x2 1 0 9158 8456 6294 1029 6225 6229 mx3_x2
xsubckt_7666_mx3_x2 1 0 9156 8456 6294 1057 6205 6210 mx3_x2
xsubckt_8065_sff1_x4 1 2108 0 10292 1742 sff1_x4
xsubckt_8588_sff1_x4 1 2060 0 9769 2006 sff1_x4
xsubckt_9322_sff1_x4 1 2203 0 9118 1019 sff1_x4
xfeed_209 1 0 tie
xfeed_208 1 0 tie
xfeed_207 1 0 tie
xfeed_206 1 0 tie
xfeed_205 1 0 decap_w0
xfeed_204 1 0 decap_w0
xfeed_203 1 0 decap_w0
xfeed_202 1 0 decap_w0
xfeed_201 1 0 decap_w0
xfeed_200 1 0 decap_w0
xsubckt_2309_mx2_x2 0 10422 1 6299 6070 1809 mx2_x2
xsubckt_1701_a4_x2 0 6677 1 6720 8039 8040 8041 a4_x2
xsubckt_1048_nand2_x0 1 0 7309 1989 637 nand2_x0
xsubckt_2650_mx2_x2 0 5705 1 816 1352 1320 mx2_x2
xsubckt_2652_mx2_x2 0 5703 1 784 5704 5707 mx2_x2
xsubckt_2654_mx2_x2 0 5701 1 816 1640 1608 mx2_x2
xsubckt_4507_a4_x2 0 4164 1 4165 6305 6312 7884 a4_x2
xsubckt_4679_nxr2_x1 4113 1 0 4115 8313 nxr2_x1
xsubckt_5456_a4_x2 0 3459 1 3465 1985 1996 2007 a4_x2
xsubckt_6611_mx2_x2 0 2418 1 866 911 879 mx2_x2
xsubckt_7127_a3_x2 1 8649 0 7922 366 8306 a3_x2
xsubckt_7146_mx2_x2 0 9549 1 8643 465 360 mx2_x2
xsubckt_7148_mx2_x2 0 9547 1 8643 463 358 mx2_x2
xsubckt_7491_mx2_x2 0 9320 1 8480 6245 1095 mx2_x2
xsubckt_7537_mx2_x2 0 9276 1 8474 6135 1401 mx2_x2
xsubckt_7539_mx2_x2 0 9274 1 8475 6116 1398 mx2_x2
xsubckt_8422_sff1_x4 1 2057 0 9935 1977 sff1_x4
xsubckt_8945_sff1_x4 1 2218 0 9480 1575 sff1_x4
xsubckt_9396_sff1_x4 1 2142 0 9047 947 sff1_x4
xspare_feed_169 1 0 decap_w0
xspare_feed_168 1 0 decap_w0
xspare_feed_167 1 0 decap_w0
xspare_feed_166 1 0 decap_w0
xspare_feed_165 1 0 decap_w0
xspare_feed_164 1 0 decap_w0
xspare_feed_163 1 0 decap_w0
xspare_feed_162 1 0 decap_w0
xspare_feed_161 1 0 decap_w0
xspare_feed_160 1 0 decap_w0
xsubckt_2321_oa22_x2 0 6055 1 6056 6057 6058 oa22_x2
xsubckt_2267_mx2_x2 0 10428 1 6300 6125 1816 mx2_x2
xsubckt_1918_nand2_x0 1 0 6479 213 328 nand2_x0
xsubckt_527_nand2_x0 1 0 7813 7835 7928 nand2_x0
xsubckt_368_o2_x2 0 7980 1 640 661 o2_x2
xsubckt_617_nand2_x0 1 0 7722 7991 2018 nand2_x0
xsubckt_795_nand2_x0 1 0 7549 2003 638 nand2_x0
xsubckt_1121_nand2_x0 1 0 7240 228 1898 nand2_x0
xsubckt_1145_a3_x2 1 7217 0 7218 7219 7220 a3_x2
xsubckt_2656_mx2_x2 0 5699 1 819 1480 1448 mx2_x2
xsubckt_2658_mx2_x2 0 5697 1 8029 5698 5699 mx2_x2
xsubckt_3508_ao22_x2 0 4862 1 4922 4920 4917 ao22_x2
xsubckt_3670_nand3_x0 1 0 4702 4727 4731 8011 nand3_x0
xsubckt_5017_oa22_x2 0 9841 1 7886 3861 3863 oa22_x2
xsubckt_5095_a3_x2 1 3789 0 3820 3933 3936 a3_x2
xsubckt_6220_mx2_x2 0 2798 1 834 2799 2800 mx2_x2
xsubckt_6222_mx2_x2 0 2796 1 850 1883 1531 mx2_x2
xsubckt_6224_mx2_x2 0 2794 1 8223 2795 2796 mx2_x2
xsubckt_6613_mx2_x2 0 2416 1 8223 2417 2418 mx2_x2
xsubckt_6615_mx2_x2 0 2414 1 850 1775 1743 mx2_x2
xsubckt_6617_mx2_x2 0 2412 1 8213 2413 2416 mx2_x2
xsubckt_7497_mx2_x2 0 9314 1 8480 6189 1119 mx2_x2
xsubckt_7499_mx2_x2 0 9312 1 8480 6170 1117 mx2_x2
xsubckt_8418_sff1_x4 1 2111 0 9939 1613 sff1_x4
xsubckt_8496_sff1_x4 1 2159 0 9861 90 sff1_x4
xsubckt_9230_sff1_x4 1 2204 0 9210 1078 sff1_x4
xsubckt_9318_sff1_x4 1 2242 0 9122 1023 sff1_x4
xfeed_219 1 0 decap_w0
xfeed_218 1 0 decap_w0
xfeed_217 1 0 decap_w0
xfeed_216 1 0 decap_w0
xfeed_215 1 0 tie
xfeed_214 1 0 decap_w0
xfeed_213 1 0 tie
xfeed_212 1 0 decap_w0
xfeed_211 1 0 tie
xfeed_210 1 0 decap_w0
xsubckt_1507_a2_x2 0 6858 1 6859 8416 a2_x2
xsubckt_1479_a3_x2 1 6884 0 6886 442 8416 a3_x2
xsubckt_1439_a3_x2 1 6921 0 6923 6924 217 a3_x2
xsubckt_1421_oa22_x2 0 6938 1 6939 6950 6966 oa22_x2
xsubckt_1233_a2_x2 0 7132 1 203 235 a2_x2
xsubckt_1213_a2_x2 0 7152 1 200 232 a2_x2
xsubckt_1200_xr2_x1 7165 0 1 196 228 xr2_x1
xsubckt_3091_a2_x2 0 5272 1 244 763 a2_x2
xsubckt_3490_nand3_x0 1 0 4879 4904 4908 8013 nand3_x0
xsubckt_5163_a2_x2 0 3726 1 3918 735 a2_x2
xsubckt_5321_nxr2_x1 3579 1 0 3886 8268 nxr2_x1
xsubckt_5389_a3_x2 1 3516 0 3540 3870 3873 a3_x2
xsubckt_5417_a2_x2 0 3490 1 3864 8279 a2_x2
xsubckt_5612_a2_x2 0 9755 1 3352 53 a2_x2
xsubckt_6180_mx2_x2 0 2837 1 849 1852 1820 mx2_x2
xsubckt_6182_mx2_x2 0 2835 1 849 1724 1692 mx2_x2
xsubckt_6226_mx2_x2 0 2792 1 848 1051 1019 mx2_x2
xsubckt_6228_mx2_x2 0 2790 1 8212 2791 2794 mx2_x2
xsubckt_6501_a2_x2 0 9687 1 2525 2559 a2_x2
xsubckt_6619_mx2_x2 0 2410 1 849 1167 1071 mx2_x2
xsubckt_6894_a4_x2 0 8788 1 8827 8245 564 702 a4_x2
xsubckt_7953_sff1_x4 1 2163 0 10404 246 sff1_x4
xsubckt_8330_sff1_x4 1 2245 0 10027 1320 sff1_x4
xsubckt_8853_sff1_x4 1 2123 0 9572 1520 sff1_x4
xcmpt_abc_30082_new_n5638_hfns_2 1 0 6019 6016 buf_x4
xcmpt_abc_30082_new_n5638_hfns_1 1 0 6016 6017 buf_x4
xcmpt_abc_30082_new_n5638_hfns_0 1 0 6016 6018 buf_x4
xspare_feed_176 1 0 decap_w0
xspare_feed_175 1 0 decap_w0
xspare_feed_174 1 0 decap_w0
xspare_feed_173 1 0 decap_w0
xspare_feed_172 1 0 decap_w0
xspare_feed_171 1 0 decap_w0
xspare_feed_170 1 0 decap_w0
xsubckt_1901_nand2_x0 1 0 6492 249 216 nand2_x0
xsubckt_1813_nxr2_x1 6572 1 0 6575 230 nxr2_x1
xsubckt_560_oa22_x2 0 7777 1 7801 7804 8140 oa22_x2
xsubckt_1171_ao22_x2 0 7193 1 7195 7196 1903 ao22_x2
xsubckt_2905_a2_x2 0 5454 1 5455 5460 a2_x2
xsubckt_2961_nand2_x0 1 0 5399 6011 8113 nand2_x0
xsubckt_4368_nand4_x0 1 0 4187 4221 6304 6306 551 nand4_x0
xsubckt_4747_ao22_x2 0 4061 1 4063 8324 1959 ao22_x2
xsubckt_5074_nand3_x0 1 0 3809 51 128 8397 nand3_x0
xsubckt_5360_oa22_x2 0 3542 1 3543 3564 7881 oa22_x2
xsubckt_5477_a2_x2 0 9797 1 3445 51 a2_x2
xsubckt_5632_a2_x2 0 9749 1 3338 51 a2_x2
xsubckt_6184_mx2_x2 0 2833 1 833 2834 2835 mx2_x2
xsubckt_6186_mx2_x2 0 2831 1 852 1884 1532 mx2_x2
xsubckt_6188_mx2_x2 0 2829 1 8223 2830 2831 mx2_x2
xsubckt_6575_mx2_x2 0 2453 1 852 912 880 mx2_x2
xsubckt_6577_mx2_x2 0 2451 1 8223 2452 2453 mx2_x2
xsubckt_6579_mx2_x2 0 2449 1 852 1776 1744 mx2_x2
xsubckt_7049_nor3_x0 1 0 8687 579 571 649 nor3_x0
xsubckt_7279_nand2_x0 1 0 8556 8557 8577 nand2_x0
xsubckt_8326_sff1_x4 1 2126 0 10031 1346 sff1_x4
xsubckt_8761_sff1_x4 1 2073 0 9661 646 sff1_x4
xsubckt_8849_sff1_x4 1 2209 0 9576 1524 sff1_x4
xsubckt_9226_sff1_x4 1 2203 0 9214 1083 sff1_x4
xfeed_229 1 0 decap_w0
xfeed_228 1 0 decap_w0
xfeed_227 1 0 decap_w0
xfeed_226 1 0 decap_w0
xfeed_225 1 0 decap_w0
xfeed_224 1 0 decap_w0
xfeed_223 1 0 decap_w0
xfeed_222 1 0 tie
xfeed_221 1 0 decap_w0
xfeed_220 1 0 decap_w0
xspare_feed_179 1 0 decap_w0
xspare_feed_178 1 0 decap_w0
xspare_feed_177 1 0 decap_w0
xsubckt_1206_xr2_x1 7159 0 1 197 229 xr2_x1
xsubckt_2871_nand2_x0 1 0 5488 5489 782 nand2_x0
xsubckt_2957_nand3_x0 1 0 5403 5404 5407 5950 nand3_x0
xsubckt_3874_a2_x2 0 4502 1 4504 4507 a2_x2
xsubckt_4099_oa22_x2 0 4280 1 4281 4327 5995 oa22_x2
xsubckt_4763_a2_x2 0 9906 1 4050 42 a2_x2
xsubckt_4905_oa22_x2 0 9869 1 7886 3945 3947 oa22_x2
xsubckt_5356_oa22_x2 0 3546 1 3556 3553 3549 oa22_x2
xsubckt_5651_mx2_x2 0 3322 1 817 1706 1674 mx2_x2
xsubckt_5653_mx2_x2 0 3320 1 788 3321 3322 mx2_x2
xsubckt_6835_a2_x2 0 8834 1 8835 8836 a2_x2
xsubckt_6890_ao22_x2 0 8791 1 706 8277 645 ao22_x2
xsubckt_6978_ao22_x2 0 8726 1 706 8277 640 ao22_x2
xsubckt_7189_nand2_x0 1 0 8622 8623 7850 nand2_x0
xsubckt_7949_sff1_x4 1 2163 0 10408 220 sff1_x4
xsubckt_9134_sff1_x4 1 2215 0 9306 1110 sff1_x4
xspare_feed_183 1 0 decap_w0
xspare_feed_182 1 0 decap_w0
xspare_feed_181 1 0 decap_w0
xspare_feed_180 1 0 decap_w0
xsubckt_1721_nxr2_x1 6658 1 0 6661 236 nxr2_x1
xsubckt_1378_nand2_x0 1 0 6987 199 8083 nand2_x0
xsubckt_556_oa22_x2 0 187 1 1894 7796 7781 oa22_x2
xsubckt_4047_o2_x2 0 4332 1 227 746 o2_x2
xsubckt_4519_mx3_x2 1 0 10054 4164 6288 1665 6206 6210 mx3_x2
xsubckt_4655_ao22_x2 0 4131 1 4133 8308 1954 ao22_x2
xsubckt_5171_o2_x2 0 9829 1 3719 3730 o2_x2
xsubckt_5655_mx2_x2 0 3318 1 796 906 874 mx2_x2
xsubckt_5657_mx2_x2 0 3316 1 782 3317 3320 mx2_x2
xsubckt_5659_mx2_x2 0 3314 1 796 1034 1002 mx2_x2
xsubckt_6139_o2_x2 0 2876 1 2877 7931 o2_x2
xsubckt_6941_nor3_x0 1 0 8753 8754 8766 8832 nor3_x0
xsubckt_7064_oa22_x2 0 8675 1 703 8245 574 oa22_x2
xsubckt_8234_sff1_x4 1 2225 0 10123 1672 sff1_x4
xsubckt_8757_sff1_x4 1 2070 0 9665 657 sff1_x4
xfeed_239 1 0 tie
xfeed_238 1 0 tie
xfeed_237 1 0 decap_w0
xfeed_236 1 0 decap_w0
xfeed_235 1 0 decap_w0
xfeed_234 1 0 decap_w0
xfeed_233 1 0 decap_w0
xfeed_232 1 0 tie
xfeed_231 1 0 decap_w0
xfeed_230 1 0 decap_w0
xspare_feed_189 1 0 decap_w0
xspare_feed_188 1 0 decap_w0
xspare_feed_187 1 0 decap_w0
xspare_feed_186 1 0 decap_w0
xspare_feed_185 1 0 decap_w0
xspare_feed_184 1 0 decap_w0
xsubckt_1795_nxr2_x1 6589 1 0 6591 199 nxr2_x1
xsubckt_3305_nand2_x0 1 0 5061 5062 781 nand2_x0
xsubckt_3912_nand3_x0 1 0 4464 4484 4488 8013 nand3_x0
xsubckt_4340_mx2_x2 0 10219 1 4191 6252 1448 mx2_x2
xsubckt_4760_nxr2_x1 4051 1 0 4053 8327 nxr2_x1
xsubckt_9042_sff1_x4 1 2132 0 9388 1367 sff1_x4
xcmpt_abc_30082_new_n3405_hfns_2 1 0 8291 8288 buf_x4
xcmpt_abc_30082_new_n3405_hfns_1 1 0 8288 8289 buf_x4
xcmpt_abc_30082_new_n3405_hfns_0 1 0 8288 8290 buf_x4
xspare_feed_190 1 0 decap_w0
xsubckt_909_oa22_x2 0 7441 1 422 7810 7618 oa22_x2
xsubckt_987_oa22_x2 0 7367 1 7614 7478 7368 oa22_x2
xsubckt_3029_oa22_x2 0 5333 1 5392 5390 5389 oa22_x2
xsubckt_3125_nand2_x0 1 0 5238 5239 781 nand2_x0
xsubckt_4007_nand2_x0 1 0 4371 4372 781 nand2_x0
xsubckt_4095_nand2_x0 1 0 4284 6011 8075 nand2_x0
xsubckt_4348_mx2_x2 0 10211 1 4190 6178 1470 mx2_x2
xsubckt_6794_ao22_x2 0 8861 1 8422 8863 8862 ao22_x2
xsubckt_8142_sff1_x4 1 2195 0 10215 1444 sff1_x4
xsubckt_8665_sff1_x4 1 2182 0 9724 523 sff1_x4
xfeed_249 1 0 tie
xfeed_248 1 0 decap_w0
xfeed_247 1 0 decap_w0
xfeed_246 1 0 decap_w0
xfeed_245 1 0 decap_w0
xfeed_244 1 0 decap_w0
xfeed_243 1 0 decap_w0
xfeed_242 1 0 decap_w0
xfeed_241 1 0 tie
xfeed_240 1 0 tie
xfeed_0 1 0 decap_w0
xspare_feed_199 1 0 decap_w0
xspare_feed_198 1 0 decap_w0
xspare_feed_197 1 0 decap_w0
xspare_feed_196 1 0 decap_w0
xspare_feed_195 1 0 decap_w0
xspare_feed_194 1 0 decap_w0
xspare_feed_193 1 0 decap_w0
xspare_feed_192 1 0 decap_w0
xspare_feed_191 1 0 decap_w0
xsubckt_1361_nand2_x0 1 0 7004 7005 7012 nand2_x0
xsubckt_1271_nand2_x0 1 0 7094 7095 7099 nand2_x0
xsubckt_767_nand2_x0 1 0 7576 7760 328 nand2_x0
xsubckt_821_oa22_x2 0 7525 1 7544 7542 7543 oa22_x2
xsubckt_3035_nand2_x0 1 0 5327 5330 5333 nand2_x0
xsubckt_3420_mx2_x2 0 4948 1 8032 4949 4950 mx2_x2
xsubckt_3422_mx2_x2 0 4946 1 795 1241 1209 mx2_x2
xsubckt_3424_mx2_x2 0 4944 1 8032 4945 4946 mx2_x2
xsubckt_9038_sff1_x4 1 2079 0 9392 375 sff1_x4
xsubckt_9473_sff1_x4 1 2100 0 8970 1833 sff1_x4
xfeed_9 1 0 decap_w0
xfeed_8 1 0 decap_w0
xfeed_7 1 0 decap_w0
xfeed_6 1 0 decap_w0
xfeed_5 1 0 decap_w0
xfeed_4 1 0 decap_w0
xfeed_3 1 0 decap_w0
xfeed_2 1 0 tie
xfeed_1 1 0 decap_w0
xsubckt_409_nand2_x0 1 0 7936 7937 53 nand2_x0
xsubckt_379_nor2_x0 1 0 7966 660 659 nor2_x0
xsubckt_3372_oa22_x2 0 4995 1 4996 4997 776 oa22_x2
xsubckt_3426_mx2_x2 0 4942 1 794 1369 1337 mx2_x2
xsubckt_3428_mx2_x2 0 4940 1 8032 4941 4942 mx2_x2
xsubckt_3771_mx2_x2 0 4603 1 795 1842 1810 mx2_x2
xsubckt_3819_mx2_x2 0 4556 1 795 1041 1009 mx2_x2
xsubckt_6068_oa22_x2 0 2945 1 3191 2948 2946 oa22_x2
xsubckt_7325_oa22_x2 0 8519 1 701 8245 741 oa22_x2
xsubckt_7730_mx2_x2 0 9096 1 8444 6244 967 mx2_x2
xsubckt_8050_sff1_x4 1 2225 0 10307 1758 sff1_x4
xsubckt_8138_sff1_x4 1 2251 0 10219 1448 sff1_x4
xsubckt_8573_sff1_x4 1 2050 0 9784 2023 sff1_x4
xfeed_259 1 0 decap_w0
xfeed_258 1 0 tie
xfeed_257 1 0 decap_w0
xfeed_256 1 0 decap_w0
xfeed_255 1 0 tie
xfeed_254 1 0 decap_w0
xfeed_253 1 0 tie
xfeed_252 1 0 tie
xfeed_251 1 0 tie
xfeed_250 1 0 decap_w0
xsubckt_2236_ao22_x2 0 6164 1 86 6174 6291 ao22_x2
xsubckt_2113_mx2_x2 0 6334 1 825 6335 6342 mx2_x2
xsubckt_2111_mx2_x2 0 6336 1 834 6337 6338 mx2_x2
xsubckt_483_nand4_x0 1 0 7851 703 652 45 1912 nand4_x0
xsubckt_233_inv_x0 1 0 322 8143 inv_x0
xsubckt_231_inv_x0 1 0 324 8145 inv_x0
xsubckt_727_a2_x2 0 7617 1 8411 558 a2_x2
xsubckt_747_a2_x2 0 7595 1 218 1898 a2_x2
xsubckt_750_nand2_x0 1 0 7592 629 1941 nand2_x0
xsubckt_3039_mx2_x2 0 5323 1 794 1055 1023 mx2_x2
xsubckt_3632_xr2_x1 4740 0 1 234 753 xr2_x1
xsubckt_3775_mx2_x2 0 4599 1 794 1426 1394 mx2_x2
xsubckt_5960_oa22_x2 0 3050 1 3190 3053 3051 oa22_x2
xsubckt_7085_mx3_x2 1 0 9590 8668 6291 1509 6225 6229 mx3_x2
xsubckt_7341_mx2_x2 0 9488 1 8831 8507 756 mx2_x2
xsubckt_7736_mx2_x2 0 9090 1 8443 6188 991 mx2_x2
xsubckt_7862_nand2_x0 1 0 8942 8423 3282 nand2_x0
xsubckt_8046_sff1_x4 1 2189 0 10311 1732 sff1_x4
xsubckt_8569_sff1_x4 1 2050 0 9788 2027 sff1_x4
xsubckt_8930_sff1_x4 1 2079 0 9495 737 sff1_x4
xsubckt_9381_sff1_x4 1 2235 0 9062 933 sff1_x4
xsubckt_9469_sff1_x4 1 2097 0 8974 1859 sff1_x4
xsubckt_2333_a4_x2 0 6039 1 6066 73 72 71 a4_x2
xsubckt_2222_nand3_x0 1 0 6182 6203 89 88 nand3_x0
xsubckt_2119_mx2_x2 0 6328 1 832 6329 6330 mx2_x2
xsubckt_2117_mx2_x2 0 6330 1 853 1833 1801 mx2_x2
xsubckt_2115_mx2_x2 0 6332 1 853 1705 1673 mx2_x2
xsubckt_1961_nand2_x0 1 0 6454 7809 195 nand2_x0
xsubckt_1430_nand3_x0 1 0 6930 6931 6932 6933 nand3_x0
xsubckt_1340_nand3_x0 1 0 7025 7052 442 8130 nand3_x0
xsubckt_239_inv_x0 1 0 237 8137 inv_x0
xsubckt_237_inv_x0 1 0 2013 8139 inv_x0
xsubckt_235_inv_x0 1 0 423 8141 inv_x0
xsubckt_191_inv_x0 1 0 2284 8185 inv_x0
xsubckt_836_nand3_x0 1 0 7510 7511 7512 7513 nand3_x0
xsubckt_1137_oa22_x2 0 7225 1 409 7809 7618 oa22_x2
xsubckt_2843_nand2_x0 1 0 5515 6011 8118 nand2_x0
xsubckt_3014_nand3_x0 1 0 5347 5367 5371 8013 nand3_x0
xsubckt_3567_ao22_x2 0 4804 1 4862 4857 4859 ao22_x2
xsubckt_3635_nand2_x0 1 0 4737 4740 4743 nand2_x0
xsubckt_3725_nand2_x0 1 0 4648 4649 780 nand2_x0
xsubckt_3779_mx2_x2 0 4595 1 793 1586 1554 mx2_x2
xsubckt_7087_mx3_x2 1 0 9588 8668 6291 1537 6206 6209 mx3_x2
xsubckt_7349_mx2_x2 0 9486 1 8500 6283 1603 mx2_x2
xsubckt_7690_mx2_x2 0 9134 1 8449 6283 1027 mx2_x2
xsubckt_7692_mx2_x2 0 9132 1 8449 6273 1015 mx2_x2
xsubckt_7738_mx2_x2 0 9088 1 8444 6170 989 mx2_x2
xsubckt_8403_sff1_x4 1 2238 0 9954 1629 sff1_x4
xsubckt_8481_sff1_x4 1 2044 0 9876 1922 sff1_x4
xsubckt_8926_sff1_x4 1 2153 0 9499 763 sff1_x4
xsubckt_9303_sff1_x4 1 2113 0 9137 1037 sff1_x4
xsubckt_9377_sff1_x4 1 2106 0 9066 937 sff1_x4
xfeed_269 1 0 tie
xfeed_268 1 0 decap_w0
xfeed_267 1 0 decap_w0
xfeed_266 1 0 decap_w0
xfeed_265 1 0 decap_w0
xfeed_264 1 0 decap_w0
xfeed_263 1 0 decap_w0
xfeed_262 1 0 decap_w0
xfeed_261 1 0 decap_w0
xfeed_260 1 0 decap_w0
xsubckt_2075_mx2_x2 0 6371 1 860 1772 1740 mx2_x2
xsubckt_2073_mx2_x2 0 6373 1 830 6374 6377 mx2_x2
xsubckt_2071_mx2_x2 0 6375 1 860 1644 1612 mx2_x2
xsubckt_1441_nxr2_x1 6919 1 0 6922 8286 nxr2_x1
xsubckt_441_o2_x2 0 7897 1 646 645 o2_x2
xsubckt_193_inv_x0 1 0 2283 8183 inv_x0
xsubckt_195_inv_x0 1 0 2282 8181 inv_x0
xsubckt_197_inv_x0 1 0 2281 8179 inv_x0
xsubckt_2753_nand2_x0 1 0 5604 5605 8021 nand2_x0
xsubckt_2839_nand3_x0 1 0 5519 5520 5523 5949 nand3_x0
xsubckt_3203_a2_x2 0 5161 1 5162 5167 a2_x2
xsubckt_3209_nor2_x0 1 0 5156 242 761 nor2_x0
xsubckt_3545_nand2_x0 1 0 4825 4826 779 nand2_x0
xsubckt_6421_mx2_x2 0 2602 1 853 1429 1397 mx2_x2
xsubckt_6423_mx2_x2 0 2600 1 8211 2601 2604 mx2_x2
xsubckt_6814_mx2_x2 0 9422 1 7918 431 399 mx2_x2
xsubckt_6886_nand3_x0 1 0 8793 8258 394 8261 nand3_x0
xsubckt_7694_mx2_x2 0 9130 1 8449 6258 1001 mx2_x2
xsubckt_7696_mx2_x2 0 9128 1 8449 6245 999 mx2_x2
xsubckt_8477_sff1_x4 1 2044 0 9880 1926 sff1_x4
xsubckt_9211_sff1_x4 1 2106 0 9229 1090 sff1_x4
xspare_feed_309 1 0 decap_w0
xspare_feed_308 1 0 decap_w0
xspare_feed_307 1 0 decap_w0
xspare_feed_306 1 0 decap_w0
xspare_feed_305 1 0 decap_w0
xspare_feed_304 1 0 decap_w0
xspare_feed_303 1 0 decap_w0
xspare_feed_302 1 0 decap_w0
xspare_feed_301 1 0 decap_w0
xspare_feed_300 1 0 decap_w0
xsubckt_2079_mx2_x2 0 6367 1 859 908 876 mx2_x2
xsubckt_2077_mx2_x2 0 6369 1 8221 6370 6371 mx2_x2
xsubckt_1402_oa22_x2 0 6963 1 7103 6964 6977 oa22_x2
xsubckt_199_inv_x0 1 0 2280 8177 inv_x0
xsubckt_656_mx2_x2 0 7685 1 217 426 409 mx2_x2
xsubckt_906_xr2_x1 7444 0 1 759 84 xr2_x1
xsubckt_1151_a2_x2 0 7212 1 744 69 a2_x2
xsubckt_2468_mx2_x2 0 5884 1 821 919 887 mx2_x2
xsubckt_2899_oa22_x2 0 5460 1 5461 5500 5957 oa22_x2
xsubckt_3365_nand2_x0 1 0 5002 5003 782 nand2_x0
xsubckt_4759_a4_x2 0 4052 1 4054 4065 4143 1956 a4_x2
xsubckt_5129_nand2_x0 1 0 9832 3758 3770 nand2_x0
xsubckt_5315_a2_x2 0 3585 1 3586 3587 a2_x2
xsubckt_5482_a3_x2 1 3441 0 3446 2035 2036 a3_x2
xsubckt_5736_nand3_x0 1 0 3266 6002 703 8295 nand3_x0
xsubckt_6036_mx2_x2 0 2977 1 860 1856 1824 mx2_x2
xsubckt_6038_mx2_x2 0 2975 1 860 1728 1696 mx2_x2
xsubckt_6069_a2_x2 0 9699 1 2945 2979 a2_x2
xsubckt_6381_mx2_x2 0 2641 1 860 1654 1622 mx2_x2
xsubckt_6425_mx2_x2 0 2598 1 8206 2599 2614 mx2_x2
xsubckt_6770_mx2_x2 0 8884 1 859 1354 1322 mx2_x2
xsubckt_6772_mx2_x2 0 8882 1 8220 8883 8884 mx2_x2
xsubckt_6860_a3_x2 1 8811 0 8258 394 393 a3_x2
xsubckt_8311_sff1_x4 1 2232 0 10046 1657 sff1_x4
xsubckt_8834_sff1_x4 1 2189 0 9591 1510 sff1_x4
xsubckt_9285_sff1_x4 1 2198 0 9155 1056 sff1_x4
xfeed_279 1 0 decap_w0
xfeed_278 1 0 decap_w0
xfeed_277 1 0 decap_w0
xfeed_276 1 0 decap_w0
xfeed_275 1 0 decap_w0
xfeed_274 1 0 tie
xfeed_273 1 0 decap_w0
xfeed_272 1 0 decap_w0
xfeed_271 1 0 decap_w0
xfeed_270 1 0 decap_w0
xcmpt_abc_30082_new_n5446_hfns_2 1 0 6301 6298 buf_x4
xcmpt_abc_30082_new_n5446_hfns_1 1 0 6298 6299 buf_x4
xcmpt_abc_30082_new_n5446_hfns_0 1 0 6298 6300 buf_x4
xsubckt_2199_a2_x2 0 6222 1 6232 62 a2_x2
xsubckt_1866_a3_x2 1 6522 0 6523 6524 6525 a3_x2
xsubckt_1777_nand3_x0 1 0 6606 6634 8045 8046 nand3_x0
xsubckt_1660_a2_x2 0 6715 1 6716 241 a2_x2
xsubckt_1513_nand2_x0 1 0 6852 6854 6860 nand2_x0
xsubckt_1423_nand2_x0 1 0 6936 6968 7972 nand2_x0
xsubckt_3263_a2_x2 0 5102 1 5103 5108 a2_x2
xsubckt_3275_nand2_x0 1 0 5091 5094 5097 nand2_x0
xsubckt_5341_oa22_x2 0 3561 1 3882 3588 3879 oa22_x2
xsubckt_5629_a2_x2 0 9750 1 3340 47 a2_x2
xsubckt_6383_mx2_x2 0 2639 1 8221 2640 2641 mx2_x2
xsubckt_6385_mx2_x2 0 2637 1 858 1430 1398 mx2_x2
xsubckt_6387_mx2_x2 0 2635 1 8213 2636 2639 mx2_x2
xsubckt_6774_mx2_x2 0 8880 1 858 1130 1098 mx2_x2
xsubckt_6776_mx2_x2 0 8878 1 8213 8879 8882 mx2_x2
xsubckt_6778_mx2_x2 0 8876 1 859 1578 1546 mx2_x2
xsubckt_7934_sff1_x4 1 2113 0 10418 1805 sff1_x4
xsubckt_8385_sff1_x4 1 2112 0 9972 1486 sff1_x4
xsubckt_9207_sff1_x4 1 2119 0 9233 1197 sff1_x4
xcmpt_abc_30082_new_n5448_hfns_9 1 0 6296 6286 buf_x4
xcmpt_abc_30082_new_n5448_hfns_8 1 0 6286 6287 buf_x4
xcmpt_abc_30082_new_n5448_hfns_7 1 0 6286 6288 buf_x4
xcmpt_abc_30082_new_n5448_hfns_6 1 0 6286 6289 buf_x4
xcmpt_abc_30082_new_n5448_hfns_5 1 0 6286 6290 buf_x4
xcmpt_abc_30082_new_n5448_hfns_4 1 0 6286 6291 buf_x4
xcmpt_abc_30082_new_n5448_hfns_3 1 0 6286 6292 buf_x4
xcmpt_abc_30082_new_n5448_hfns_2 1 0 6286 6293 buf_x4
xcmpt_abc_30082_new_n5448_hfns_1 1 0 6286 6294 buf_x4
xcmpt_abc_30082_new_n5448_hfns_0 1 0 6286 6295 buf_x4
xspare_feed_316 1 0 decap_w0
xspare_feed_315 1 0 decap_w0
xspare_feed_314 1 0 decap_w0
xspare_feed_313 1 0 decap_w0
xspare_feed_312 1 0 decap_w0
xspare_feed_311 1 0 decap_w0
xspare_feed_310 1 0 decap_w0
xsubckt_1597_nand3_x0 1 0 6774 6802 8056 8057 nand3_x0
xsubckt_739_nand2_x0 1 0 7602 7603 7611 nand2_x0
xsubckt_864_xr2_x1 7484 0 1 761 86 xr2_x1
xsubckt_3185_nand2_x0 1 0 5179 5180 781 nand2_x0
xsubckt_3614_nand3_x0 1 0 4757 4762 4766 772 nand3_x0
xsubckt_3629_oa22_x2 0 4743 1 4803 4801 4800 oa22_x2
xsubckt_4681_a2_x2 0 4112 1 1915 1914 a2_x2
xsubckt_5649_a2_x2 0 3324 1 3325 3326 a2_x2
xsubckt_6389_mx2_x2 0 2633 1 8206 2634 2649 mx2_x2
xsubckt_6753_a2_x2 0 9680 1 8901 8935 a2_x2
xsubckt_8307_sff1_x4 1 2238 0 10050 1661 sff1_x4
xsubckt_8742_sff1_x4 1 2176 0 2303 2271 sff1_x4
xsubckt_9193_sff1_x4 1 2212 0 9247 1212 sff1_x4
xfeed_289 1 0 decap_w0
xfeed_288 1 0 decap_w0
xfeed_287 1 0 decap_w0
xfeed_286 1 0 decap_w0
xfeed_285 1 0 decap_w0
xfeed_284 1 0 decap_w0
xfeed_283 1 0 tie
xfeed_282 1 0 decap_w0
xfeed_281 1 0 decap_w0
xfeed_280 1 0 decap_w0
xspare_feed_319 1 0 decap_w0
xspare_feed_318 1 0 decap_w0
xspare_feed_317 1 0 decap_w0
xsubckt_2147_o2_x2 0 6311 1 556 555 o2_x2
xsubckt_1780_nxr2_x1 6603 1 0 6605 200 nxr2_x1
xsubckt_1639_o3_x2 0 6734 1 6735 6736 6939 o3_x2
xsubckt_1413_o2_x2 0 6952 1 6953 6954 o2_x2
xsubckt_1384_oa22_x2 0 6981 1 6982 6985 7162 oa22_x2
xsubckt_1218_o2_x2 0 7147 1 199 231 o2_x2
xsubckt_394_nor4_x0 1 0 7951 648 647 623 620 nor4_x0
xsubckt_559_nand2_x0 1 0 7778 7779 7798 nand2_x0
xsubckt_902_nand2_x0 1 0 179 7448 7460 nand2_x0
xsubckt_1153_nand2_x0 1 0 7210 7211 7213 nand2_x0
xsubckt_3434_nand3_x0 1 0 4934 4939 4943 772 nand3_x0
xsubckt_5856_mx2_x2 0 3152 1 863 1831 1799 mx2_x2
xsubckt_5858_mx2_x2 0 3150 1 863 1703 1671 mx2_x2
xsubckt_8293_sff1_x4 1 2099 0 10064 1667 sff1_x4
xsubckt_8738_sff1_x4 1 2182 0 2307 2275 sff1_x4
xsubckt_9115_sff1_x4 1 2132 0 9325 1122 sff1_x4
xspare_feed_323 1 0 decap_w0
xspare_feed_322 1 0 decap_w0
xspare_feed_321 1 0 decap_w0
xspare_feed_320 1 0 decap_w0
xsubckt_1583_ao22_x2 0 6787 1 6801 214 8416 ao22_x2
xsubckt_1238_o2_x2 0 7127 1 204 236 o2_x2
xsubckt_370_a4_x2 0 7978 1 7979 7981 7982 7983 a4_x2
xsubckt_990_nand2_x0 1 0 7364 629 1928 nand2_x0
xsubckt_1060_ao22_x2 0 7298 1 7300 7303 1903 ao22_x2
xsubckt_2510_nxr2_x1 5842 1 0 5843 5849 nxr2_x1
xsubckt_3505_o2_x2 0 4864 1 4865 5995 o2_x2
xsubckt_3965_nand2_x0 1 0 4412 4413 784 nand2_x0
xsubckt_3972_oa22_x2 0 4405 1 4406 4407 776 oa22_x2
xsubckt_4050_nand2_x0 1 0 4329 4330 4333 nand2_x0
xsubckt_4543_mx2_x2 0 10032 1 4157 6282 1347 mx2_x2
xsubckt_4829_nxr2_x1 3999 1 0 4001 8342 nxr2_x1
xsubckt_4932_mx2_x2 0 3924 1 6445 6209 154 mx2_x2
xsubckt_8215_sff1_x4 1 2238 0 10142 1273 sff1_x4
xsubckt_8289_sff1_x4 1 2138 0 10068 1294 sff1_x4
xsubckt_8650_sff1_x4 1 2185 0 9739 509 sff1_x4
xsubckt_9189_sff1_x4 1 2235 0 9251 1216 sff1_x4
xfeed_299 1 0 decap_w0
xfeed_298 1 0 decap_w0
xfeed_297 1 0 tie
xfeed_296 1 0 tie
xfeed_295 1 0 tie
xfeed_294 1 0 tie
xfeed_293 1 0 tie
xfeed_292 1 0 decap_w0
xfeed_291 1 0 decap_w0
xfeed_290 1 0 decap_w0
xspare_feed_329 1 0 decap_w0
xspare_feed_328 1 0 decap_w0
xspare_feed_327 1 0 decap_w0
xspare_feed_326 1 0 decap_w0
xspare_feed_325 1 0 decap_w0
xspare_feed_324 1 0 decap_w0
xspare_buffer_16 1 0 2254 2094 buf_x4
xspare_buffer_12 1 0 2254 2147 buf_x4
xsubckt_1933_nand2_x0 1 0 6467 210 328 nand2_x0
xsubckt_880_oa22_x2 0 7468 1 7469 7473 7793 oa22_x2
xsubckt_968_oa22_x2 0 7385 1 7614 7478 7386 oa22_x2
xsubckt_3088_oa22_x2 0 5275 1 5333 5330 5332 oa22_x2
xsubckt_3254_nand3_x0 1 0 5111 5116 5120 770 nand3_x0
xsubckt_3785_nand2_x0 1 0 4589 4590 784 nand2_x0
xsubckt_4545_mx2_x2 0 10030 1 4156 6272 1335 mx2_x2
xsubckt_4547_mx2_x2 0 10028 1 4156 6259 1321 mx2_x2
xsubckt_4936_mx2_x2 0 3921 1 6444 6200 153 mx2_x2
xsubckt_5637_nxr2_x1 3334 1 0 3337 8072 nxr2_x1
xsubckt_6502_oa22_x2 0 2524 1 55 1906 200 oa22_x2
xsubckt_8123_sff1_x4 1 2229 0 10234 1236 sff1_x4
xsubckt_8646_sff1_x4 1 2185 0 9743 515 sff1_x4
xsubckt_9023_sff1_x4 1 2063 0 9407 392 sff1_x4
xspare_feed_330 1 0 decap_w0
xsubckt_2282_nand3_x0 1 0 6104 6105 541 8408 nand3_x0
xsubckt_542_nand2_x0 1 0 7797 7798 7799 nand2_x0
xsubckt_712_a3_x2 1 7631 0 7632 7633 7634 a3_x2
xsubckt_2725_nand2_x0 1 0 5631 6008 8118 nand2_x0
xsubckt_3074_nand3_x0 1 0 5288 5293 5297 772 nand3_x0
xsubckt_3230_mx2_x2 0 5135 1 806 924 892 mx2_x2
xsubckt_4158_mx2_x2 0 10383 1 4224 6278 1794 mx2_x2
xsubckt_4549_mx2_x2 0 10026 1 4157 6244 1319 mx2_x2
xsubckt_4896_mx2_x2 0 3951 1 6445 6280 155 mx2_x2
xsubckt_6790_nor4_x0 1 0 8865 1898 1894 1912 1901 nor4_x0
xsubckt_7310_oa22_x2 0 8531 1 703 8245 738 oa22_x2
xsubckt_8197_sff1_x4 1 2103 0 10160 1283 sff1_x4
xsubckt_9019_sff1_x4 1 2086 0 9411 396 sff1_x4
xsubckt_9097_sff1_x4 1 2205 0 9343 892 sff1_x4
xsubckt_9454_sff1_x4 1 2242 0 8989 1882 sff1_x4
xspare_feed_339 1 0 decap_w0
xspare_feed_338 1 0 decap_w0
xspare_feed_337 1 0 decap_w0
xspare_feed_336 1 0 decap_w0
xspare_feed_335 1 0 decap_w0
xspare_feed_334 1 0 decap_w0
xspare_feed_333 1 0 decap_w0
xspare_feed_332 1 0 decap_w0
xspare_feed_331 1 0 decap_w0
xspare_buffer_28 1 0 2253 2226 buf_x4
xspare_buffer_24 1 0 2253 2239 buf_x4
xspare_buffer_20 1 0 2253 2252 buf_x4
xsubckt_452_nand2_x0 1 0 7882 53 1912 nand2_x0
xsubckt_538_nand3_x0 1 0 7801 330 8285 217 nand3_x0
xsubckt_3232_mx2_x2 0 5133 1 8029 5134 5135 mx2_x2
xsubckt_3234_mx2_x2 0 5131 1 806 1500 1468 mx2_x2
xsubckt_3236_mx2_x2 0 5129 1 8029 5130 5131 mx2_x2
xsubckt_3809_nor2_x0 1 0 4566 231 750 nor2_x0
xsubckt_5510_oa22_x2 0 3422 1 2026 3427 2025 oa22_x2
xsubckt_8031_sff1_x4 1 2204 0 10326 1136 sff1_x4
xsubckt_8119_sff1_x4 1 2242 0 10238 1241 sff1_x4
xsubckt_8554_sff1_x4 1 2060 0 9803 1985 sff1_x4
xcmpt_abc_30082_new_n7483_hfns_2 1 0 4216 4213 buf_x4
xcmpt_abc_30082_new_n7483_hfns_1 1 0 4213 4214 buf_x4
xcmpt_abc_30082_new_n7483_hfns_0 1 0 4213 4215 buf_x4
xsubckt_2310_mx2_x2 0 6068 1 546 105 2269 mx2_x2
xsubckt_2096_oa22_x2 0 316 1 8283 6354 6351 oa22_x2
xsubckt_685_a2_x2 0 7657 1 7658 1894 a2_x2
xsubckt_919_a2_x2 0 7431 1 7432 7438 a2_x2
xsubckt_2701_mx2_x2 0 5655 1 8028 5656 5657 mx2_x2
xsubckt_2703_mx2_x2 0 5653 1 805 1639 1607 mx2_x2
xsubckt_3238_mx2_x2 0 5127 1 805 1660 1628 mx2_x2
xsubckt_3583_mx2_x2 0 4788 1 805 1173 1077 mx2_x2
xsubckt_3854_nand3_x0 1 0 4521 4526 4530 772 nand3_x0
xsubckt_5348_ao22_x2 0 3554 1 3882 3885 730 ao22_x2
xsubckt_7151_mx2_x2 0 9544 1 8643 460 355 mx2_x2
xsubckt_7540_mx2_x2 0 9273 1 8475 6107 1397 mx2_x2
xsubckt_7542_mx2_x2 0 9271 1 8475 6088 1395 mx2_x2
xsubckt_8911_sff1_x4 1 2083 0 9514 747 sff1_x4
xsubckt_9362_sff1_x4 1 2222 0 9081 981 sff1_x4
xspare_feed_349 1 0 decap_w0
xspare_feed_348 1 0 tie
xspare_feed_347 1 0 tie
xspare_feed_346 1 0 decap_w0
xspare_feed_345 1 0 tie
xspare_feed_344 1 0 tie
xspare_feed_343 1 0 decap_w0
xspare_feed_342 1 0 tie
xspare_feed_341 1 0 tie
xspare_feed_340 1 0 decap_w0
xspare_buffer_37 1 0 2252 2250 buf_x4
xspare_buffer_36 1 0 2252 2251 buf_x4
xspare_buffer_32 1 0 2253 2213 buf_x4
xsubckt_2316_mx2_x2 0 10421 1 6300 6061 1808 mx2_x2
xsubckt_545_o3_x2 0 7794 1 1899 1895 1903 o3_x2
xsubckt_939_a2_x2 0 7412 1 7413 7421 a2_x2
xsubckt_1118_oa22_x2 0 7243 1 410 7810 7618 oa22_x2
xsubckt_2661_mx2_x2 0 5694 1 8012 5695 5710 mx2_x2
xsubckt_2705_mx2_x2 0 5651 1 8030 5652 5653 mx2_x2
xsubckt_2707_mx2_x2 0 5649 1 804 1223 1191 mx2_x2
xsubckt_2709_mx2_x2 0 5647 1 8030 5648 5649 mx2_x2
xsubckt_3500_nand2_x0 1 0 4869 6012 8095 nand2_x0
xsubckt_3587_mx2_x2 0 4784 1 804 1781 1749 mx2_x2
xsubckt_4646_nand3_x0 1 0 4137 701 1977 1912 nand3_x0
xsubckt_4684_oa22_x2 0 4109 1 4112 4116 1975 oa22_x2
xsubckt_6392_oa22_x2 0 2630 1 3191 2633 2631 oa22_x2
xsubckt_7153_mx2_x2 0 9542 1 8642 458 353 mx2_x2
xsubckt_7155_mx2_x2 0 9540 1 8642 455 350 mx2_x2
xsubckt_7157_mx2_x2 0 9538 1 8642 453 348 mx2_x2
xsubckt_7544_mx2_x2 0 9269 1 8475 6071 1393 mx2_x2
xsubckt_7546_mx2_x2 0 9267 1 8475 6054 1391 mx2_x2
xsubckt_7548_mx2_x2 0 9265 1 8475 6035 1389 mx2_x2
xsubckt_8027_sff1_x4 1 2232 0 10330 1140 sff1_x4
xsubckt_8462_sff1_x4 1 2057 0 9895 1942 sff1_x4
xsubckt_8985_sff1_x4 1 2238 0 9440 1565 sff1_x4
xspare_buffer_38 1 0 2252 2249 buf_x4
xsubckt_2291_a4_x2 0 6093 1 6120 79 78 77 a4_x2
xsubckt_2274_mx2_x2 0 10427 1 6300 6116 1814 mx2_x2
xsubckt_799_nand2_x0 1 0 7545 7546 7554 nand2_x0
xsubckt_999_a2_x2 0 7356 1 753 78 a2_x2
xsubckt_2665_mx2_x2 0 5690 1 6011 221 223 mx2_x2
xsubckt_2913_xr2_x1 5447 0 1 247 766 xr2_x1
xsubckt_3320_nand2_x0 1 0 5046 6011 8101 nand2_x0
xsubckt_3674_nand3_x0 1 0 4698 4703 4707 770 nand3_x0
xsubckt_5492_oa22_x2 0 3434 1 2033 3439 2032 oa22_x2
xsubckt_5499_nor2_x0 1 0 9790 3430 3431 nor2_x0
xsubckt_6231_mx2_x2 0 2787 1 838 1307 1275 mx2_x2
xsubckt_6620_mx2_x2 0 2409 1 8224 2410 2411 mx2_x2
xsubckt_6622_mx2_x2 0 2407 1 838 1039 1007 mx2_x2
xsubckt_6624_mx2_x2 0 2405 1 8210 2406 2409 mx2_x2
xsubckt_7159_mx2_x2 0 9536 1 8643 451 346 mx2_x2
xsubckt_8907_sff1_x4 1 2066 0 9518 60 sff1_x4
xsubckt_9270_sff1_x4 1 2112 0 9170 1422 sff1_x4
xsubckt_9358_sff1_x4 1 2242 0 9085 986 sff1_x4
.ends picorv32_cts_r
