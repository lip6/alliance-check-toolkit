* top_eldo.cir bench SARlogic
*

*****************
.option  nopage nomod
+        newtol numdgt=7 ingold=2 gmindc=1e-18
.option DOTNODE
.option MSGNODE = 0

.TEMP 25
.lib '/users/soft/techno/dev/taiwan/T-018-CM-SP-007-K3/180/models/eldo/cmn018_assp_v1d3.eldo' TT
.lib '/users/soft/techno/dev/taiwan/T-018-CM-SP-007-K3/180/models/eldo/cmn018_assp_v1d3.eldo' TT_3V
.lib '/users/soft/techno/dev/taiwan/T-018-CM-SP-007-K3/180/models/eldo/cmn018_assp_v1d3.eldo' TT_RES
.lib '/users/soft/techno/dev/taiwan/T-018-CM-SP-007-K3/180/models/eldo/cmn018_assp_v1d3.eldo' TT_DIO

Vsupply 1 0 1.8
Vground 0 0 0

******************
* circuit model
* include standard cells
.INCLUDE /users/soft/techno/techno/pdkmaster/views/tsmc_c018/FlexLib/spice/FlexLib.spi

* include circuit netlist
.INCLUDE SARlogic_simu.spi

*****************
* Circuit Instantiation
* INTERF vss
* INTERF vdd
* INTERF rst
* INTERF res[7]
* INTERF res[6]
* INTERF res[5]
* INTERF res[4]
* INTERF res[3]
* INTERF res[2]
* INTERF res[1]
* INTERF res[0]
* INTERF cmp
* INTERF clk
* INTERF SOC
* INTERF SE
* INTERF EOC
* INTERF DAC_control[7]
* INTERF DAC_control[6]
* INTERF DAC_control[5]
* INTERF DAC_control[4]
* INTERF DAC_control[3]
* INTERF DAC_control[2]
* INTERF DAC_control[1]
* INTERF DAC_control[0]

* NET     0 = vss
* NET     1 = vdd
* NET     2 = rst
* NET    27 = res[7]
* NET    28 = res[6]
* NET    29 = res[5]
* NET    30 = res[4]
* NET    31 = res[3]
* NET    32 = res[2]
* NET    33 = res[1]
* NET    34 = res[0]
* NET    45 = cmp
* NET    46 = clk
* NET   144 = SOC
* NET   146 = SE
* NET   148 = EOC
* NET   157 = DAC_control[7]
* NET   158 = DAC_control[6]
* NET   159 = DAC_control[5]
* NET   160 = DAC_control[4]
* NET   161 = DAC_control[3]
* NET   162 = DAC_control[2]
* NET   163 = DAC_control[1]
* NET   164 = DAC_control[0]

*SARlogic 0 1 2 27 28 29 30 31 32 33 34 45 46 144 146 148 157 158 159 160 161 162 163 164
XSARlogic 0 1 2 27 28 29 30 31 32 33 34 45 46 144 146 148 157 158 159 160 161 162 163 164 SARlogic

*load on outputs
Cres0 34 0 0.5pF
Cres1 33 0 0.5pF
Cres2 32 0 0.5pF
Cres3 31 0 0.5pF
Cres4 30 0 0.5pF
Cres5 29 0 0.5pF
Cres6 28 0 0.5pF
Cres7 27 0 0.5pF

C0 164 0 0.5pF
C1 163 0 0.5pF
C2 162 0 0.5pF
C3 161 0 0.5pF
C4 160 0 0.5pF
C5 159 0 0.5pF
C6 158 0 0.5pF
C7 157 0 0.5pF

*clock
vck 46 0 dc 0.6 pulse (0 1.8 5ns 1ns 1ns 50ns 110ns)

* input
** reset
vrst 2 0 0
** cmp
vcmp 45 0 1.8

*start of conversion SOC
vsoc 144 0 dc 0.6 pulse (0 1.8 5ns 1ns 1ns 110ns 1100ns)

.op
.TRAN 100ps 1500ns 0
.PLOT TRAN v(46) v(144) v(157) v(158) v(159) v(27) v(28) v(29)

.end
