* Coriolis Structural SPICE Driver
* Generated on Jul 10, 2024, 15:05
* Cell/Subckt "m65_cts_r".
*
* INTERF wt
* INTERF vss
* INTERF vdd
* INTERF sync
* INTERF start
* INTERF rdy
* INTERF rd
* INTERF p_reset
* INTERF nmi
* INTERF m_clock
* INTERF irq
* INTERF debug[9]
* INTERF debug[8]
* INTERF debug[7]
* INTERF debug[6]
* INTERF debug[5]
* INTERF debug[4]
* INTERF debug[3]
* INTERF debug[2]
* INTERF debug[15]
* INTERF debug[14]
* INTERF debug[13]
* INTERF debug[12]
* INTERF debug[11]
* INTERF debug[10]
* INTERF debug[1]
* INTERF debug[0]
* INTERF datao[7]
* INTERF datao[6]
* INTERF datao[5]
* INTERF datao[4]
* INTERF datao[3]
* INTERF datao[2]
* INTERF datao[1]
* INTERF datao[0]
* INTERF data[7]
* INTERF data[6]
* INTERF data[5]
* INTERF data[4]
* INTERF data[3]
* INTERF data[2]
* INTERF data[1]
* INTERF data[0]
* INTERF adrs[9]
* INTERF adrs[8]
* INTERF adrs[7]
* INTERF adrs[6]
* INTERF adrs[5]
* INTERF adrs[4]
* INTERF adrs[3]
* INTERF adrs[2]
* INTERF adrs[15]
* INTERF adrs[14]
* INTERF adrs[13]
* INTERF adrs[12]
* INTERF adrs[11]
* INTERF adrs[10]
* INTERF adrs[1]
* INTERF adrs[0]

* Terminal models (aka standard cells) used througout all the hierarchy.
.include tie_x0.spi
.include rowend_x0.spi
.include a3_x2.spi
.include a2_x2.spi
.include oa22_x2.spi
.include nao22_x1.spi
.include na3_x1.spi
.include ao2o22_x2.spi
.include na2_x1.spi
.include ao22_x2.spi
.include nxr2_x1.spi
.include an12_x1.spi
.include no3_x1.spi
.include sff1_x4.spi
.include sff1r_x4.spi
.include oa2a2a23_x2.spi
.include oa2ao222_x2.spi
.include noa22_x1.spi
.include a4_x2.spi
.include na4_x1.spi
.include o4_x2.spi
.include noa2a2a23_x1.spi
.include no2_x1.spi
.include noa2ao222_x1.spi
.include inv_x1.spi
.include on12_x1.spi
.include o3_x2.spi
.include o2_x2.spi
.include mx2_x2.spi
.include no4_x1.spi
.include nao2o22_x1.spi
.include nmx2_x1.spi
.include xr2_x4.spi
.include buf_x8.spi
.include noa2a22_x1.spi

* Non-terminal models (part of the user's design hierarchy).

.subckt m65_cts_r 0 1 2 4 5 9 10 11 12 14 15 53 54 55 56 57 58 59 60 61 62 63 64 65 66 67 68 69 70 71 72 73 74 75 76 77 78 79 80 81 82 83 84 134 135 136 137 138 139 140 141 142 143 144 145 146 147 148 149
* NET     0 = wt
* NET     1 = vss
* NET     2 = vdd
* NET     3 = tc
* NET     4 = sync
* NET     5 = start
* NET     6 = reg_762[2]
* NET     7 = reg_762[1]
* NET     8 = reg_762[0]
* NET     9 = rdy
* NET    10 = rd
* NET    11 = p_reset
* NET    12 = nmi
* NET    13 = nm1
* NET    14 = m_clock
* NET    15 = irq
* NET    16 = int_req
* NET    17 = incr_thr
* NET    18 = incr_out[9]
* NET    19 = incr_out[8]
* NET    20 = incr_out[7]
* NET    21 = incr_out[6]
* NET    22 = incr_out[5]
* NET    23 = incr_out[4]
* NET    24 = incr_out[3]
* NET    25 = incr_out[2]
* NET    26 = incr_out[15]
* NET    27 = incr_out[14]
* NET    28 = incr_out[13]
* NET    29 = incr_out[12]
* NET    30 = incr_out[11]
* NET    31 = incr_out[10]
* NET    32 = incr_out[1]
* NET    33 = incr_out[0]
* NET    34 = incr_dox
* NET    35 = incr_ci
* NET    36 = ift_run
* NET    37 = fz
* NET    38 = fv
* NET    39 = fn
* NET    40 = fd
* NET    41 = fc
* NET    42 = ex_st[5]
* NET    43 = ex_st[4]
* NET    44 = ex_st[3]
* NET    45 = ex_st[2]
* NET    46 = ex_st[1]
* NET    47 = ex_st[0]
* NET    48 = ex
* NET    49 = do_res
* NET    50 = do_nmi
* NET    51 = do_irq
* NET    52 = do_brk
* NET    53 = debug[9]
* NET    54 = debug[8]
* NET    55 = debug[7]
* NET    56 = debug[6]
* NET    57 = debug[5]
* NET    58 = debug[4]
* NET    59 = debug[3]
* NET    60 = debug[2]
* NET    61 = debug[15]
* NET    62 = debug[14]
* NET    63 = debug[13]
* NET    64 = debug[12]
* NET    65 = debug[11]
* NET    66 = debug[10]
* NET    67 = debug[1]
* NET    68 = debug[0]
* NET    69 = datao[7]
* NET    70 = datao[6]
* NET    71 = datao[5]
* NET    72 = datao[4]
* NET    73 = datao[3]
* NET    74 = datao[2]
* NET    75 = datao[1]
* NET    76 = datao[0]
* NET    77 = data[7]
* NET    78 = data[6]
* NET    79 = data[5]
* NET    80 = data[4]
* NET    81 = data[3]
* NET    82 = data[2]
* NET    83 = data[1]
* NET    84 = data[0]
* NET    85 = alu_z
* NET    86 = alu_v
* NET    87 = alu_thr
* NET    88 = alu_sbc
* NET    89 = alu_s
* NET    90 = alu_ror
* NET    91 = alu_rol
* NET    92 = alu_out[6]
* NET    93 = alu_out[5]
* NET    94 = alu_out[4]
* NET    95 = alu_out[3]
* NET    96 = alu_out[2]
* NET    97 = alu_out[1]
* NET    98 = alu_out[0]
* NET    99 = alu_net_64
* NET   100 = alu_net_62
* NET   101 = alu_net_57
* NET   102 = alu_net_53
* NET   103 = alu_net_43
* NET   104 = alu_lsr
* NET   105 = alu_incc
* NET   106 = alu_inc
* NET   107 = alu_in2[5]
* NET   108 = alu_in2[4]
* NET   109 = alu_in2[3]
* NET   110 = alu_in2[2]
* NET   111 = alu_in2[1]
* NET   112 = alu_in2[0]
* NET   113 = alu_in1[6]
* NET   114 = alu_in1[5]
* NET   115 = alu_in1[4]
* NET   116 = alu_in1[3]
* NET   117 = alu_in1[2]
* NET   118 = alu_in1[1]
* NET   119 = alu_eor
* NET   120 = alu_do_or
* NET   121 = alu_do_and
* NET   122 = alu_df
* NET   123 = alu_dec2
* NET   124 = alu_dec
* NET   125 = alu_ci
* NET   126 = alu_c
* NET   127 = alu_bita
* NET   128 = alu_asl
* NET   129 = alu_adder_lo_net_1[3]
* NET   130 = alu_adder_lo_net_1[2]
* NET   131 = alu_adder_hi_net_1[3]
* NET   132 = alu_adder_hi_net_1[2]
* NET   133 = alu_adc
* NET   134 = adrs[9]
* NET   135 = adrs[8]
* NET   136 = adrs[7]
* NET   137 = adrs[6]
* NET   138 = adrs[5]
* NET   139 = adrs[4]
* NET   140 = adrs[3]
* NET   141 = adrs[2]
* NET   142 = adrs[15]
* NET   143 = adrs[14]
* NET   144 = adrs[13]
* NET   145 = adrs[12]
* NET   146 = adrs[11]
* NET   147 = adrs[10]
* NET   148 = adrs[1]
* NET   149 = adrs[0]
* NET   150 = abc_8306_new_n999
* NET   151 = abc_8306_new_n998
* NET   152 = abc_8306_new_n997
* NET   153 = abc_8306_new_n996
* NET   154 = abc_8306_new_n995
* NET   155 = abc_8306_new_n994
* NET   156 = abc_8306_new_n993
* NET   157 = abc_8306_new_n992
* NET   158 = abc_8306_new_n991
* NET   159 = abc_8306_new_n990
* NET   160 = abc_8306_new_n989
* NET   161 = abc_8306_new_n988
* NET   162 = abc_8306_new_n987
* NET   163 = abc_8306_new_n986
* NET   164 = abc_8306_new_n985
* NET   165 = abc_8306_new_n984
* NET   166 = abc_8306_new_n983
* NET   167 = abc_8306_new_n982
* NET   168 = abc_8306_new_n981
* NET   169 = abc_8306_new_n980
* NET   170 = abc_8306_new_n979
* NET   171 = abc_8306_new_n978
* NET   172 = abc_8306_new_n977
* NET   173 = abc_8306_new_n976
* NET   174 = abc_8306_new_n975
* NET   175 = abc_8306_new_n974
* NET   176 = abc_8306_new_n972
* NET   177 = abc_8306_new_n971
* NET   178 = abc_8306_new_n970
* NET   179 = abc_8306_new_n969
* NET   180 = abc_8306_new_n968
* NET   181 = abc_8306_new_n967
* NET   182 = abc_8306_new_n966
* NET   183 = abc_8306_new_n965
* NET   184 = abc_8306_new_n964
* NET   185 = abc_8306_new_n963
* NET   186 = abc_8306_new_n962
* NET   187 = abc_8306_new_n961
* NET   188 = abc_8306_new_n960
* NET   189 = abc_8306_new_n959
* NET   190 = abc_8306_new_n958
* NET   191 = abc_8306_new_n957
* NET   192 = abc_8306_new_n956
* NET   193 = abc_8306_new_n955
* NET   194 = abc_8306_new_n954
* NET   195 = abc_8306_new_n953
* NET   196 = abc_8306_new_n952
* NET   197 = abc_8306_new_n951
* NET   198 = abc_8306_new_n950
* NET   199 = abc_8306_new_n949
* NET   200 = abc_8306_new_n948
* NET   201 = abc_8306_new_n947
* NET   202 = abc_8306_new_n946
* NET   203 = abc_8306_new_n945
* NET   204 = abc_8306_new_n944
* NET   205 = abc_8306_new_n943
* NET   206 = abc_8306_new_n942
* NET   207 = abc_8306_new_n941
* NET   208 = abc_8306_new_n940
* NET   209 = abc_8306_new_n939
* NET   210 = abc_8306_new_n938
* NET   211 = abc_8306_new_n937
* NET   212 = abc_8306_new_n935
* NET   213 = abc_8306_new_n934
* NET   214 = abc_8306_new_n933
* NET   215 = abc_8306_new_n932
* NET   216 = abc_8306_new_n931
* NET   217 = abc_8306_new_n930
* NET   218 = abc_8306_new_n929
* NET   219 = abc_8306_new_n928
* NET   220 = abc_8306_new_n927
* NET   221 = abc_8306_new_n926
* NET   222 = abc_8306_new_n925
* NET   223 = abc_8306_new_n924
* NET   224 = abc_8306_new_n923
* NET   225 = abc_8306_new_n922
* NET   226 = abc_8306_new_n921
* NET   227 = abc_8306_new_n920
* NET   228 = abc_8306_new_n919
* NET   229 = abc_8306_new_n918
* NET   230 = abc_8306_new_n917
* NET   231 = abc_8306_new_n916
* NET   232 = abc_8306_new_n915
* NET   233 = abc_8306_new_n914
* NET   234 = abc_8306_new_n912
* NET   235 = abc_8306_new_n911
* NET   236 = abc_8306_new_n910
* NET   237 = abc_8306_new_n909
* NET   238 = abc_8306_new_n908
* NET   239 = abc_8306_new_n907
* NET   240 = abc_8306_new_n906
* NET   241 = abc_8306_new_n905
* NET   242 = abc_8306_new_n904
* NET   243 = abc_8306_new_n903
* NET   244 = abc_8306_new_n902
* NET   245 = abc_8306_new_n901
* NET   246 = abc_8306_new_n900
* NET   247 = abc_8306_new_n899
* NET   248 = abc_8306_new_n898
* NET   249 = abc_8306_new_n897
* NET   250 = abc_8306_new_n896
* NET   251 = abc_8306_new_n895
* NET   252 = abc_8306_new_n894
* NET   253 = abc_8306_new_n893
* NET   254 = abc_8306_new_n892
* NET   255 = abc_8306_new_n891
* NET   256 = abc_8306_new_n890
* NET   257 = abc_8306_new_n889
* NET   258 = abc_8306_new_n888
* NET   259 = abc_8306_new_n887
* NET   260 = abc_8306_new_n886
* NET   261 = abc_8306_new_n885
* NET   262 = abc_8306_new_n884
* NET   263 = abc_8306_new_n883
* NET   264 = abc_8306_new_n882
* NET   265 = abc_8306_new_n881
* NET   266 = abc_8306_new_n880
* NET   267 = abc_8306_new_n879
* NET   268 = abc_8306_new_n878
* NET   269 = abc_8306_new_n877
* NET   270 = abc_8306_new_n876
* NET   271 = abc_8306_new_n875
* NET   272 = abc_8306_new_n874
* NET   273 = abc_8306_new_n873
* NET   274 = abc_8306_new_n872
* NET   275 = abc_8306_new_n871
* NET   276 = abc_8306_new_n870
* NET   277 = abc_8306_new_n869
* NET   278 = abc_8306_new_n868
* NET   279 = abc_8306_new_n867
* NET   280 = abc_8306_new_n866
* NET   281 = abc_8306_new_n865
* NET   282 = abc_8306_new_n864
* NET   283 = abc_8306_new_n863
* NET   284 = abc_8306_new_n862
* NET   285 = abc_8306_new_n861
* NET   286 = abc_8306_new_n860
* NET   287 = abc_8306_new_n859
* NET   288 = abc_8306_new_n858
* NET   289 = abc_8306_new_n857
* NET   290 = abc_8306_new_n856
* NET   291 = abc_8306_new_n855
* NET   292 = abc_8306_new_n854
* NET   293 = abc_8306_new_n853
* NET   294 = abc_8306_new_n852
* NET   295 = abc_8306_new_n851
* NET   296 = abc_8306_new_n850
* NET   297 = abc_8306_new_n849
* NET   298 = abc_8306_new_n848
* NET   299 = abc_8306_new_n847
* NET   300 = abc_8306_new_n846
* NET   301 = abc_8306_new_n845
* NET   302 = abc_8306_new_n844
* NET   303 = abc_8306_new_n843
* NET   304 = abc_8306_new_n842
* NET   305 = abc_8306_new_n841
* NET   306 = abc_8306_new_n840
* NET   307 = abc_8306_new_n839
* NET   308 = abc_8306_new_n838
* NET   309 = abc_8306_new_n837
* NET   310 = abc_8306_new_n836
* NET   311 = abc_8306_new_n835
* NET   312 = abc_8306_new_n834
* NET   313 = abc_8306_new_n833
* NET   314 = abc_8306_new_n832
* NET   315 = abc_8306_new_n831
* NET   316 = abc_8306_new_n830
* NET   317 = abc_8306_new_n829
* NET   318 = abc_8306_new_n828
* NET   319 = abc_8306_new_n827
* NET   320 = abc_8306_new_n826
* NET   321 = abc_8306_new_n825
* NET   322 = abc_8306_new_n824
* NET   323 = abc_8306_new_n823
* NET   324 = abc_8306_new_n822
* NET   325 = abc_8306_new_n821
* NET   326 = abc_8306_new_n820
* NET   327 = abc_8306_new_n819
* NET   328 = abc_8306_new_n818
* NET   329 = abc_8306_new_n817
* NET   330 = abc_8306_new_n816
* NET   331 = abc_8306_new_n815
* NET   332 = abc_8306_new_n814
* NET   333 = abc_8306_new_n813
* NET   334 = abc_8306_new_n812
* NET   335 = abc_8306_new_n811
* NET   336 = abc_8306_new_n810
* NET   337 = abc_8306_new_n809
* NET   338 = abc_8306_new_n808
* NET   339 = abc_8306_new_n807
* NET   340 = abc_8306_new_n806
* NET   341 = abc_8306_new_n805
* NET   342 = abc_8306_new_n804
* NET   343 = abc_8306_new_n803
* NET   344 = abc_8306_new_n802
* NET   345 = abc_8306_new_n801
* NET   346 = abc_8306_new_n800
* NET   347 = abc_8306_new_n799
* NET   348 = abc_8306_new_n798
* NET   349 = abc_8306_new_n797
* NET   350 = abc_8306_new_n796
* NET   351 = abc_8306_new_n795
* NET   352 = abc_8306_new_n794
* NET   353 = abc_8306_new_n793
* NET   354 = abc_8306_new_n792
* NET   355 = abc_8306_new_n791
* NET   356 = abc_8306_new_n790
* NET   357 = abc_8306_new_n789
* NET   358 = abc_8306_new_n788
* NET   359 = abc_8306_new_n787
* NET   360 = abc_8306_new_n786
* NET   361 = abc_8306_new_n785
* NET   362 = abc_8306_new_n784
* NET   363 = abc_8306_new_n783
* NET   364 = abc_8306_new_n782
* NET   365 = abc_8306_new_n781
* NET   366 = abc_8306_new_n780
* NET   367 = abc_8306_new_n779
* NET   368 = abc_8306_new_n778
* NET   369 = abc_8306_new_n777
* NET   370 = abc_8306_new_n776
* NET   371 = abc_8306_new_n775
* NET   372 = abc_8306_new_n774
* NET   373 = abc_8306_new_n773
* NET   374 = abc_8306_new_n772
* NET   375 = abc_8306_new_n771
* NET   376 = abc_8306_new_n770
* NET   377 = abc_8306_new_n769
* NET   378 = abc_8306_new_n768
* NET   379 = abc_8306_new_n767
* NET   380 = abc_8306_new_n766
* NET   381 = abc_8306_new_n764
* NET   382 = abc_8306_new_n763
* NET   383 = abc_8306_new_n762
* NET   384 = abc_8306_new_n761
* NET   385 = abc_8306_new_n760
* NET   386 = abc_8306_new_n759
* NET   387 = abc_8306_new_n758
* NET   388 = abc_8306_new_n757
* NET   389 = abc_8306_new_n756
* NET   390 = abc_8306_new_n755
* NET   391 = abc_8306_new_n754
* NET   392 = abc_8306_new_n753
* NET   393 = abc_8306_new_n752
* NET   394 = abc_8306_new_n751
* NET   395 = abc_8306_new_n750
* NET   396 = abc_8306_new_n749
* NET   397 = abc_8306_new_n748
* NET   398 = abc_8306_new_n747
* NET   399 = abc_8306_new_n746
* NET   400 = abc_8306_new_n745
* NET   401 = abc_8306_new_n744
* NET   402 = abc_8306_new_n743
* NET   403 = abc_8306_new_n742
* NET   404 = abc_8306_new_n741
* NET   405 = abc_8306_new_n740
* NET   406 = abc_8306_new_n739
* NET   407 = abc_8306_new_n738
* NET   408 = abc_8306_new_n737
* NET   409 = abc_8306_new_n736
* NET   410 = abc_8306_new_n735
* NET   411 = abc_8306_new_n734
* NET   412 = abc_8306_new_n733
* NET   413 = abc_8306_new_n732
* NET   414 = abc_8306_new_n731
* NET   415 = abc_8306_new_n730
* NET   416 = abc_8306_new_n729
* NET   417 = abc_8306_new_n728
* NET   418 = abc_8306_new_n727
* NET   419 = abc_8306_new_n726
* NET   420 = abc_8306_new_n725
* NET   421 = abc_8306_new_n724
* NET   422 = abc_8306_new_n723
* NET   423 = abc_8306_new_n722
* NET   424 = abc_8306_new_n721
* NET   425 = abc_8306_new_n720
* NET   426 = abc_8306_new_n719
* NET   427 = abc_8306_new_n718
* NET   428 = abc_8306_new_n717
* NET   429 = abc_8306_new_n716
* NET   430 = abc_8306_new_n715
* NET   431 = abc_8306_new_n714
* NET   432 = abc_8306_new_n713
* NET   433 = abc_8306_new_n712
* NET   434 = abc_8306_new_n711
* NET   435 = abc_8306_new_n710
* NET   436 = abc_8306_new_n709
* NET   437 = abc_8306_new_n708
* NET   438 = abc_8306_new_n707
* NET   439 = abc_8306_new_n706
* NET   440 = abc_8306_new_n705
* NET   441 = abc_8306_new_n704
* NET   442 = abc_8306_new_n703
* NET   443 = abc_8306_new_n702
* NET   444 = abc_8306_new_n701
* NET   445 = abc_8306_new_n700
* NET   446 = abc_8306_new_n699
* NET   447 = abc_8306_new_n698
* NET   448 = abc_8306_new_n697
* NET   449 = abc_8306_new_n696
* NET   450 = abc_8306_new_n695
* NET   451 = abc_8306_new_n694
* NET   452 = abc_8306_new_n693
* NET   453 = abc_8306_new_n692
* NET   454 = abc_8306_new_n691
* NET   455 = abc_8306_new_n690
* NET   456 = abc_8306_new_n689
* NET   457 = abc_8306_new_n688
* NET   458 = abc_8306_new_n687
* NET   459 = abc_8306_new_n686
* NET   460 = abc_8306_new_n685
* NET   461 = abc_8306_new_n684
* NET   462 = abc_8306_new_n683
* NET   463 = abc_8306_new_n682
* NET   464 = abc_8306_new_n681
* NET   465 = abc_8306_new_n680
* NET   466 = abc_8306_new_n679
* NET   467 = abc_8306_new_n678
* NET   468 = abc_8306_new_n677
* NET   469 = abc_8306_new_n676
* NET   470 = abc_8306_new_n675
* NET   471 = abc_8306_new_n674
* NET   472 = abc_8306_new_n673
* NET   473 = abc_8306_new_n672
* NET   474 = abc_8306_new_n671
* NET   475 = abc_8306_new_n670
* NET   476 = abc_8306_new_n669
* NET   477 = abc_8306_new_n668
* NET   478 = abc_8306_new_n667
* NET   479 = abc_8306_new_n666
* NET   480 = abc_8306_new_n665
* NET   481 = abc_8306_new_n664
* NET   482 = abc_8306_new_n663
* NET   483 = abc_8306_new_n662
* NET   484 = abc_8306_new_n661
* NET   485 = abc_8306_new_n660
* NET   486 = abc_8306_new_n659
* NET   487 = abc_8306_new_n658
* NET   488 = abc_8306_new_n657
* NET   489 = abc_8306_new_n656
* NET   490 = abc_8306_new_n655
* NET   491 = abc_8306_new_n654
* NET   492 = abc_8306_new_n653
* NET   493 = abc_8306_new_n652
* NET   494 = abc_8306_new_n651
* NET   495 = abc_8306_new_n650
* NET   496 = abc_8306_new_n649
* NET   497 = abc_8306_new_n648
* NET   498 = abc_8306_new_n647
* NET   499 = abc_8306_new_n646
* NET   500 = abc_8306_new_n645
* NET   501 = abc_8306_new_n644
* NET   502 = abc_8306_new_n643
* NET   503 = abc_8306_new_n642
* NET   504 = abc_8306_new_n641
* NET   505 = abc_8306_new_n640
* NET   506 = abc_8306_new_n639
* NET   507 = abc_8306_new_n638
* NET   508 = abc_8306_new_n637
* NET   509 = abc_8306_new_n636
* NET   510 = abc_8306_new_n635
* NET   511 = abc_8306_new_n634
* NET   512 = abc_8306_new_n633
* NET   513 = abc_8306_new_n632
* NET   514 = abc_8306_new_n631
* NET   515 = abc_8306_new_n630
* NET   516 = abc_8306_new_n629
* NET   517 = abc_8306_new_n628
* NET   518 = abc_8306_new_n627
* NET   519 = abc_8306_new_n626
* NET   520 = abc_8306_new_n625
* NET   521 = abc_8306_new_n624
* NET   522 = abc_8306_new_n623
* NET   523 = abc_8306_new_n622
* NET   524 = abc_8306_new_n621
* NET   525 = abc_8306_new_n620
* NET   526 = abc_8306_new_n619
* NET   527 = abc_8306_new_n618
* NET   528 = abc_8306_new_n617
* NET   529 = abc_8306_new_n616
* NET   530 = abc_8306_new_n615
* NET   531 = abc_8306_new_n614
* NET   532 = abc_8306_new_n613
* NET   533 = abc_8306_new_n612
* NET   534 = abc_8306_new_n611
* NET   535 = abc_8306_new_n610
* NET   536 = abc_8306_new_n609
* NET   537 = abc_8306_new_n608
* NET   538 = abc_8306_new_n607
* NET   539 = abc_8306_new_n606
* NET   540 = abc_8306_new_n605
* NET   541 = abc_8306_new_n604
* NET   542 = abc_8306_new_n603
* NET   543 = abc_8306_new_n602
* NET   544 = abc_8306_new_n601
* NET   545 = abc_8306_new_n600
* NET   546 = abc_8306_new_n599
* NET   547 = abc_8306_new_n598
* NET   548 = abc_8306_new_n597
* NET   549 = abc_8306_new_n596
* NET   550 = abc_8306_new_n595
* NET   551 = abc_8306_new_n594
* NET   552 = abc_8306_new_n593
* NET   553 = abc_8306_new_n592
* NET   554 = abc_8306_new_n591
* NET   555 = abc_8306_new_n590
* NET   556 = abc_8306_new_n589
* NET   557 = abc_8306_new_n588
* NET   558 = abc_8306_new_n587
* NET   559 = abc_8306_new_n586
* NET   560 = abc_8306_new_n585
* NET   561 = abc_8306_new_n584
* NET   562 = abc_8306_new_n583
* NET   563 = abc_8306_new_n582
* NET   564 = abc_8306_new_n581
* NET   565 = abc_8306_new_n580
* NET   566 = abc_8306_new_n579
* NET   567 = abc_8306_new_n578
* NET   568 = abc_8306_new_n577
* NET   569 = abc_8306_new_n576
* NET   570 = abc_8306_new_n575
* NET   571 = abc_8306_new_n574
* NET   572 = abc_8306_new_n573
* NET   573 = abc_8306_new_n572
* NET   574 = abc_8306_new_n571
* NET   575 = abc_8306_new_n570
* NET   576 = abc_8306_new_n569
* NET   577 = abc_8306_new_n568
* NET   578 = abc_8306_new_n567
* NET   579 = abc_8306_new_n566
* NET   580 = abc_8306_new_n565
* NET   581 = abc_8306_new_n564
* NET   582 = abc_8306_new_n563
* NET   583 = abc_8306_new_n562
* NET   584 = abc_8306_new_n561
* NET   585 = abc_8306_new_n560
* NET   586 = abc_8306_new_n559
* NET   587 = abc_8306_new_n558
* NET   588 = abc_8306_new_n557
* NET   589 = abc_8306_new_n556
* NET   590 = abc_8306_new_n555
* NET   591 = abc_8306_new_n554
* NET   592 = abc_8306_new_n553
* NET   593 = abc_8306_new_n552
* NET   594 = abc_8306_new_n551
* NET   595 = abc_8306_new_n550
* NET   596 = abc_8306_new_n549
* NET   597 = abc_8306_new_n548
* NET   598 = abc_8306_new_n547
* NET   599 = abc_8306_new_n546
* NET   600 = abc_8306_new_n545
* NET   601 = abc_8306_new_n544
* NET   602 = abc_8306_new_n543
* NET   603 = abc_8306_new_n542
* NET   604 = abc_8306_new_n541
* NET   605 = abc_8306_new_n540
* NET   606 = abc_8306_new_n539
* NET   607 = abc_8306_new_n538
* NET   608 = abc_8306_new_n537
* NET   609 = abc_8306_new_n536
* NET   610 = abc_8306_new_n535
* NET   611 = abc_8306_new_n534
* NET   612 = abc_8306_new_n533
* NET   613 = abc_8306_new_n532
* NET   614 = abc_8306_new_n531
* NET   615 = abc_8306_new_n530
* NET   616 = abc_8306_new_n529
* NET   617 = abc_8306_new_n528
* NET   618 = abc_8306_new_n527
* NET   619 = abc_8306_new_n526
* NET   620 = abc_8306_new_n525
* NET   621 = abc_8306_new_n524
* NET   622 = abc_8306_new_n523
* NET   623 = abc_8306_new_n522
* NET   624 = abc_8306_new_n521
* NET   625 = abc_8306_new_n520
* NET   626 = abc_8306_new_n519
* NET   627 = abc_8306_new_n518
* NET   628 = abc_8306_new_n517
* NET   629 = abc_8306_new_n516
* NET   630 = abc_8306_new_n515
* NET   631 = abc_8306_new_n514
* NET   632 = abc_8306_new_n513
* NET   633 = abc_8306_new_n512
* NET   634 = abc_8306_new_n511
* NET   635 = abc_8306_new_n510
* NET   636 = abc_8306_new_n509
* NET   637 = abc_8306_new_n508
* NET   638 = abc_8306_new_n507
* NET   639 = abc_8306_new_n506
* NET   640 = abc_8306_new_n505
* NET   641 = abc_8306_new_n504
* NET   642 = abc_8306_new_n503
* NET   643 = abc_8306_new_n501
* NET   644 = abc_8306_new_n500
* NET   645 = abc_8306_new_n499
* NET   646 = abc_8306_new_n498
* NET   647 = abc_8306_new_n497
* NET   648 = abc_8306_new_n496
* NET   649 = abc_8306_new_n495
* NET   650 = abc_8306_new_n494
* NET   651 = abc_8306_new_n493
* NET   652 = abc_8306_new_n492
* NET   653 = abc_8306_new_n491
* NET   654 = abc_8306_new_n490
* NET   655 = abc_8306_new_n489
* NET   656 = abc_8306_new_n488
* NET   657 = abc_8306_new_n487
* NET   658 = abc_8306_new_n486
* NET   659 = abc_8306_new_n485
* NET   660 = abc_8306_new_n484
* NET   661 = abc_8306_new_n483
* NET   662 = abc_8306_new_n482
* NET   663 = abc_8306_new_n481
* NET   664 = abc_8306_new_n480
* NET   665 = abc_8306_new_n479
* NET   666 = abc_8306_new_n478
* NET   667 = abc_8306_new_n477
* NET   668 = abc_8306_new_n476
* NET   669 = abc_8306_new_n475
* NET   670 = abc_8306_new_n474
* NET   671 = abc_8306_new_n473
* NET   672 = abc_8306_new_n472
* NET   673 = abc_8306_new_n471
* NET   674 = abc_8306_new_n470
* NET   675 = abc_8306_new_n469
* NET   676 = abc_8306_new_n468
* NET   677 = abc_8306_new_n467
* NET   678 = abc_8306_new_n466
* NET   679 = abc_8306_new_n465
* NET   680 = abc_8306_new_n464
* NET   681 = abc_8306_new_n463
* NET   682 = abc_8306_new_n462
* NET   683 = abc_8306_new_n461
* NET   684 = abc_8306_new_n460
* NET   685 = abc_8306_new_n459
* NET   686 = abc_8306_new_n458
* NET   687 = abc_8306_new_n457
* NET   688 = abc_8306_new_n456
* NET   689 = abc_8306_new_n455
* NET   690 = abc_8306_new_n454
* NET   691 = abc_8306_new_n453
* NET   692 = abc_8306_new_n452
* NET   693 = abc_8306_new_n451
* NET   694 = abc_8306_new_n450
* NET   695 = abc_8306_new_n449
* NET   696 = abc_8306_new_n448
* NET   697 = abc_8306_new_n447
* NET   698 = abc_8306_new_n446
* NET   699 = abc_8306_new_n445
* NET   700 = abc_8306_new_n444
* NET   701 = abc_8306_new_n443
* NET   702 = abc_8306_new_n442
* NET   703 = abc_8306_new_n441
* NET   704 = abc_8306_new_n440
* NET   705 = abc_8306_new_n439
* NET   706 = abc_8306_new_n438
* NET   707 = abc_8306_new_n437
* NET   708 = abc_8306_new_n436
* NET   709 = abc_8306_new_n435
* NET   710 = abc_8306_new_n434
* NET   711 = abc_8306_new_n433
* NET   712 = abc_8306_new_n432
* NET   713 = abc_8306_new_n431
* NET   714 = abc_8306_new_n430
* NET   715 = abc_8306_new_n429
* NET   716 = abc_8306_new_n428
* NET   717 = abc_8306_new_n427
* NET   718 = abc_8306_new_n426
* NET   719 = abc_8306_new_n425
* NET   720 = abc_8306_new_n424
* NET   721 = abc_8306_new_n423
* NET   722 = abc_8306_new_n422
* NET   723 = abc_8306_new_n421
* NET   724 = abc_8306_new_n420
* NET   725 = abc_8306_new_n419
* NET   726 = abc_8306_new_n418
* NET   727 = abc_8306_new_n417
* NET   728 = abc_8306_new_n416
* NET   729 = abc_8306_new_n415
* NET   730 = abc_8306_new_n414
* NET   731 = abc_8306_new_n413
* NET   732 = abc_8306_new_n412
* NET   733 = abc_8306_new_n411
* NET   734 = abc_8306_new_n410
* NET   735 = abc_8306_new_n409
* NET   736 = abc_8306_new_n408
* NET   737 = abc_8306_new_n407
* NET   738 = abc_8306_new_n406
* NET   739 = abc_8306_new_n405
* NET   740 = abc_8306_new_n404
* NET   741 = abc_8306_new_n403
* NET   742 = abc_8306_new_n402
* NET   743 = abc_8306_new_n401
* NET   744 = abc_8306_new_n400
* NET   745 = abc_8306_new_n399
* NET   746 = abc_8306_new_n398
* NET   747 = abc_8306_new_n397
* NET   748 = abc_8306_new_n395
* NET   749 = abc_8306_new_n394
* NET   750 = abc_8306_new_n393
* NET   751 = abc_8306_new_n392
* NET   752 = abc_8306_new_n391
* NET   753 = abc_8306_new_n390
* NET   754 = abc_8306_new_n389
* NET   755 = abc_8306_new_n388
* NET   756 = abc_8306_new_n387
* NET   757 = abc_8306_new_n386
* NET   758 = abc_8306_new_n385
* NET   759 = abc_8306_new_n384
* NET   760 = abc_8306_new_n383
* NET   761 = abc_8306_new_n382
* NET   762 = abc_8306_new_n381
* NET   763 = abc_8306_new_n380
* NET   764 = abc_8306_new_n379
* NET   765 = abc_8306_new_n378
* NET   766 = abc_8306_new_n377
* NET   767 = abc_8306_new_n376
* NET   768 = abc_8306_new_n375
* NET   769 = abc_8306_new_n374
* NET   770 = abc_8306_new_n373
* NET   771 = abc_8306_new_n372
* NET   772 = abc_8306_new_n371
* NET   773 = abc_8306_new_n370
* NET   774 = abc_8306_new_n369
* NET   775 = abc_8306_new_n368
* NET   776 = abc_8306_new_n367
* NET   777 = abc_8306_new_n366
* NET   778 = abc_8306_new_n365
* NET   779 = abc_8306_new_n364
* NET   780 = abc_8306_new_n363
* NET   781 = abc_8306_new_n362
* NET   782 = abc_8306_new_n361
* NET   783 = abc_8306_new_n360
* NET   784 = abc_8306_new_n359
* NET   785 = abc_8306_new_n358
* NET   786 = abc_8306_new_n357
* NET   787 = abc_8306_new_n356
* NET   788 = abc_8306_new_n355
* NET   789 = abc_8306_new_n354
* NET   790 = abc_8306_new_n353
* NET   791 = abc_8306_new_n352
* NET   792 = abc_8306_new_n351
* NET   793 = abc_8306_new_n350
* NET   794 = abc_8306_new_n349
* NET   795 = abc_8306_new_n348
* NET   796 = abc_8306_new_n347
* NET   797 = abc_8306_new_n346
* NET   798 = abc_8306_new_n345
* NET   799 = abc_8306_new_n344
* NET   800 = abc_8306_new_n343
* NET   801 = abc_8306_new_n342
* NET   802 = abc_8306_new_n341
* NET   803 = abc_8306_new_n340
* NET   804 = abc_8306_new_n339
* NET   805 = abc_8306_new_n338
* NET   806 = abc_8306_new_n337
* NET   807 = abc_8306_new_n336
* NET   808 = abc_8306_new_n335
* NET   809 = abc_8306_new_n334
* NET   810 = abc_8306_new_n333
* NET   811 = abc_8306_new_n332
* NET   812 = abc_8306_new_n331
* NET   813 = abc_8306_new_n330
* NET   814 = abc_8306_new_n329
* NET   815 = abc_8306_new_n327
* NET   816 = abc_8306_new_n326
* NET   817 = abc_8306_new_n325
* NET   818 = abc_8306_new_n324
* NET   819 = abc_8306_new_n323
* NET   820 = abc_8306_new_n322
* NET   821 = abc_8306_new_n321
* NET   822 = abc_8306_new_n320
* NET   823 = abc_8306_new_n319
* NET   824 = abc_8306_new_n318
* NET   825 = abc_8306_new_n317
* NET   826 = abc_8306_new_n316
* NET   827 = abc_8306_new_n315
* NET   828 = abc_8306_new_n314
* NET   829 = abc_8306_new_n313
* NET   830 = abc_8306_new_n312
* NET   831 = abc_8306_new_n311
* NET   832 = abc_8306_new_n310
* NET   833 = abc_8306_new_n309
* NET   834 = abc_8306_new_n308
* NET   835 = abc_8306_new_n307
* NET   836 = abc_8306_new_n306
* NET   837 = abc_8306_new_n305
* NET   838 = abc_8306_new_n304
* NET   839 = abc_8306_new_n303
* NET   840 = abc_8306_new_n302
* NET   841 = abc_8306_new_n301
* NET   842 = abc_8306_new_n300
* NET   843 = abc_8306_new_n299
* NET   844 = abc_8306_new_n298
* NET   845 = abc_8306_new_n297
* NET   846 = abc_8306_new_n296
* NET   847 = abc_8306_new_n295
* NET   848 = abc_8306_new_n294
* NET   849 = abc_8306_new_n293
* NET   850 = abc_8306_new_n292
* NET   851 = abc_8306_new_n291
* NET   852 = abc_8306_new_n290
* NET   853 = abc_8306_new_n289
* NET   854 = abc_8306_new_n288
* NET   855 = abc_8306_new_n287
* NET   856 = abc_8306_new_n286
* NET   857 = abc_8306_new_n285
* NET   858 = abc_8306_new_n284
* NET   859 = abc_8306_new_n283
* NET   860 = abc_8306_new_n282
* NET   861 = abc_8306_new_n281
* NET   862 = abc_8306_new_n280
* NET   863 = abc_8306_new_n279
* NET   864 = abc_8306_new_n278
* NET   865 = abc_8306_new_n277
* NET   866 = abc_8306_new_n276
* NET   867 = abc_8306_new_n275
* NET   868 = abc_8306_new_n274
* NET   869 = abc_8306_new_n273
* NET   870 = abc_8306_new_n272
* NET   871 = abc_8306_new_n271
* NET   872 = abc_8306_new_n270
* NET   873 = abc_8306_new_n269
* NET   874 = abc_8306_new_n268
* NET   875 = abc_8306_new_n267
* NET   876 = abc_8306_new_n266
* NET   877 = abc_8306_new_n265
* NET   878 = abc_8306_new_n264
* NET   879 = abc_8306_new_n263
* NET   880 = abc_8306_new_n262
* NET   881 = abc_8306_new_n261
* NET   882 = abc_8306_new_n260
* NET   883 = abc_8306_new_n259
* NET   884 = abc_8306_new_n258
* NET   885 = abc_8306_new_n257
* NET   886 = abc_8306_new_n256
* NET   887 = abc_8306_new_n255
* NET   888 = abc_8306_new_n254
* NET   889 = abc_8306_new_n253
* NET   890 = abc_8306_new_n252
* NET   891 = abc_8306_new_n251
* NET   892 = abc_8306_new_n250
* NET   893 = abc_8306_new_n249
* NET   894 = abc_8306_new_n248
* NET   895 = abc_8306_new_n247
* NET   896 = abc_8306_new_n246
* NET   897 = abc_8306_new_n245
* NET   898 = abc_8306_new_n244
* NET   899 = abc_8306_new_n243
* NET   900 = abc_8306_new_n242
* NET   901 = abc_8306_new_n241
* NET   902 = abc_8306_new_n240
* NET   903 = abc_8306_new_n239
* NET   904 = abc_8306_new_n238
* NET   905 = abc_8306_new_n237
* NET   906 = abc_8306_new_n236
* NET   907 = abc_8306_new_n235
* NET   908 = abc_8306_new_n234
* NET   909 = abc_8306_new_n233
* NET   910 = abc_8306_new_n232
* NET   911 = abc_8306_new_n1799
* NET   912 = abc_8306_new_n1798
* NET   913 = abc_8306_new_n1797
* NET   914 = abc_8306_new_n1796
* NET   915 = abc_8306_new_n1795
* NET   916 = abc_8306_new_n1794
* NET   917 = abc_8306_new_n1793
* NET   918 = abc_8306_new_n1792
* NET   919 = abc_8306_new_n1791
* NET   920 = abc_8306_new_n1789
* NET   921 = abc_8306_new_n1788
* NET   922 = abc_8306_new_n1787
* NET   923 = abc_8306_new_n1786
* NET   924 = abc_8306_new_n1785
* NET   925 = abc_8306_new_n1783
* NET   926 = abc_8306_new_n1782
* NET   927 = abc_8306_new_n1780
* NET   928 = abc_8306_new_n1779
* NET   929 = abc_8306_new_n1778
* NET   930 = abc_8306_new_n1777
* NET   931 = abc_8306_new_n1776
* NET   932 = abc_8306_new_n1775
* NET   933 = abc_8306_new_n1774
* NET   934 = abc_8306_new_n1773
* NET   935 = abc_8306_new_n1772
* NET   936 = abc_8306_new_n1770
* NET   937 = abc_8306_new_n1769
* NET   938 = abc_8306_new_n1768
* NET   939 = abc_8306_new_n1767
* NET   940 = abc_8306_new_n1765
* NET   941 = abc_8306_new_n1764
* NET   942 = abc_8306_new_n1754
* NET   943 = abc_8306_new_n1753
* NET   944 = abc_8306_new_n1752
* NET   945 = abc_8306_new_n1743
* NET   946 = abc_8306_new_n1742
* NET   947 = abc_8306_new_n1733
* NET   948 = abc_8306_new_n1732
* NET   949 = abc_8306_new_n1723
* NET   950 = abc_8306_new_n1722
* NET   951 = abc_8306_new_n1721
* NET   952 = abc_8306_new_n1719
* NET   953 = abc_8306_new_n1718
* NET   954 = abc_8306_new_n1717
* NET   955 = abc_8306_new_n1716
* NET   956 = abc_8306_new_n1715
* NET   957 = abc_8306_new_n1714
* NET   958 = abc_8306_new_n1712
* NET   959 = abc_8306_new_n1711
* NET   960 = abc_8306_new_n1710
* NET   961 = abc_8306_new_n1709
* NET   962 = abc_8306_new_n1708
* NET   963 = abc_8306_new_n1707
* NET   964 = abc_8306_new_n1705
* NET   965 = abc_8306_new_n1704
* NET   966 = abc_8306_new_n1703
* NET   967 = abc_8306_new_n1702
* NET   968 = abc_8306_new_n1701
* NET   969 = abc_8306_new_n1700
* NET   970 = abc_8306_new_n1698
* NET   971 = abc_8306_new_n1697
* NET   972 = abc_8306_new_n1696
* NET   973 = abc_8306_new_n1695
* NET   974 = abc_8306_new_n1694
* NET   975 = abc_8306_new_n1692
* NET   976 = abc_8306_new_n1691
* NET   977 = abc_8306_new_n1690
* NET   978 = abc_8306_new_n1689
* NET   979 = abc_8306_new_n1688
* NET   980 = abc_8306_new_n1687
* NET   981 = abc_8306_new_n1685
* NET   982 = abc_8306_new_n1684
* NET   983 = abc_8306_new_n1683
* NET   984 = abc_8306_new_n1682
* NET   985 = abc_8306_new_n1681
* NET   986 = abc_8306_new_n1680
* NET   987 = abc_8306_new_n1678
* NET   988 = abc_8306_new_n1677
* NET   989 = abc_8306_new_n1676
* NET   990 = abc_8306_new_n1675
* NET   991 = abc_8306_new_n1674
* NET   992 = abc_8306_new_n1672
* NET   993 = abc_8306_new_n1671
* NET   994 = abc_8306_new_n1670
* NET   995 = abc_8306_new_n1669
* NET   996 = abc_8306_new_n1668
* NET   997 = abc_8306_new_n1667
* NET   998 = abc_8306_new_n1666
* NET   999 = abc_8306_new_n1665
* NET  1000 = abc_8306_new_n1656
* NET  1001 = abc_8306_new_n1655
* NET  1002 = abc_8306_new_n1654
* NET  1003 = abc_8306_new_n1653
* NET  1004 = abc_8306_new_n1652
* NET  1005 = abc_8306_new_n1651
* NET  1006 = abc_8306_new_n1641
* NET  1007 = abc_8306_new_n1640
* NET  1008 = abc_8306_new_n1639
* NET  1009 = abc_8306_new_n1638
* NET  1010 = abc_8306_new_n1637
* NET  1011 = abc_8306_new_n1636
* NET  1012 = abc_8306_new_n1634
* NET  1013 = abc_8306_new_n1633
* NET  1014 = abc_8306_new_n1632
* NET  1015 = abc_8306_new_n1631
* NET  1016 = abc_8306_new_n1630
* NET  1017 = abc_8306_new_n1629
* NET  1018 = abc_8306_new_n1627
* NET  1019 = abc_8306_new_n1626
* NET  1020 = abc_8306_new_n1625
* NET  1021 = abc_8306_new_n1624
* NET  1022 = abc_8306_new_n1623
* NET  1023 = abc_8306_new_n1622
* NET  1024 = abc_8306_new_n1620
* NET  1025 = abc_8306_new_n1619
* NET  1026 = abc_8306_new_n1618
* NET  1027 = abc_8306_new_n1617
* NET  1028 = abc_8306_new_n1616
* NET  1029 = abc_8306_new_n1614
* NET  1030 = abc_8306_new_n1613
* NET  1031 = abc_8306_new_n1612
* NET  1032 = abc_8306_new_n1611
* NET  1033 = abc_8306_new_n1610
* NET  1034 = abc_8306_new_n1609
* NET  1035 = abc_8306_new_n1607
* NET  1036 = abc_8306_new_n1606
* NET  1037 = abc_8306_new_n1605
* NET  1038 = abc_8306_new_n1604
* NET  1039 = abc_8306_new_n1603
* NET  1040 = abc_8306_new_n1602
* NET  1041 = abc_8306_new_n1600
* NET  1042 = abc_8306_new_n1599
* NET  1043 = abc_8306_new_n1598
* NET  1044 = abc_8306_new_n1597
* NET  1045 = abc_8306_new_n1596
* NET  1046 = abc_8306_new_n1595
* NET  1047 = abc_8306_new_n1593
* NET  1048 = abc_8306_new_n1592
* NET  1049 = abc_8306_new_n1591
* NET  1050 = abc_8306_new_n1590
* NET  1051 = abc_8306_new_n1589
* NET  1052 = abc_8306_new_n1588
* NET  1053 = abc_8306_new_n1587
* NET  1054 = abc_8306_new_n1586
* NET  1055 = abc_8306_new_n1585
* NET  1056 = abc_8306_new_n1584
* NET  1057 = abc_8306_new_n1583
* NET  1058 = abc_8306_new_n1582
* NET  1059 = abc_8306_new_n1581
* NET  1060 = abc_8306_new_n1579
* NET  1061 = abc_8306_new_n1578
* NET  1062 = abc_8306_new_n1577
* NET  1063 = abc_8306_new_n1576
* NET  1064 = abc_8306_new_n1575
* NET  1065 = abc_8306_new_n1574
* NET  1066 = abc_8306_new_n1573
* NET  1067 = abc_8306_new_n1572
* NET  1068 = abc_8306_new_n1571
* NET  1069 = abc_8306_new_n1570
* NET  1070 = abc_8306_new_n1569
* NET  1071 = abc_8306_new_n1568
* NET  1072 = abc_8306_new_n1566
* NET  1073 = abc_8306_new_n1565
* NET  1074 = abc_8306_new_n1564
* NET  1075 = abc_8306_new_n1563
* NET  1076 = abc_8306_new_n1562
* NET  1077 = abc_8306_new_n1561
* NET  1078 = abc_8306_new_n1560
* NET  1079 = abc_8306_new_n1559
* NET  1080 = abc_8306_new_n1558
* NET  1081 = abc_8306_new_n1557
* NET  1082 = abc_8306_new_n1556
* NET  1083 = abc_8306_new_n1555
* NET  1084 = abc_8306_new_n1553
* NET  1085 = abc_8306_new_n1552
* NET  1086 = abc_8306_new_n1551
* NET  1087 = abc_8306_new_n1550
* NET  1088 = abc_8306_new_n1549
* NET  1089 = abc_8306_new_n1548
* NET  1090 = abc_8306_new_n1547
* NET  1091 = abc_8306_new_n1546
* NET  1092 = abc_8306_new_n1545
* NET  1093 = abc_8306_new_n1544
* NET  1094 = abc_8306_new_n1543
* NET  1095 = abc_8306_new_n1542
* NET  1096 = abc_8306_new_n1540
* NET  1097 = abc_8306_new_n1539
* NET  1098 = abc_8306_new_n1538
* NET  1099 = abc_8306_new_n1537
* NET  1100 = abc_8306_new_n1536
* NET  1101 = abc_8306_new_n1535
* NET  1102 = abc_8306_new_n1534
* NET  1103 = abc_8306_new_n1533
* NET  1104 = abc_8306_new_n1532
* NET  1105 = abc_8306_new_n1531
* NET  1106 = abc_8306_new_n1530
* NET  1107 = abc_8306_new_n1528
* NET  1108 = abc_8306_new_n1527
* NET  1109 = abc_8306_new_n1526
* NET  1110 = abc_8306_new_n1525
* NET  1111 = abc_8306_new_n1524
* NET  1112 = abc_8306_new_n1523
* NET  1113 = abc_8306_new_n1522
* NET  1114 = abc_8306_new_n1521
* NET  1115 = abc_8306_new_n1520
* NET  1116 = abc_8306_new_n1519
* NET  1117 = abc_8306_new_n1518
* NET  1118 = abc_8306_new_n1517
* NET  1119 = abc_8306_new_n1516
* NET  1120 = abc_8306_new_n1514
* NET  1121 = abc_8306_new_n1513
* NET  1122 = abc_8306_new_n1512
* NET  1123 = abc_8306_new_n1511
* NET  1124 = abc_8306_new_n1510
* NET  1125 = abc_8306_new_n1509
* NET  1126 = abc_8306_new_n1508
* NET  1127 = abc_8306_new_n1507
* NET  1128 = abc_8306_new_n1506
* NET  1129 = abc_8306_new_n1505
* NET  1130 = abc_8306_new_n1504
* NET  1131 = abc_8306_new_n1503
* NET  1132 = abc_8306_new_n1502
* NET  1133 = abc_8306_new_n1501
* NET  1134 = abc_8306_new_n1500
* NET  1135 = abc_8306_new_n1498
* NET  1136 = abc_8306_new_n1497
* NET  1137 = abc_8306_new_n1496
* NET  1138 = abc_8306_new_n1495
* NET  1139 = abc_8306_new_n1494
* NET  1140 = abc_8306_new_n1493
* NET  1141 = abc_8306_new_n1492
* NET  1142 = abc_8306_new_n1491
* NET  1143 = abc_8306_new_n1490
* NET  1144 = abc_8306_new_n1489
* NET  1145 = abc_8306_new_n1488
* NET  1146 = abc_8306_new_n1487
* NET  1147 = abc_8306_new_n1486
* NET  1148 = abc_8306_new_n1485
* NET  1149 = abc_8306_new_n1484
* NET  1150 = abc_8306_new_n1482
* NET  1151 = abc_8306_new_n1481
* NET  1152 = abc_8306_new_n1480
* NET  1153 = abc_8306_new_n1479
* NET  1154 = abc_8306_new_n1478
* NET  1155 = abc_8306_new_n1477
* NET  1156 = abc_8306_new_n1476
* NET  1157 = abc_8306_new_n1475
* NET  1158 = abc_8306_new_n1474
* NET  1159 = abc_8306_new_n1473
* NET  1160 = abc_8306_new_n1472
* NET  1161 = abc_8306_new_n1471
* NET  1162 = abc_8306_new_n1470
* NET  1163 = abc_8306_new_n1469
* NET  1164 = abc_8306_new_n1468
* NET  1165 = abc_8306_new_n1467
* NET  1166 = abc_8306_new_n1466
* NET  1167 = abc_8306_new_n1465
* NET  1168 = abc_8306_new_n1464
* NET  1169 = abc_8306_new_n1463
* NET  1170 = abc_8306_new_n1462
* NET  1171 = abc_8306_new_n1461
* NET  1172 = abc_8306_new_n1460
* NET  1173 = abc_8306_new_n1459
* NET  1174 = abc_8306_new_n1458
* NET  1175 = abc_8306_new_n1456
* NET  1176 = abc_8306_new_n1455
* NET  1177 = abc_8306_new_n1454
* NET  1178 = abc_8306_new_n1453
* NET  1179 = abc_8306_new_n1452
* NET  1180 = abc_8306_new_n1451
* NET  1181 = abc_8306_new_n1450
* NET  1182 = abc_8306_new_n1449
* NET  1183 = abc_8306_new_n1448
* NET  1184 = abc_8306_new_n1446
* NET  1185 = abc_8306_new_n1445
* NET  1186 = abc_8306_new_n1444
* NET  1187 = abc_8306_new_n1443
* NET  1188 = abc_8306_new_n1442
* NET  1189 = abc_8306_new_n1441
* NET  1190 = abc_8306_new_n1440
* NET  1191 = abc_8306_new_n1439
* NET  1192 = abc_8306_new_n1438
* NET  1193 = abc_8306_new_n1437
* NET  1194 = abc_8306_new_n1435
* NET  1195 = abc_8306_new_n1434
* NET  1196 = abc_8306_new_n1433
* NET  1197 = abc_8306_new_n1432
* NET  1198 = abc_8306_new_n1431
* NET  1199 = abc_8306_new_n1430
* NET  1200 = abc_8306_new_n1429
* NET  1201 = abc_8306_new_n1428
* NET  1202 = abc_8306_new_n1427
* NET  1203 = abc_8306_new_n1426
* NET  1204 = abc_8306_new_n1424
* NET  1205 = abc_8306_new_n1423
* NET  1206 = abc_8306_new_n1422
* NET  1207 = abc_8306_new_n1421
* NET  1208 = abc_8306_new_n1420
* NET  1209 = abc_8306_new_n1419
* NET  1210 = abc_8306_new_n1418
* NET  1211 = abc_8306_new_n1417
* NET  1212 = abc_8306_new_n1416
* NET  1213 = abc_8306_new_n1414
* NET  1214 = abc_8306_new_n1413
* NET  1215 = abc_8306_new_n1412
* NET  1216 = abc_8306_new_n1411
* NET  1217 = abc_8306_new_n1410
* NET  1218 = abc_8306_new_n1409
* NET  1219 = abc_8306_new_n1408
* NET  1220 = abc_8306_new_n1407
* NET  1221 = abc_8306_new_n1406
* NET  1222 = abc_8306_new_n1405
* NET  1223 = abc_8306_new_n1403
* NET  1224 = abc_8306_new_n1402
* NET  1225 = abc_8306_new_n1401
* NET  1226 = abc_8306_new_n1400
* NET  1227 = abc_8306_new_n1399
* NET  1228 = abc_8306_new_n1398
* NET  1229 = abc_8306_new_n1397
* NET  1230 = abc_8306_new_n1396
* NET  1231 = abc_8306_new_n1395
* NET  1232 = abc_8306_new_n1394
* NET  1233 = abc_8306_new_n1392
* NET  1234 = abc_8306_new_n1391
* NET  1235 = abc_8306_new_n1390
* NET  1236 = abc_8306_new_n1389
* NET  1237 = abc_8306_new_n1388
* NET  1238 = abc_8306_new_n1387
* NET  1239 = abc_8306_new_n1386
* NET  1240 = abc_8306_new_n1385
* NET  1241 = abc_8306_new_n1384
* NET  1242 = abc_8306_new_n1383
* NET  1243 = abc_8306_new_n1381
* NET  1244 = abc_8306_new_n1380
* NET  1245 = abc_8306_new_n1379
* NET  1246 = abc_8306_new_n1378
* NET  1247 = abc_8306_new_n1377
* NET  1248 = abc_8306_new_n1376
* NET  1249 = abc_8306_new_n1375
* NET  1250 = abc_8306_new_n1374
* NET  1251 = abc_8306_new_n1373
* NET  1252 = abc_8306_new_n1372
* NET  1253 = abc_8306_new_n1371
* NET  1254 = abc_8306_new_n1370
* NET  1255 = abc_8306_new_n1369
* NET  1256 = abc_8306_new_n1368
* NET  1257 = abc_8306_new_n1367
* NET  1258 = abc_8306_new_n1366
* NET  1259 = abc_8306_new_n1365
* NET  1260 = abc_8306_new_n1364
* NET  1261 = abc_8306_new_n1363
* NET  1262 = abc_8306_new_n1362
* NET  1263 = abc_8306_new_n1361
* NET  1264 = abc_8306_new_n1360
* NET  1265 = abc_8306_new_n1359
* NET  1266 = abc_8306_new_n1358
* NET  1267 = abc_8306_new_n1357
* NET  1268 = abc_8306_new_n1356
* NET  1269 = abc_8306_new_n1355
* NET  1270 = abc_8306_new_n1354
* NET  1271 = abc_8306_new_n1353
* NET  1272 = abc_8306_new_n1352
* NET  1273 = abc_8306_new_n1351
* NET  1274 = abc_8306_new_n1350
* NET  1275 = abc_8306_new_n1349
* NET  1276 = abc_8306_new_n1348
* NET  1277 = abc_8306_new_n1346
* NET  1278 = abc_8306_new_n1345
* NET  1279 = abc_8306_new_n1344
* NET  1280 = abc_8306_new_n1343
* NET  1281 = abc_8306_new_n1342
* NET  1282 = abc_8306_new_n1341
* NET  1283 = abc_8306_new_n1340
* NET  1284 = abc_8306_new_n1339
* NET  1285 = abc_8306_new_n1338
* NET  1286 = abc_8306_new_n1337
* NET  1287 = abc_8306_new_n1336
* NET  1288 = abc_8306_new_n1335
* NET  1289 = abc_8306_new_n1334
* NET  1290 = abc_8306_new_n1333
* NET  1291 = abc_8306_new_n1332
* NET  1292 = abc_8306_new_n1331
* NET  1293 = abc_8306_new_n1330
* NET  1294 = abc_8306_new_n1329
* NET  1295 = abc_8306_new_n1328
* NET  1296 = abc_8306_new_n1327
* NET  1297 = abc_8306_new_n1326
* NET  1298 = abc_8306_new_n1325
* NET  1299 = abc_8306_new_n1324
* NET  1300 = abc_8306_new_n1323
* NET  1301 = abc_8306_new_n1322
* NET  1302 = abc_8306_new_n1319
* NET  1303 = abc_8306_new_n1317
* NET  1304 = abc_8306_new_n1316
* NET  1305 = abc_8306_new_n1315
* NET  1306 = abc_8306_new_n1312
* NET  1307 = abc_8306_new_n1311
* NET  1308 = abc_8306_new_n1310
* NET  1309 = abc_8306_new_n1309
* NET  1310 = abc_8306_new_n1308
* NET  1311 = abc_8306_new_n1307
* NET  1312 = abc_8306_new_n1305
* NET  1313 = abc_8306_new_n1303
* NET  1314 = abc_8306_new_n1301
* NET  1315 = abc_8306_new_n1299
* NET  1316 = abc_8306_new_n1297
* NET  1317 = abc_8306_new_n1295
* NET  1318 = abc_8306_new_n1293
* NET  1319 = abc_8306_new_n1292
* NET  1320 = abc_8306_new_n1291
* NET  1321 = abc_8306_new_n1290
* NET  1322 = abc_8306_new_n1289
* NET  1323 = abc_8306_new_n1288
* NET  1324 = abc_8306_new_n1287
* NET  1325 = abc_8306_new_n1286
* NET  1326 = abc_8306_new_n1285
* NET  1327 = abc_8306_new_n1284
* NET  1328 = abc_8306_new_n1283
* NET  1329 = abc_8306_new_n1282
* NET  1330 = abc_8306_new_n1281
* NET  1331 = abc_8306_new_n1280
* NET  1332 = abc_8306_new_n1279
* NET  1333 = abc_8306_new_n1278
* NET  1334 = abc_8306_new_n1277
* NET  1335 = abc_8306_new_n1276
* NET  1336 = abc_8306_new_n1275
* NET  1337 = abc_8306_new_n1274
* NET  1338 = abc_8306_new_n1273
* NET  1339 = abc_8306_new_n1272
* NET  1340 = abc_8306_new_n1271
* NET  1341 = abc_8306_new_n1270
* NET  1342 = abc_8306_new_n1269
* NET  1343 = abc_8306_new_n1268
* NET  1344 = abc_8306_new_n1267
* NET  1345 = abc_8306_new_n1266
* NET  1346 = abc_8306_new_n1265
* NET  1347 = abc_8306_new_n1264
* NET  1348 = abc_8306_new_n1263
* NET  1349 = abc_8306_new_n1262
* NET  1350 = abc_8306_new_n1261
* NET  1351 = abc_8306_new_n1260
* NET  1352 = abc_8306_new_n1259
* NET  1353 = abc_8306_new_n1258
* NET  1354 = abc_8306_new_n1257
* NET  1355 = abc_8306_new_n1256
* NET  1356 = abc_8306_new_n1255
* NET  1357 = abc_8306_new_n1254
* NET  1358 = abc_8306_new_n1253
* NET  1359 = abc_8306_new_n1252
* NET  1360 = abc_8306_new_n1251
* NET  1361 = abc_8306_new_n1250
* NET  1362 = abc_8306_new_n1249
* NET  1363 = abc_8306_new_n1248
* NET  1364 = abc_8306_new_n1247
* NET  1365 = abc_8306_new_n1246
* NET  1366 = abc_8306_new_n1245
* NET  1367 = abc_8306_new_n1244
* NET  1368 = abc_8306_new_n1243
* NET  1369 = abc_8306_new_n1242
* NET  1370 = abc_8306_new_n1240
* NET  1371 = abc_8306_new_n1238
* NET  1372 = abc_8306_new_n1237
* NET  1373 = abc_8306_new_n1235
* NET  1374 = abc_8306_new_n1234
* NET  1375 = abc_8306_new_n1233
* NET  1376 = abc_8306_new_n1232
* NET  1377 = abc_8306_new_n1231
* NET  1378 = abc_8306_new_n1230
* NET  1379 = abc_8306_new_n1229
* NET  1380 = abc_8306_new_n1228
* NET  1381 = abc_8306_new_n1227
* NET  1382 = abc_8306_new_n1226
* NET  1383 = abc_8306_new_n1225
* NET  1384 = abc_8306_new_n1224
* NET  1385 = abc_8306_new_n1223
* NET  1386 = abc_8306_new_n1222
* NET  1387 = abc_8306_new_n1221
* NET  1388 = abc_8306_new_n1220
* NET  1389 = abc_8306_new_n1219
* NET  1390 = abc_8306_new_n1218
* NET  1391 = abc_8306_new_n1217
* NET  1392 = abc_8306_new_n1216
* NET  1393 = abc_8306_new_n1215
* NET  1394 = abc_8306_new_n1213
* NET  1395 = abc_8306_new_n1212
* NET  1396 = abc_8306_new_n1211
* NET  1397 = abc_8306_new_n1210
* NET  1398 = abc_8306_new_n1209
* NET  1399 = abc_8306_new_n1208
* NET  1400 = abc_8306_new_n1207
* NET  1401 = abc_8306_new_n1206
* NET  1402 = abc_8306_new_n1205
* NET  1403 = abc_8306_new_n1204
* NET  1404 = abc_8306_new_n1203
* NET  1405 = abc_8306_new_n1202
* NET  1406 = abc_8306_new_n1201
* NET  1407 = abc_8306_new_n1200
* NET  1408 = abc_8306_new_n1199
* NET  1409 = abc_8306_new_n1198
* NET  1410 = abc_8306_new_n1197
* NET  1411 = abc_8306_new_n1196
* NET  1412 = abc_8306_new_n1195
* NET  1413 = abc_8306_new_n1194
* NET  1414 = abc_8306_new_n1193
* NET  1415 = abc_8306_new_n1191
* NET  1416 = abc_8306_new_n1190
* NET  1417 = abc_8306_new_n1189
* NET  1418 = abc_8306_new_n1188
* NET  1419 = abc_8306_new_n1187
* NET  1420 = abc_8306_new_n1186
* NET  1421 = abc_8306_new_n1185
* NET  1422 = abc_8306_new_n1184
* NET  1423 = abc_8306_new_n1183
* NET  1424 = abc_8306_new_n1182
* NET  1425 = abc_8306_new_n1181
* NET  1426 = abc_8306_new_n1180
* NET  1427 = abc_8306_new_n1179
* NET  1428 = abc_8306_new_n1178
* NET  1429 = abc_8306_new_n1177
* NET  1430 = abc_8306_new_n1176
* NET  1431 = abc_8306_new_n1175
* NET  1432 = abc_8306_new_n1174
* NET  1433 = abc_8306_new_n1173
* NET  1434 = abc_8306_new_n1172
* NET  1435 = abc_8306_new_n1171
* NET  1436 = abc_8306_new_n1170
* NET  1437 = abc_8306_new_n1169
* NET  1438 = abc_8306_new_n1168
* NET  1439 = abc_8306_new_n1167
* NET  1440 = abc_8306_new_n1165
* NET  1441 = abc_8306_new_n1164
* NET  1442 = abc_8306_new_n1163
* NET  1443 = abc_8306_new_n1162
* NET  1444 = abc_8306_new_n1161
* NET  1445 = abc_8306_new_n1160
* NET  1446 = abc_8306_new_n1159
* NET  1447 = abc_8306_new_n1158
* NET  1448 = abc_8306_new_n1157
* NET  1449 = abc_8306_new_n1156
* NET  1450 = abc_8306_new_n1155
* NET  1451 = abc_8306_new_n1154
* NET  1452 = abc_8306_new_n1153
* NET  1453 = abc_8306_new_n1152
* NET  1454 = abc_8306_new_n1151
* NET  1455 = abc_8306_new_n1150
* NET  1456 = abc_8306_new_n1149
* NET  1457 = abc_8306_new_n1148
* NET  1458 = abc_8306_new_n1147
* NET  1459 = abc_8306_new_n1145
* NET  1460 = abc_8306_new_n1144
* NET  1461 = abc_8306_new_n1143
* NET  1462 = abc_8306_new_n1142
* NET  1463 = abc_8306_new_n1141
* NET  1464 = abc_8306_new_n1140
* NET  1465 = abc_8306_new_n1139
* NET  1466 = abc_8306_new_n1138
* NET  1467 = abc_8306_new_n1137
* NET  1468 = abc_8306_new_n1136
* NET  1469 = abc_8306_new_n1135
* NET  1470 = abc_8306_new_n1134
* NET  1471 = abc_8306_new_n1133
* NET  1472 = abc_8306_new_n1132
* NET  1473 = abc_8306_new_n1131
* NET  1474 = abc_8306_new_n1130
* NET  1475 = abc_8306_new_n1129
* NET  1476 = abc_8306_new_n1128
* NET  1477 = abc_8306_new_n1127
* NET  1478 = abc_8306_new_n1126
* NET  1479 = abc_8306_new_n1125
* NET  1480 = abc_8306_new_n1124
* NET  1481 = abc_8306_new_n1123
* NET  1482 = abc_8306_new_n1122
* NET  1483 = abc_8306_new_n1121
* NET  1484 = abc_8306_new_n1120
* NET  1485 = abc_8306_new_n1119
* NET  1486 = abc_8306_new_n1118
* NET  1487 = abc_8306_new_n1117
* NET  1488 = abc_8306_new_n1116
* NET  1489 = abc_8306_new_n1115
* NET  1490 = abc_8306_new_n1114
* NET  1491 = abc_8306_new_n1113
* NET  1492 = abc_8306_new_n1112
* NET  1493 = abc_8306_new_n1111
* NET  1494 = abc_8306_new_n1110
* NET  1495 = abc_8306_new_n1109
* NET  1496 = abc_8306_new_n1108
* NET  1497 = abc_8306_new_n1107
* NET  1498 = abc_8306_new_n1106
* NET  1499 = abc_8306_new_n1105
* NET  1500 = abc_8306_new_n1104
* NET  1501 = abc_8306_new_n1103
* NET  1502 = abc_8306_new_n1102
* NET  1503 = abc_8306_new_n1101
* NET  1504 = abc_8306_new_n1100
* NET  1505 = abc_8306_new_n1099
* NET  1506 = abc_8306_new_n1098
* NET  1507 = abc_8306_new_n1097
* NET  1508 = abc_8306_new_n1096
* NET  1509 = abc_8306_new_n1095
* NET  1510 = abc_8306_new_n1094
* NET  1511 = abc_8306_new_n1093
* NET  1512 = abc_8306_new_n1092
* NET  1513 = abc_8306_new_n1091
* NET  1514 = abc_8306_new_n1090
* NET  1515 = abc_8306_new_n1089
* NET  1516 = abc_8306_new_n1088
* NET  1517 = abc_8306_new_n1087
* NET  1518 = abc_8306_new_n1086
* NET  1519 = abc_8306_new_n1085
* NET  1520 = abc_8306_new_n1084
* NET  1521 = abc_8306_new_n1083
* NET  1522 = abc_8306_new_n1082
* NET  1523 = abc_8306_new_n1081
* NET  1524 = abc_8306_new_n1080
* NET  1525 = abc_8306_new_n1079
* NET  1526 = abc_8306_new_n1078
* NET  1527 = abc_8306_new_n1077
* NET  1528 = abc_8306_new_n1076
* NET  1529 = abc_8306_new_n1075
* NET  1530 = abc_8306_new_n1074
* NET  1531 = abc_8306_new_n1073
* NET  1532 = abc_8306_new_n1072
* NET  1533 = abc_8306_new_n1071
* NET  1534 = abc_8306_new_n1070
* NET  1535 = abc_8306_new_n1069
* NET  1536 = abc_8306_new_n1068
* NET  1537 = abc_8306_new_n1067
* NET  1538 = abc_8306_new_n1066
* NET  1539 = abc_8306_new_n1065
* NET  1540 = abc_8306_new_n1064
* NET  1541 = abc_8306_new_n1063
* NET  1542 = abc_8306_new_n1062
* NET  1543 = abc_8306_new_n1061
* NET  1544 = abc_8306_new_n1060
* NET  1545 = abc_8306_new_n1059
* NET  1546 = abc_8306_new_n1058
* NET  1547 = abc_8306_new_n1057
* NET  1548 = abc_8306_new_n1056
* NET  1549 = abc_8306_new_n1055
* NET  1550 = abc_8306_new_n1054
* NET  1551 = abc_8306_new_n1053
* NET  1552 = abc_8306_new_n1052
* NET  1553 = abc_8306_new_n1051
* NET  1554 = abc_8306_new_n1050
* NET  1555 = abc_8306_new_n1049
* NET  1556 = abc_8306_new_n1048
* NET  1557 = abc_8306_new_n1047
* NET  1558 = abc_8306_new_n1046
* NET  1559 = abc_8306_new_n1045
* NET  1560 = abc_8306_new_n1044
* NET  1561 = abc_8306_new_n1043
* NET  1562 = abc_8306_new_n1042
* NET  1563 = abc_8306_new_n1041
* NET  1564 = abc_8306_new_n1040
* NET  1565 = abc_8306_new_n1039
* NET  1566 = abc_8306_new_n1038
* NET  1567 = abc_8306_new_n1037
* NET  1568 = abc_8306_new_n1036
* NET  1569 = abc_8306_new_n1035
* NET  1570 = abc_8306_new_n1034
* NET  1571 = abc_8306_new_n1033
* NET  1572 = abc_8306_new_n1032
* NET  1573 = abc_8306_new_n1031
* NET  1574 = abc_8306_new_n1030
* NET  1575 = abc_8306_new_n1029
* NET  1576 = abc_8306_new_n1028
* NET  1577 = abc_8306_new_n1027
* NET  1578 = abc_8306_new_n1026
* NET  1579 = abc_8306_new_n1025
* NET  1580 = abc_8306_new_n1023
* NET  1581 = abc_8306_new_n1022
* NET  1582 = abc_8306_new_n1021
* NET  1583 = abc_8306_new_n1020
* NET  1584 = abc_8306_new_n1019
* NET  1585 = abc_8306_new_n1018
* NET  1586 = abc_8306_new_n1017
* NET  1587 = abc_8306_new_n1016
* NET  1588 = abc_8306_new_n1015
* NET  1589 = abc_8306_new_n1014
* NET  1590 = abc_8306_new_n1013
* NET  1591 = abc_8306_new_n1012
* NET  1592 = abc_8306_new_n1011
* NET  1593 = abc_8306_new_n1010
* NET  1594 = abc_8306_new_n1009
* NET  1595 = abc_8306_new_n1008
* NET  1596 = abc_8306_new_n1007
* NET  1597 = abc_8306_new_n1006
* NET  1598 = abc_8306_new_n1005
* NET  1599 = abc_8306_new_n1004
* NET  1600 = abc_8306_new_n1003
* NET  1601 = abc_8306_new_n1002
* NET  1602 = abc_8306_new_n1001
* NET  1603 = abc_8306_new_n1000
* NET  1604 = abc_8306_auto_rtlil_cc_2608_MuxGate_8305
* NET  1605 = abc_8306_auto_rtlil_cc_2608_MuxGate_8303
* NET  1606 = abc_8306_auto_rtlil_cc_2608_MuxGate_8301
* NET  1607 = abc_8306_auto_rtlil_cc_2608_MuxGate_8299
* NET  1608 = abc_8306_auto_rtlil_cc_2608_MuxGate_8297
* NET  1609 = abc_8306_auto_rtlil_cc_2608_MuxGate_8291
* NET  1610 = abc_8306_auto_rtlil_cc_2608_MuxGate_8289
* NET  1611 = abc_8306_auto_rtlil_cc_2608_MuxGate_8287
* NET  1612 = abc_8306_auto_rtlil_cc_2608_MuxGate_8285
* NET  1613 = abc_8306_auto_rtlil_cc_2608_MuxGate_8283
* NET  1614 = abc_8306_auto_rtlil_cc_2608_MuxGate_8281
* NET  1615 = abc_8306_auto_rtlil_cc_2608_MuxGate_8279
* NET  1616 = abc_8306_auto_rtlil_cc_2608_MuxGate_8277
* NET  1617 = abc_8306_auto_rtlil_cc_2608_MuxGate_8275
* NET  1618 = abc_8306_auto_rtlil_cc_2608_MuxGate_8273
* NET  1619 = abc_8306_auto_rtlil_cc_2608_MuxGate_8271
* NET  1620 = abc_8306_auto_rtlil_cc_2608_MuxGate_8269
* NET  1621 = abc_8306_auto_rtlil_cc_2608_MuxGate_8267
* NET  1622 = abc_8306_auto_rtlil_cc_2608_MuxGate_8265
* NET  1623 = abc_8306_auto_rtlil_cc_2608_MuxGate_8263
* NET  1624 = abc_8306_auto_rtlil_cc_2608_MuxGate_8261
* NET  1625 = abc_8306_auto_rtlil_cc_2608_MuxGate_8259
* NET  1626 = abc_8306_auto_rtlil_cc_2608_MuxGate_8257
* NET  1627 = abc_8306_auto_rtlil_cc_2608_MuxGate_8255
* NET  1628 = abc_8306_auto_rtlil_cc_2608_MuxGate_8249
* NET  1629 = abc_8306_auto_rtlil_cc_2608_MuxGate_8243
* NET  1630 = abc_8306_auto_rtlil_cc_2608_MuxGate_8237
* NET  1631 = abc_8306_auto_rtlil_cc_2608_MuxGate_8231
* NET  1632 = abc_8306_auto_rtlil_cc_2608_MuxGate_8225
* NET  1633 = abc_8306_auto_rtlil_cc_2608_MuxGate_8219
* NET  1634 = abc_8306_auto_rtlil_cc_2608_MuxGate_8213
* NET  1635 = abc_8306_auto_rtlil_cc_2608_MuxGate_8207
* NET  1636 = abc_8306_auto_rtlil_cc_2608_MuxGate_8205
* NET  1637 = abc_8306_auto_rtlil_cc_2608_MuxGate_8203
* NET  1638 = abc_8306_auto_rtlil_cc_2608_MuxGate_8201
* NET  1639 = abc_8306_auto_rtlil_cc_2608_MuxGate_8199
* NET  1640 = abc_8306_auto_rtlil_cc_2608_MuxGate_8197
* NET  1641 = abc_8306_auto_rtlil_cc_2608_MuxGate_8195
* NET  1642 = abc_8306_auto_rtlil_cc_2608_MuxGate_8193
* NET  1643 = abc_8306_auto_rtlil_cc_2608_MuxGate_8191
* NET  1644 = abc_8306_auto_rtlil_cc_2608_MuxGate_8189
* NET  1645 = abc_8306_auto_rtlil_cc_2608_MuxGate_8187
* NET  1646 = abc_8306_auto_rtlil_cc_2608_MuxGate_8185
* NET  1647 = abc_8306_auto_rtlil_cc_2608_MuxGate_8183
* NET  1648 = abc_8306_auto_rtlil_cc_2608_MuxGate_8181
* NET  1649 = abc_8306_auto_rtlil_cc_2608_MuxGate_8179
* NET  1650 = abc_8306_auto_rtlil_cc_2608_MuxGate_8177
* NET  1651 = abc_8306_auto_rtlil_cc_2608_MuxGate_8175
* NET  1652 = abc_8306_auto_rtlil_cc_2608_MuxGate_8173
* NET  1653 = abc_8306_auto_rtlil_cc_2608_MuxGate_8171
* NET  1654 = abc_8306_auto_rtlil_cc_2608_MuxGate_8169
* NET  1655 = abc_8306_auto_rtlil_cc_2608_MuxGate_8167
* NET  1656 = abc_8306_auto_rtlil_cc_2608_MuxGate_8165
* NET  1657 = abc_8306_auto_rtlil_cc_2608_MuxGate_8163
* NET  1658 = abc_8306_auto_rtlil_cc_2608_MuxGate_8161
* NET  1659 = abc_8306_auto_rtlil_cc_2608_MuxGate_8159
* NET  1660 = abc_8306_auto_rtlil_cc_2608_MuxGate_8157
* NET  1661 = abc_8306_auto_rtlil_cc_2608_MuxGate_8155
* NET  1662 = abc_8306_auto_rtlil_cc_2608_MuxGate_8153
* NET  1663 = abc_8306_auto_rtlil_cc_2608_MuxGate_8151
* NET  1664 = abc_8306_auto_rtlil_cc_2608_MuxGate_8149
* NET  1665 = abc_8306_auto_rtlil_cc_2608_MuxGate_8147
* NET  1666 = abc_8306_auto_rtlil_cc_2608_MuxGate_8145
* NET  1667 = abc_8306_auto_rtlil_cc_2608_MuxGate_8143
* NET  1668 = abc_8306_auto_rtlil_cc_2608_MuxGate_8141
* NET  1669 = abc_8306_auto_rtlil_cc_2608_MuxGate_8139
* NET  1670 = abc_8306_auto_rtlil_cc_2608_MuxGate_8137
* NET  1671 = abc_8306_auto_rtlil_cc_2608_MuxGate_8135
* NET  1672 = abc_8306_auto_rtlil_cc_2608_MuxGate_8133
* NET  1673 = abc_8306_auto_rtlil_cc_2608_MuxGate_8131
* NET  1674 = abc_8306_auto_rtlil_cc_2608_MuxGate_8129
* NET  1675 = abc_8306_auto_rtlil_cc_2608_MuxGate_8127
* NET  1676 = abc_8306_auto_rtlil_cc_2608_MuxGate_8125
* NET  1677 = abc_8306_auto_rtlil_cc_2608_MuxGate_8123
* NET  1678 = abc_8306_auto_rtlil_cc_2608_MuxGate_8121
* NET  1679 = abc_8306_auto_rtlil_cc_2608_MuxGate_8119
* NET  1680 = abc_8306_auto_rtlil_cc_2608_MuxGate_8117
* NET  1681 = abc_8306_auto_rtlil_cc_2608_MuxGate_8115
* NET  1682 = abc_8306_auto_rtlil_cc_2608_MuxGate_8113
* NET  1683 = abc_8306_auto_rtlil_cc_2608_MuxGate_8111
* NET  1684 = abc_8306_auto_rtlil_cc_2608_MuxGate_8109
* NET  1685 = abc_8306_auto_rtlil_cc_2608_MuxGate_8107
* NET  1686 = abc_8306_auto_rtlil_cc_2608_MuxGate_8105
* NET  1687 = abc_8306_auto_rtlil_cc_2608_MuxGate_8103
* NET  1688 = abc_8306_auto_rtlil_cc_2608_MuxGate_8101
* NET  1689 = abc_8306_auto_rtlil_cc_2608_MuxGate_8099
* NET  1690 = abc_8306_auto_rtlil_cc_2608_MuxGate_8097
* NET  1691 = abc_8306_auto_rtlil_cc_2608_MuxGate_8095
* NET  1692 = abc_8306_auto_rtlil_cc_2608_MuxGate_8093
* NET  1693 = abc_8306_auto_rtlil_cc_2608_MuxGate_8091
* NET  1694 = abc_8306_auto_rtlil_cc_2608_MuxGate_8089
* NET  1695 = abc_8306_auto_rtlil_cc_2608_MuxGate_8087
* NET  1696 = abc_8306_auto_rtlil_cc_2608_MuxGate_8085
* NET  1697 = abc_8306_auto_rtlil_cc_2608_MuxGate_8083
* NET  1698 = abc_8306_auto_rtlil_cc_2608_MuxGate_8081
* NET  1699 = abc_8306_auto_rtlil_cc_2608_MuxGate_8079
* NET  1700 = abc_8306_auto_rtlil_cc_2608_MuxGate_8077
* NET  1701 = abc_8306_auto_rtlil_cc_2608_MuxGate_8075
* NET  1702 = abc_8306_auto_rtlil_cc_2608_MuxGate_8073
* NET  1703 = abc_8306_auto_rtlil_cc_2608_MuxGate_8071
* NET  1704 = abc_8306_auto_rtlil_cc_2608_MuxGate_8069
* NET  1705 = abc_8306_auto_rtlil_cc_2608_MuxGate_8067
* NET  1706 = abc_8306_auto_rtlil_cc_2608_MuxGate_8065
* NET  1707 = abc_8306_auto_rtlil_cc_2608_MuxGate_8063
* NET  1708 = abc_8306_auto_ff_cc_704_flip_bits_8292
* NET  1709 = abc_8306_auto_ff_cc_704_flip_bits_8250
* NET  1710 = abc_8306_auto_ff_cc_704_flip_bits_8244
* NET  1711 = abc_8306_auto_ff_cc_704_flip_bits_8238
* NET  1712 = abc_8306_auto_ff_cc_704_flip_bits_8232
* NET  1713 = abc_8306_auto_ff_cc_704_flip_bits_8226
* NET  1714 = abc_8306_auto_ff_cc_704_flip_bits_8220
* NET  1715 = abc_8306_auto_ff_cc_704_flip_bits_8214
* NET  1716 = abc_8306_auto_ff_cc_704_flip_bits_8208
* NET  1717 = RY[7]
* NET  1718 = RY[6]
* NET  1719 = RY[5]
* NET  1720 = RY[4]
* NET  1721 = RY[3]
* NET  1722 = RY[2]
* NET  1723 = RY[1]
* NET  1724 = RY[0]
* NET  1725 = RX[7]
* NET  1726 = RX[6]
* NET  1727 = RX[5]
* NET  1728 = RX[4]
* NET  1729 = RX[3]
* NET  1730 = RX[2]
* NET  1731 = RX[1]
* NET  1732 = RX[0]
* NET  1733 = RA[7]
* NET  1734 = RA[6]
* NET  1735 = RA[5]
* NET  1736 = RA[4]
* NET  1737 = RA[3]
* NET  1738 = RA[2]
* NET  1739 = RA[1]
* NET  1740 = RA[0]
* NET  1741 = OP[7]
* NET  1742 = OP[6]
* NET  1743 = OP[5]
* NET  1744 = OP[4]
* NET  1745 = OP[3]
* NET  1746 = OP[2]
* NET  1747 = OP[1]
* NET  1748 = OP[0]
* NET  1749 = DL[7]
* NET  1750 = DL[6]
* NET  1751 = DL[5]
* NET  1752 = DL[4]
* NET  1753 = DL[3]
* NET  1754 = DL[2]
* NET  1755 = DL[1]
* NET  1756 = DL[0]
* NET  1757 = ABLin[7]

xfeed_409 1 2 tie_x0
xfeed_408 1 2 rowend_x0
xfeed_407 1 2 tie_x0
xfeed_406 1 2 tie_x0
xfeed_405 1 2 tie_x0
xfeed_404 1 2 tie_x0
xfeed_403 1 2 tie_x0
xfeed_402 1 2 tie_x0
xfeed_401 1 2 tie_x0
xfeed_400 1 2 tie_x0
xfeed_369 1 2 rowend_x0
xfeed_368 1 2 tie_x0
xfeed_367 1 2 tie_x0
xfeed_366 1 2 tie_x0
xfeed_365 1 2 tie_x0
xfeed_364 1 2 tie_x0
xfeed_363 1 2 rowend_x0
xfeed_362 1 2 tie_x0
xfeed_361 1 2 rowend_x0
xfeed_360 1 2 tie_x0
xsubckt_1480_a3_x2 1 2 958 962 960 959 a3_x2
xsubckt_1460_a3_x2 1 2 975 979 977 976 a3_x2
xsubckt_1333_a2_x2 1 2 1073 1076 1074 a2_x2
xsubckt_130_oa22_x2 1 2 781 802 785 782 oa22_x2
xsubckt_700_nao22_x1 1 2 215 60 753 750 nao22_x1
xsubckt_1108_a2_x2 1 2 1283 804 1375 a2_x2
xsubckt_1118_a2_x2 1 2 1274 1349 1275 a2_x2
xsubckt_1568_nao22_x1 1 2 1604 911 914 919 nao22_x1
xsubckt_1560_na3_x1 1 2 918 1434 1430 1423 na3_x1
xsubckt_1559_a3_x2 1 2 919 593 355 935 a3_x2
xsubckt_1341_nao22_x1 1 2 1066 55 1284 1249 nao22_x1
xsubckt_383_ao2o22_x2 1 2 530 588 533 531 580 ao2o22_x2
xsubckt_150_na2_x1 1 2 761 46 763 na2_x1
xsubckt_280_na3_x1 1 2 633 9 45 671 na3_x1
xsubckt_285_na3_x1 1 2 628 44 711 698 na3_x1
xsubckt_813_ao22_x2 1 2 1559 77 621 614 ao22_x2
xsubckt_934_na2_x1 1 2 70 1444 1440 na2_x1
xsubckt_1088_nao22_x1 1 2 1693 1308 1302 868 nao22_x1
xsubckt_1217_na3_x1 1 2 1182 61 1267 1262 na3_x1
xfeed_419 1 2 tie_x0
xfeed_418 1 2 tie_x0
xfeed_417 1 2 tie_x0
xfeed_416 1 2 tie_x0
xfeed_415 1 2 tie_x0
xfeed_414 1 2 tie_x0
xfeed_413 1 2 tie_x0
xfeed_412 1 2 tie_x0
xfeed_411 1 2 tie_x0
xfeed_410 1 2 tie_x0
xfeed_379 1 2 tie_x0
xfeed_378 1 2 tie_x0
xfeed_377 1 2 rowend_x0
xfeed_376 1 2 tie_x0
xfeed_375 1 2 tie_x0
xfeed_374 1 2 tie_x0
xfeed_373 1 2 tie_x0
xfeed_372 1 2 tie_x0
xfeed_371 1 2 tie_x0
xfeed_370 1 2 tie_x0
xsubckt_596_nxr2_x1 1 2 318 344 321 nxr2_x1
xsubckt_548_na2_x1 1 2 366 434 367 na2_x1
xsubckt_154_na2_x1 1 2 757 778 760 na2_x1
xsubckt_286_na3_x1 1 2 627 45 711 709 na3_x1
xsubckt_910_nao22_x1 1 2 1462 63 775 766 nao22_x1
xsubckt_1174_na3_x1 1 2 1221 65 1267 1262 na3_x1
xsubckt_1326_nxr2_x1 1 2 1080 56 1255 nxr2_x1
xsubckt_477_nao22_x1 1 2 436 441 456 458 nao22_x1
xsubckt_402_an12_x1 1 2 511 1744 1747 an12_x1
xsubckt_159_na2_x1 1 2 752 778 754 na2_x1
xsubckt_896_na2_x1 1 2 1476 1561 1479 na2_x1
xsubckt_926_no3_x1 1 2 1447 1450 1449 1448 no3_x1
xsubckt_1047_na2_x1 1 2 1332 1342 1333 na2_x1
xfeed_429 1 2 tie_x0
xfeed_428 1 2 tie_x0
xfeed_427 1 2 rowend_x0
xfeed_426 1 2 tie_x0
xfeed_425 1 2 tie_x0
xfeed_424 1 2 tie_x0
xfeed_423 1 2 tie_x0
xfeed_422 1 2 tie_x0
xfeed_421 1 2 tie_x0
xfeed_420 1 2 tie_x0
xfeed_389 1 2 rowend_x0
xfeed_388 1 2 tie_x0
xfeed_387 1 2 tie_x0
xfeed_386 1 2 tie_x0
xfeed_385 1 2 tie_x0
xfeed_384 1 2 tie_x0
xfeed_383 1 2 tie_x0
xfeed_382 1 2 tie_x0
xfeed_381 1 2 tie_x0
xfeed_380 1 2 tie_x0
xsubckt_1600_sff1_x4 1 2 137 1676 sff1_x4
xsubckt_1571_sff1r_x4 1 2 7 11 1705 sff1r_x4
xsubckt_1396_na2_x1 1 2 1669 1023 1018 na2_x1
xsubckt_1394_na2_x1 1 2 1019 1021 1020 na2_x1
xsubckt_957_nao22_x1 1 2 1417 61 775 766 nao22_x1
xsubckt_999_an12_x1 1 2 1377 757 1378 an12_x1
xsubckt_1031_no3_x1 1 2 1348 642 641 1350 no3_x1
xsubckt_1033_no3_x1 1 2 1346 549 1352 1347 no3_x1
xsubckt_1635_sff1_x4 1 2 1739 1641 sff1_x4
xsubckt_550_nao22_x1 1 2 364 459 473 634 nao22_x1
xsubckt_405_a3_x2 1 2 508 896 801 783 a3_x2
xsubckt_344_oa2a2a23_x2 1 2 569 583 582 577 574 572 571 oa2a2a23_x2
xsubckt_861_nxr2_x1 1 2 1511 1521 1515 nxr2_x1
xfeed_439 1 2 tie_x0
xfeed_438 1 2 tie_x0
xfeed_437 1 2 tie_x0
xfeed_436 1 2 tie_x0
xfeed_435 1 2 rowend_x0
xfeed_434 1 2 tie_x0
xfeed_433 1 2 tie_x0
xfeed_432 1 2 tie_x0
xfeed_431 1 2 tie_x0
xfeed_430 1 2 tie_x0
xfeed_399 1 2 tie_x0
xfeed_398 1 2 tie_x0
xfeed_397 1 2 tie_x0
xfeed_396 1 2 rowend_x0
xfeed_395 1 2 tie_x0
xfeed_394 1 2 tie_x0
xfeed_393 1 2 tie_x0
xfeed_392 1 2 tie_x0
xfeed_391 1 2 tie_x0
xfeed_390 1 2 tie_x0
xsubckt_1433_ao22_x2 1 2 999 633 570 567 ao22_x2
xsubckt_597_nao22_x1 1 2 317 1754 630 624 nao22_x1
xsubckt_455_a3_x2 1 2 458 635 472 459 a3_x2
xsubckt_435_a3_x2 1 2 478 492 487 479 a3_x2
xsubckt_1055_oa2ao222_x2 1 2 1324 1366 1368 475 633 516 oa2ao222_x2
xsubckt_1191_nao22_x1 1 2 1205 1268 1210 1207 nao22_x1
xsubckt_1565_noa22_x1 1 2 913 884 601 511 noa22_x1
xsubckt_503_a2_x2 1 2 410 421 411 a2_x2
xsubckt_358_a2_x2 1 2 555 564 556 a2_x2
xsubckt_176_ao22_x2 1 2 736 886 808 806 ao22_x2
xsubckt_253_ao2o22_x2 1 2 659 890 768 670 881 ao2o22_x2
xsubckt_680_a3_x2 1 2 234 237 236 235 a3_x2
xsubckt_887_oa2ao222_x2 1 2 1485 635 475 1548 1541 461 oa2ao222_x2
xsubckt_924_a3_x2 1 2 1449 423 1523 1516 a3_x2
xsubckt_1142_nxr2_x1 1 2 1250 54 1253 nxr2_x1
xfeed_449 1 2 tie_x0
xfeed_448 1 2 tie_x0
xfeed_447 1 2 tie_x0
xfeed_446 1 2 tie_x0
xfeed_445 1 2 tie_x0
xfeed_444 1 2 tie_x0
xfeed_443 1 2 tie_x0
xfeed_442 1 2 tie_x0
xfeed_441 1 2 tie_x0
xfeed_440 1 2 tie_x0
xsubckt_1578_sff1_x4 1 2 43 1698 sff1_x4
xsubckt_583_a2_x2 1 2 331 342 332 a2_x2
xsubckt_670_nao22_x1 1 2 244 396 404 406 nao22_x1
xsubckt_719_nao22_x1 1 2 197 64 563 562 nao22_x1
xsubckt_779_a3_x2 1 2 1592 150 1594 1593 a3_x2
xsubckt_226_ao2o22_x2 1 2 686 741 734 731 727 ao2o22_x2
xsubckt_857_a2_x2 1 2 1515 461 1516 a2_x2
xsubckt_1045_a4_x2 1 2 1334 1446 1434 1423 1335 a4_x2
xsubckt_1223_nao22_x1 1 2 1176 1268 1180 1178 nao22_x1
xfeed_459 1 2 tie_x0
xfeed_458 1 2 tie_x0
xfeed_457 1 2 tie_x0
xfeed_456 1 2 tie_x0
xfeed_455 1 2 tie_x0
xfeed_454 1 2 tie_x0
xfeed_453 1 2 tie_x0
xfeed_452 1 2 tie_x0
xfeed_451 1 2 tie_x0
xfeed_450 1 2 tie_x0
xsubckt_1349_a4_x2 1 2 1059 629 628 627 561 a4_x2
xsubckt_263_na4_x1 1 2 649 677 662 656 650 na4_x1
xsubckt_684_an12_x1 1 2 231 269 233 an12_x1
xsubckt_692_oa2a2a23_x2 1 2 223 593 425 306 304 294 293 oa2a2a23_x2
xsubckt_890_oa2ao222_x2 1 2 1482 434 1539 1504 1484 493 oa2ao222_x2
xsubckt_476_ao22_x2 1 2 437 441 456 458 ao22_x2
xsubckt_872_ao22_x2 1 2 1500 1572 1570 1569 ao22_x2
xsubckt_916_na3_x1 1 2 1457 353 1488 1479 na3_x1
xfeed_509 1 2 tie_x0
xfeed_508 1 2 tie_x0
xfeed_507 1 2 tie_x0
xfeed_506 1 2 tie_x0
xfeed_505 1 2 tie_x0
xfeed_504 1 2 tie_x0
xfeed_503 1 2 tie_x0
xfeed_502 1 2 tie_x0
xfeed_501 1 2 tie_x0
xfeed_500 1 2 tie_x0
xfeed_469 1 2 tie_x0
xfeed_468 1 2 tie_x0
xfeed_467 1 2 tie_x0
xfeed_466 1 2 rowend_x0
xfeed_465 1 2 tie_x0
xfeed_464 1 2 tie_x0
xfeed_463 1 2 tie_x0
xfeed_462 1 2 tie_x0
xfeed_461 1 2 tie_x0
xfeed_460 1 2 rowend_x0
xsubckt_1487_a3_x2 1 2 952 956 954 953 a3_x2
xsubckt_1343_nao22_x1 1 2 1064 1749 1329 1264 nao22_x1
xsubckt_1281_a2_x2 1 2 1121 1127 1122 a2_x2
xsubckt_612_nao22_x1 1 2 302 307 521 845 nao22_x1
xsubckt_741_na2_x1 1 2 73 180 176 na2_x1
xsubckt_875_na3_x1 1 2 1497 1538 1501 1498 na3_x1
xsubckt_1025_na3_x1 1 2 1354 819 566 1364 na3_x1
xsubckt_1371_na3_x1 1 2 1039 147 1162 1049 na3_x1
xsubckt_1337_o4_x2 1 2 1070 820 1165 1161 1158 o4_x2
xsubckt_744_na2_x1 1 2 173 906 634 na2_x1
xsubckt_749_na2_x1 1 2 168 461 170 na2_x1
xsubckt_868_ao22_x2 1 2 1504 1538 1514 1507 ao22_x2
xsubckt_1153_ao22_x2 1 2 1240 1384 1263 847 ao22_x2
xfeed_519 1 2 rowend_x0
xfeed_518 1 2 tie_x0
xfeed_517 1 2 tie_x0
xfeed_516 1 2 tie_x0
xfeed_515 1 2 tie_x0
xfeed_514 1 2 tie_x0
xfeed_513 1 2 tie_x0
xfeed_512 1 2 rowend_x0
xfeed_511 1 2 tie_x0
xfeed_510 1 2 tie_x0
xfeed_479 1 2 tie_x0
xfeed_478 1 2 tie_x0
xfeed_477 1 2 tie_x0
xfeed_476 1 2 tie_x0
xfeed_475 1 2 tie_x0
xfeed_474 1 2 tie_x0
xfeed_473 1 2 tie_x0
xfeed_472 1 2 tie_x0
xfeed_471 1 2 rowend_x0
xfeed_470 1 2 tie_x0
xsubckt_1378_na3_x1 1 2 1033 146 1162 1049 na3_x1
xsubckt_491_oa2a2a23_x2 1 2 422 551 502 466 465 425 593 oa2a2a23_x2
xsubckt_1114_ao22_x2 1 2 1277 1278 1364 633 ao22_x2
xsubckt_1245_na2_x1 1 2 1155 1163 1156 na2_x1
xsubckt_1620_sff1_x4 1 2 1754 1656 sff1_x4
xsubckt_1573_sff1r_x4 1 2 48 11 1703 sff1r_x4
xsubckt_1463_nao22_x1 1 2 973 1752 1290 1265 nao22_x1
xsubckt_568_noa2a2a23_x1 1 2 346 905 634 489 1753 467 81 noa2a2a23_x1
xsubckt_213_no2_x1 1 2 699 701 700 no2_x1
xsubckt_1061_ao22_x2 1 2 1318 1319 1334 1341 ao22_x2
xsubckt_1234_no3_x1 1 2 1166 1173 1168 1167 no3_x1
xfeed_529 1 2 rowend_x0
xfeed_528 1 2 tie_x0
xfeed_527 1 2 rowend_x0
xfeed_526 1 2 tie_x0
xfeed_525 1 2 tie_x0
xfeed_524 1 2 tie_x0
xfeed_523 1 2 tie_x0
xfeed_522 1 2 tie_x0
xfeed_521 1 2 tie_x0
xfeed_520 1 2 tie_x0
xfeed_489 1 2 tie_x0
xfeed_488 1 2 tie_x0
xfeed_487 1 2 tie_x0
xfeed_486 1 2 tie_x0
xfeed_485 1 2 tie_x0
xfeed_484 1 2 tie_x0
xfeed_483 1 2 tie_x0
xfeed_482 1 2 rowend_x0
xfeed_481 1 2 tie_x0
xfeed_480 1 2 tie_x0
xsubckt_1655_sff1_x4 1 2 1727 1621 sff1_x4
xsubckt_1616_sff1_x4 1 2 1742 1660 sff1_x4
xsubckt_1399_oa2ao222_x2 1 2 1015 1189 1186 1269 1248 1271 oa2ao222_x2
xsubckt_610_ao22_x2 1 2 304 305 521 845 ao22_x2
xsubckt_552_nao22_x1 1 2 362 440 456 458 nao22_x1
xsubckt_303_a3_x2 1 2 610 9 45 676 a3_x2
xsubckt_886_oa2ao222_x2 1 2 1486 1494 1503 1505 1562 1489 oa2ao222_x2
xsubckt_443_noa2ao222_x1 1 2 470 719 734 741 568 569 noa2ao222_x1
xsubckt_4_inv_x1 1 2 906 1712 inv_x1
xsubckt_3_inv_x1 1 2 907 1711 inv_x1
xsubckt_2_inv_x1 1 2 908 1710 inv_x1
xsubckt_1_inv_x1 1 2 909 1709 inv_x1
xsubckt_0_inv_x1 1 2 910 1708 inv_x1
xsubckt_198_a3_x2 1 2 714 795 785 782 a3_x2
xsubckt_206_a2_x2 1 2 706 807 707 a2_x2
xsubckt_1193_nao22_x1 1 2 1686 1204 1296 1588 nao22_x1
xfeed_539 1 2 tie_x0
xfeed_538 1 2 tie_x0
xfeed_537 1 2 tie_x0
xfeed_536 1 2 tie_x0
xfeed_535 1 2 tie_x0
xfeed_534 1 2 tie_x0
xfeed_533 1 2 tie_x0
xfeed_532 1 2 tie_x0
xfeed_531 1 2 tie_x0
xfeed_530 1 2 tie_x0
xfeed_499 1 2 tie_x0
xfeed_498 1 2 tie_x0
xfeed_497 1 2 tie_x0
xfeed_496 1 2 tie_x0
xfeed_495 1 2 tie_x0
xfeed_494 1 2 tie_x0
xfeed_493 1 2 tie_x0
xfeed_492 1 2 tie_x0
xfeed_491 1 2 tie_x0
xfeed_490 1 2 tie_x0
xsubckt_599_nao22_x1 1 2 315 904 605 599 nao22_x1
xsubckt_431_a2_x2 1 2 482 514 483 a2_x2
xsubckt_325_on12_x1 1 2 588 1744 1747 on12_x1
xsubckt_9_inv_x1 1 2 901 8 inv_x1
xsubckt_8_inv_x1 1 2 902 1716 inv_x1
xsubckt_7_inv_x1 1 2 903 1715 inv_x1
xsubckt_6_inv_x1 1 2 904 1714 inv_x1
xsubckt_5_inv_x1 1 2 905 1713 inv_x1
xsubckt_657_a3_x2 1 2 257 357 350 259 a3_x2
xsubckt_722_an12_x1 1 2 194 195 198 an12_x1
xsubckt_852_nao22_x1 1 2 1520 635 475 1524 nao22_x1
xsubckt_1015_nao22_x1 1 2 1364 1366 1368 475 nao22_x1
xsubckt_1598_sff1_x4 1 2 139 1678 sff1_x4
xsubckt_1315_nao22_x1 1 2 1090 57 1284 1249 nao22_x1
xsubckt_592_ao22_x2 1 2 322 474 327 325 ao22_x2
xsubckt_762_nao22_x1 1 2 155 493 160 158 nao22_x1
xsubckt_765_a2_x2 1 2 152 154 153 a2_x2
xfeed_549 1 2 tie_x0
xfeed_548 1 2 tie_x0
xfeed_547 1 2 tie_x0
xfeed_546 1 2 tie_x0
xfeed_545 1 2 tie_x0
xfeed_544 1 2 tie_x0
xfeed_543 1 2 tie_x0
xfeed_542 1 2 tie_x0
xfeed_541 1 2 tie_x0
xfeed_540 1 2 tie_x0
xsubckt_549_ao22_x2 1 2 365 459 473 634 ao22_x2
xsubckt_492_nao22_x1 1 2 421 1755 630 624 nao22_x1
xsubckt_463_noa2ao222_x1 1 2 450 451 684 897 883 1743 noa2ao222_x1
xsubckt_461_na4_x1 1 2 452 45 3 711 709 na4_x1
xsubckt_142_an12_x1 1 2 769 1743 1744 an12_x1
xsubckt_860_o3_x2 1 2 1512 634 1522 1515 o3_x2
xsubckt_1003_na4_x1 1 2 1373 1382 1380 1377 1374 na4_x1
xsubckt_1041_a3_x2 1 2 1338 254 242 1339 a3_x2
xfeed_559 1 2 rowend_x0
xfeed_558 1 2 tie_x0
xfeed_557 1 2 tie_x0
xfeed_556 1 2 tie_x0
xfeed_555 1 2 tie_x0
xfeed_554 1 2 rowend_x0
xfeed_553 1 2 tie_x0
xfeed_552 1 2 tie_x0
xfeed_551 1 2 tie_x0
xfeed_550 1 2 tie_x0
xsubckt_1435_nao22_x1 1 2 997 998 391 432 nao22_x1
xsubckt_1350_na4_x1 1 2 1058 629 628 627 561 na4_x1
xsubckt_457_ao22_x2 1 2 456 460 473 634 ao22_x2
xsubckt_224_nao22_x1 1 2 688 731 734 741 nao22_x1
xsubckt_1091_a3_x2 1 2 1300 618 471 1414 a3_x2
xsubckt_1280_noa22_x1 1 2 1122 1123 1352 82 noa22_x1
xsubckt_1406_oa2ao222_x2 1 2 1009 1179 1177 1269 1248 1271 oa2ao222_x2
xsubckt_291_na3_x1 1 2 622 9 711 691 na3_x1
xsubckt_728_na3_x1 1 2 188 201 191 190 na3_x1
xsubckt_792_nao22_x1 1 2 72 1580 1588 780 nao22_x1
xsubckt_1228_a2_x2 1 2 1172 632 622 a2_x2
xfeed_609 1 2 rowend_x0
xfeed_608 1 2 tie_x0
xfeed_607 1 2 tie_x0
xfeed_606 1 2 tie_x0
xfeed_605 1 2 tie_x0
xfeed_604 1 2 tie_x0
xfeed_603 1 2 tie_x0
xfeed_602 1 2 tie_x0
xfeed_601 1 2 tie_x0
xfeed_600 1 2 tie_x0
xfeed_569 1 2 rowend_x0
xfeed_568 1 2 tie_x0
xfeed_567 1 2 tie_x0
xfeed_566 1 2 tie_x0
xfeed_565 1 2 tie_x0
xfeed_564 1 2 tie_x0
xfeed_563 1 2 tie_x0
xfeed_562 1 2 tie_x0
xfeed_561 1 2 tie_x0
xfeed_560 1 2 tie_x0
xsubckt_1441_na2_x1 1 2 1650 997 992 na2_x1
xsubckt_1285_o4_x2 1 2 1118 840 1165 1161 1158 o4_x2
xsubckt_557_na2_x1 1 2 357 366 359 na2_x1
xsubckt_162_na2_x1 1 2 749 44 767 na2_x1
xsubckt_296_na3_x1 1 2 617 1742 46 683 na3_x1
xsubckt_688_na3_x1 1 2 227 303 301 292 na3_x1
xsubckt_944_na2_x1 1 2 1430 1547 1541 na2_x1
xsubckt_1227_na3_x1 1 2 1173 548 541 516 na3_x1
xsubckt_1447_na2_x1 1 2 1649 991 987 na2_x1
xsubckt_558_na2_x1 1 2 356 40 658 na2_x1
xsubckt_10_inv_x1 1 2 900 7 inv_x1
xsubckt_11_inv_x1 1 2 899 6 inv_x1
xsubckt_12_inv_x1 1 2 898 16 inv_x1
xsubckt_13_inv_x1 1 2 897 9 inv_x1
xsubckt_1052_na2_x1 1 2 1327 626 1328 na2_x1
xsubckt_1184_na3_x1 1 2 1212 64 1267 1262 na3_x1
xfeed_619 1 2 tie_x0
xfeed_618 1 2 tie_x0
xfeed_617 1 2 tie_x0
xfeed_616 1 2 tie_x0
xfeed_615 1 2 tie_x0
xfeed_614 1 2 tie_x0
xfeed_613 1 2 tie_x0
xfeed_612 1 2 tie_x0
xfeed_611 1 2 tie_x0
xfeed_610 1 2 tie_x0
xfeed_576 1 2 tie_x0
xfeed_575 1 2 tie_x0
xfeed_574 1 2 tie_x0
xfeed_573 1 2 tie_x0
xfeed_572 1 2 tie_x0
xfeed_571 1 2 tie_x0
xfeed_570 1 2 tie_x0
xsubckt_1640_sff1_x4 1 2 1734 1636 sff1_x4
xsubckt_1601_sff1_x4 1 2 136 1675 sff1_x4
xsubckt_1465_nao22_x1 1 2 971 1268 1105 1103 nao22_x1
xsubckt_14_inv_x1 1 2 896 1747 inv_x1
xsubckt_15_inv_x1 1 2 895 1748 inv_x1
xsubckt_16_inv_x1 1 2 894 1744 inv_x1
xsubckt_17_inv_x1 1 2 893 1743 inv_x1
xsubckt_18_inv_x1 1 2 892 1742 inv_x1
xsubckt_19_inv_x1 1 2 891 1741 inv_x1
xsubckt_757_ao22_x2 1 2 160 165 161 233 ao22_x2
xsubckt_877_noa2ao222_x1 1 2 1495 1537 1502 1499 495 500 noa2ao222_x1
xsubckt_1058_na2_x1 1 2 1321 9 660 na2_x1
xsubckt_1200_nxr2_x1 1 2 1197 863 1208 nxr2_x1
xfeed_579 1 2 tie_x0
xfeed_578 1 2 tie_x0
xfeed_577 1 2 tie_x0
xsubckt_1636_sff1_x4 1 2 1738 1640 sff1_x4
xsubckt_1436_no3_x1 1 2 996 1290 1265 998 no3_x1
xsubckt_211_a3_x2 1 2 701 46 747 711 a3_x2
xsubckt_862_nxr2_x1 1 2 1510 1520 1515 nxr2_x1
xsubckt_1205_oa2ao222_x2 1 2 1193 1447 1453 1454 629 561 oa2ao222_x2
xfeed_629 1 2 tie_x0
xfeed_628 1 2 tie_x0
xfeed_627 1 2 tie_x0
xfeed_626 1 2 tie_x0
xfeed_625 1 2 tie_x0
xfeed_624 1 2 tie_x0
xfeed_623 1 2 tie_x0
xfeed_622 1 2 tie_x0
xfeed_621 1 2 tie_x0
xfeed_620 1 2 tie_x0
xfeed_583 1 2 tie_x0
xfeed_582 1 2 tie_x0
xfeed_581 1 2 tie_x0
xfeed_580 1 2 tie_x0
xsubckt_1541_noa2ao222_x1 1 2 934 9 687 685 803 794 noa2ao222_x1
xsubckt_626_ao22_x2 1 2 288 290 298 634 ao22_x2
xsubckt_464_nao22_x1 1 2 449 883 798 786 nao22_x1
xsubckt_181_ao22_x2 1 2 731 744 742 784 ao22_x2
xsubckt_897_nxr2_x1 1 2 1475 1562 1479 nxr2_x1
xsubckt_932_noa2ao222_x1 1 2 1441 38 758 384 386 1734 noa2ao222_x1
xfeed_589 1 2 tie_x0
xfeed_588 1 2 tie_x0
xfeed_587 1 2 tie_x0
xfeed_586 1 2 tie_x0
xfeed_585 1 2 tie_x0
xfeed_584 1 2 tie_x0
xsubckt_613_a2_x2 1 2 301 317 305 a2_x2
xsubckt_603_a2_x2 1 2 311 313 312 a2_x2
xsubckt_428_a2_x2 1 2 485 606 486 a2_x2
xsubckt_418_a2_x2 1 2 495 497 496 a2_x2
xsubckt_374_nao22_x1 1 2 539 1746 732 896 nao22_x1
xsubckt_184_a2_x2 1 2 728 737 729 a2_x2
xsubckt_740_a3_x2 1 2 176 179 178 177 a3_x2
xsubckt_770_a3_x2 1 2 1601 57 569 568 a3_x2
xsubckt_790_a3_x2 1 2 1581 383 1584 1582 a3_x2
xsubckt_839_a3_x2 1 2 1533 56 569 568 a3_x2
xfeed_639 1 2 tie_x0
xfeed_638 1 2 tie_x0
xfeed_637 1 2 tie_x0
xfeed_636 1 2 tie_x0
xfeed_635 1 2 tie_x0
xfeed_634 1 2 tie_x0
xfeed_633 1 2 tie_x0
xfeed_632 1 2 tie_x0
xfeed_631 1 2 tie_x0
xfeed_630 1 2 tie_x0
xfeed_590 1 2 tie_x0
xsubckt_1579_sff1_x4 1 2 42 1697 sff1_x4
xsubckt_1317_nao22_x1 1 2 1088 1751 1329 1264 nao22_x1
xsubckt_438_a2_x2 1 2 475 494 478 a2_x2
xsubckt_693_noa2a2a23_x1 1 2 222 402 323 299 396 247 403 noa2a2a23_x1
xsubckt_777_an12_x1 1 2 1594 1603 1595 an12_x1
xfeed_599 1 2 tie_x0
xfeed_598 1 2 tie_x0
xfeed_597 1 2 tie_x0
xfeed_596 1 2 tie_x0
xfeed_595 1 2 tie_x0
xfeed_594 1 2 tie_x0
xfeed_593 1 2 tie_x0
xfeed_592 1 2 tie_x0
xfeed_591 1 2 tie_x0
xsubckt_1561_noa2ao222_x1 1 2 917 1433 1422 1435 487 492 noa2ao222_x1
xsubckt_1366_noa2ao222_x1 1 2 1043 83 1329 1055 760 668 noa2ao222_x1
xsubckt_584_nao22_x1 1 2 330 1721 520 505 nao22_x1
xsubckt_498_a2_x2 1 2 415 417 416 a2_x2
xsubckt_122_o2_x2 1 2 789 1743 1742 o2_x2
xsubckt_313_na4_x1 1 2 600 895 809 800 746 na4_x1
xsubckt_937_a2_x2 1 2 1437 354 1479 a2_x2
xsubckt_967_a2_x2 1 2 1408 513 1409 a2_x2
xsubckt_977_a2_x2 1 2 1398 672 1399 a2_x2
xsubckt_1135_a4_x2 1 2 1257 68 67 60 59 a4_x2
xfeed_646 1 2 tie_x0
xfeed_645 1 2 tie_x0
xfeed_644 1 2 tie_x0
xfeed_643 1 2 tie_x0
xfeed_642 1 2 tie_x0
xfeed_641 1 2 tie_x0
xfeed_640 1 2 tie_x0
xsubckt_1397_oa2ao222_x2 1 2 1017 1447 1453 1454 625 561 oa2ao222_x2
xsubckt_494_nao22_x1 1 2 419 903 605 599 nao22_x1
xsubckt_481_ao22_x2 1 2 432 493 439 437 ao22_x2
xsubckt_316_nao22_x1 1 2 597 902 605 599 nao22_x1
xsubckt_997_a2_x2 1 2 1379 1382 1380 a2_x2
xsubckt_1048_a3_x2 1 2 1331 9 46 705 a3_x2
xsubckt_1203_a3_x2 1 2 1194 1202 1201 1195 a3_x2
xfeed_649 1 2 tie_x0
xfeed_648 1 2 tie_x0
xfeed_647 1 2 tie_x0
xsubckt_530_na3_x1 1 2 383 892 46 763 na3_x1
xsubckt_706_nao22_x1 1 2 210 232 231 256 nao22_x1
xsubckt_1106_a2_x2 1 2 1285 602 1287 a2_x2
xfeed_653 1 2 tie_x0
xfeed_652 1 2 tie_x0
xfeed_651 1 2 tie_x0
xfeed_650 1 2 tie_x0
xsubckt_1562_mx2_x2 1 2 916 1547 1541 1434 mx2_x2
xsubckt_1555_na4_x1 1 2 922 40 672 1399 923 na4_x1
xsubckt_1386_noa2ao222_x1 1 2 1026 80 1329 1055 760 668 noa2ao222_x1
xsubckt_593_an12_x1 1 2 321 635 322 an12_x1
xsubckt_526_nao22_x1 1 2 387 68 753 750 nao22_x1
xsubckt_404_na2_x1 1 2 509 528 511 na2_x1
xsubckt_794_nao22_x1 1 2 1578 635 475 1592 nao22_x1
xsubckt_1030_na3_x1 1 2 1349 9 47 681 na3_x1
xsubckt_1136_a2_x2 1 2 1256 58 1257 a2_x2
xsubckt_1207_ao22_x2 1 2 1191 1384 1263 824 ao22_x2
xfeed_659 1 2 tie_x0
xfeed_658 1 2 tie_x0
xfeed_657 1 2 tie_x0
xfeed_656 1 2 tie_x0
xfeed_655 1 2 tie_x0
xfeed_654 1 2 tie_x0
xsubckt_1567_mx2_x2 1 2 911 824 912 1397 mx2_x2
xsubckt_1510_nao22_x1 1 2 946 600 688 897 nao22_x1
xsubckt_1312_nxr2_x1 1 2 1093 862 1256 nxr2_x1
xsubckt_495_na3_x1 1 2 418 67 569 568 na3_x1
xsubckt_363_na2_x1 1 2 550 623 552 na2_x1
xsubckt_1096_oa2ao222_x2 1 2 1295 679 46 45 44 671 oa2ao222_x2
xsubckt_1257_nao22_x1 1 2 1144 67 1284 1249 nao22_x1
xfeed_660 1 2 tie_x0
xsubckt_1384_na3_x1 1 2 1028 145 1162 1049 na3_x1
xsubckt_1352_oa2ao222_x2 1 2 1056 1245 1250 1269 1271 1248 oa2ao222_x2
xsubckt_637_noa2ao222_x1 1 2 277 318 288 281 478 635 noa2ao222_x1
xsubckt_543_oa22_x2 1 2 371 372 380 635 oa22_x2
xsubckt_742_ao22_x2 1 2 175 635 475 189 ao22_x2
xsubckt_1021_no4_x1 1 2 1358 608 607 1360 1359 no4_x1
xsubckt_1251_na2_x1 1 2 1682 1164 1150 na2_x1
xsubckt_1261_o3_x2 1 2 1140 52 51 50 o3_x2
xfeed_669 1 2 tie_x0
xfeed_668 1 2 tie_x0
xfeed_667 1 2 tie_x0
xfeed_666 1 2 tie_x0
xfeed_665 1 2 tie_x0
xfeed_664 1 2 tie_x0
xfeed_663 1 2 tie_x0
xfeed_662 1 2 tie_x0
xfeed_661 1 2 tie_x0
xsubckt_1667_sff1r_x4 1 2 13 11 1609 sff1r_x4
xsubckt_1660_sff1_x4 1 2 1722 1616 sff1_x4
xsubckt_1621_sff1_x4 1 2 1753 1655 sff1_x4
xsubckt_1330_nao22_x1 1 2 1076 1750 1329 1264 nao22_x1
xsubckt_256_nao22_x1 1 2 656 717 734 741 nao22_x1
xsubckt_736_nao22_x1 1 2 180 779 207 183 nao22_x1
xsubckt_1240_no3_x1 1 2 1160 642 639 1387 no3_x1
xsubckt_1656_sff1_x4 1 2 1726 1620 sff1_x4
xsubckt_1467_nao22_x1 1 2 1646 970 999 1588 nao22_x1
xsubckt_1377_nao22_x1 1 2 1034 1058 183 207 nao22_x1
xsubckt_611_ao22_x2 1 2 303 307 521 845 ao22_x2
xsubckt_560_a4_x2 1 2 354 9 1743 40 685 a4_x2
xsubckt_254_ao22_x2 1 2 658 719 734 741 ao22_x2
xsubckt_650_ao22_x2 1 2 264 344 322 634 ao22_x2
xsubckt_882_nxr2_x1 1 2 1490 1511 1500 nxr2_x1
xsubckt_1023_ao22_x2 1 2 1356 1357 1365 541 ao22_x2
xsubckt_1255_nxr2_x1 1 2 1146 68 67 nxr2_x1
xfeed_679 1 2 tie_x0
xfeed_678 1 2 tie_x0
xfeed_677 1 2 tie_x0
xfeed_676 1 2 tie_x0
xfeed_675 1 2 tie_x0
xfeed_674 1 2 tie_x0
xfeed_673 1 2 tie_x0
xfeed_672 1 2 tie_x0
xfeed_671 1 2 tie_x0
xfeed_670 1 2 tie_x0
xsubckt_1617_sff1_x4 1 2 1741 1659 sff1_x4
xsubckt_433_a3_x2 1 2 480 632 628 481 a3_x2
xsubckt_423_a3_x2 1 2 490 541 537 516 a3_x2
xsubckt_385_a4_x2 1 2 528 895 809 800 790 a4_x2
xsubckt_702_noa2ao222_x1 1 2 213 910 758 384 386 1738 noa2ao222_x1
xsubckt_804_nxr2_x1 1 2 1568 1571 1569 nxr2_x1
xsubckt_1109_nao22_x1 1 2 1282 36 897 16 nao22_x1
xsubckt_1450_nao22_x1 1 2 984 1754 1290 1265 nao22_x1
xsubckt_511_a2_x2 1 2 402 1742 793 a2_x2
xsubckt_501_a2_x2 1 2 412 419 413 a2_x2
xsubckt_288_a3_x2 1 2 625 629 628 627 a3_x2
xsubckt_727_a3_x2 1 2 189 201 191 190 a3_x2
xsubckt_902_a3_x2 1 2 1470 423 1591 1574 a3_x2
xsubckt_912_a3_x2 1 2 1460 757 383 1461 a3_x2
xfeed_689 1 2 tie_x0
xfeed_688 1 2 tie_x0
xfeed_687 1 2 tie_x0
xfeed_686 1 2 tie_x0
xfeed_685 1 2 tie_x0
xfeed_684 1 2 tie_x0
xfeed_683 1 2 tie_x0
xfeed_682 1 2 tie_x0
xfeed_681 1 2 tie_x0
xfeed_680 1 2 tie_x0
xsubckt_1599_sff1_x4 1 2 138 1677 sff1_x4
xsubckt_581_a2_x2 1 2 333 340 334 a2_x2
xsubckt_386_a2_x2 1 2 527 604 528 a2_x2
xsubckt_119_ao22_x2 1 2 792 804 810 887 ao22_x2
xsubckt_540_oa2a2a23_x2 1 2 374 903 634 489 1755 467 83 oa2a2a23_x2
xsubckt_676_nao22_x1 1 2 238 779 255 241 nao22_x1
xsubckt_708_nxr2_x1 1 2 208 272 209 nxr2_x1
xsubckt_895_a2_x2 1 2 1477 1561 1479 a2_x2
xsubckt_950_ao22_x2 1 2 1424 1425 1524 246 ao22_x2
xfeed_697 1 2 tie_x0
xfeed_696 1 2 rowend_x0
xfeed_695 1 2 tie_x0
xfeed_694 1 2 tie_x0
xfeed_693 1 2 tie_x0
xfeed_692 1 2 tie_x0
xfeed_691 1 2 tie_x0
xfeed_690 1 2 tie_x0
xsubckt_515_na4_x1 1 2 398 781 598 509 400 na4_x1
xsubckt_496_nao22_x1 1 2 417 53 563 562 nao22_x1
xsubckt_126_na4_x1 1 2 785 48 1741 790 787 na4_x1
xsubckt_1083_a4_x2 1 2 1305 9 817 776 668 a4_x2
xsubckt_1413_mx2_x2 1 2 1664 1746 82 815 mx2_x2
xsubckt_1412_mx2_x2 1 2 1665 1747 83 815 mx2_x2
xsubckt_1411_mx2_x2 1 2 1666 1748 84 815 mx2_x2
xsubckt_1302_nao22_x1 1 2 1102 58 1284 1249 nao22_x1
xsubckt_470_na4_x1 1 2 443 565 537 452 446 na4_x1
xsubckt_129_na4_x1 1 2 782 895 1741 812 790 na4_x1
xsubckt_104_an12_x1 1 2 807 48 1744 an12_x1
xsubckt_228_nao22_x1 1 2 684 726 734 741 nao22_x1
xsubckt_854_ao2o22_x2 1 2 1518 828 490 468 824 ao2o22_x2
xsubckt_1024_a2_x2 1 2 1355 1362 1356 a2_x2
xsubckt_1171_a3_x2 1 2 1223 1231 1230 1224 a3_x2
xsubckt_1439_nao22_x1 1 2 993 1268 1247 878 nao22_x1
xsubckt_1418_mx2_x2 1 2 1659 1741 77 815 mx2_x2
xsubckt_1417_mx2_x2 1 2 1660 1742 78 815 mx2_x2
xsubckt_1416_mx2_x2 1 2 1661 1743 79 815 mx2_x2
xsubckt_1415_mx2_x2 1 2 1662 1744 80 815 mx2_x2
xsubckt_1414_mx2_x2 1 2 1663 1745 81 815 mx2_x2
xsubckt_1390_nao22_x1 1 2 1023 1058 1467 1475 nao22_x1
xsubckt_479_na4_x1 1 2 434 635 492 487 479 na4_x1
xsubckt_343_noa2a2a23_x1 1 2 570 583 582 577 574 572 571 noa2a2a23_x1
xsubckt_103_on12_x1 1 2 808 1746 1745 on12_x1
xsubckt_210_na2_x1 1 2 702 747 711 na2_x1
xsubckt_215_na2_x1 1 2 697 711 698 na2_x1
xsubckt_893_ao22_x2 1 2 1479 350 1487 1481 ao22_x2
xsubckt_1232_na3_x1 1 2 1168 565 537 485 na3_x1
xsubckt_1233_na3_x1 1 2 1167 637 632 622 na3_x1
xsubckt_1553_a2_x2 1 2 924 1742 511 a2_x2
xsubckt_1382_an12_x1 1 2 1029 1033 1030 an12_x1
xsubckt_1303_oa2ao222_x2 1 2 1101 1102 1104 1269 1271 1248 oa2ao222_x2
xsubckt_634_oa2ao222_x2 1 2 280 371 369 368 286 285 oa2ao222_x2
xsubckt_563_na2_x1 1 2 351 356 353 na2_x1
xsubckt_528_nao22_x1 1 2 385 54 775 766 nao22_x1
xsubckt_349_na3_x1 1 2 564 68 569 568 na3_x1
xsubckt_172_na2_x1 1 2 740 744 742 na2_x1
xsubckt_952_na2_x1 1 2 1422 1427 1424 na2_x1
xsubckt_954_na2_x1 1 2 1420 1434 1423 na2_x1
xsubckt_1259_nao22_x1 1 2 1142 1755 1329 1264 nao22_x1
xsubckt_1454_na2_x1 1 2 1648 986 981 na2_x1
xsubckt_601_nao22_x1 1 2 313 66 563 562 nao22_x1
xsubckt_566_na2_x1 1 2 348 905 634 na2_x1
xsubckt_565_na2_x1 1 2 349 476 351 na2_x1
xsubckt_20_inv_x1 1 2 890 47 inv_x1
xsubckt_178_na2_x1 1 2 734 737 736 na2_x1
xsubckt_918_nao22_x1 1 2 1455 1489 1478 354 nao22_x1
xsubckt_1062_na2_x1 1 2 1703 1343 1318 na2_x1
xsubckt_1107_na2_x1 1 2 1284 602 1287 na2_x1
xsubckt_1195_na3_x1 1 2 1202 63 1267 1262 na3_x1
xsubckt_1669_sff1r_x4 1 2 41 11 1607 sff1r_x4
xsubckt_1641_sff1_x4 1 2 1733 1635 sff1_x4
xsubckt_26_inv_x1 1 2 884 38 inv_x1
xsubckt_25_inv_x1 1 2 885 39 inv_x1
xsubckt_24_inv_x1 1 2 886 43 inv_x1
xsubckt_23_inv_x1 1 2 887 42 inv_x1
xsubckt_22_inv_x1 1 2 888 52 inv_x1
xsubckt_21_inv_x1 1 2 889 45 inv_x1
xsubckt_179_na2_x1 1 2 733 740 735 na2_x1
xsubckt_200_ao22_x2 1 2 712 713 714 801 ao22_x2
xsubckt_258_nao22_x1 1 2 654 724 734 741 nao22_x1
xsubckt_723_ao22_x2 1 2 193 194 584 864 ao22_x2
xsubckt_738_nao22_x1 1 2 178 65 775 766 nao22_x1
xsubckt_1064_na2_x1 1 2 1702 1332 1317 na2_x1
xsubckt_1066_na2_x1 1 2 1701 1344 1316 na2_x1
xsubckt_1068_na2_x1 1 2 1700 1355 1315 na2_x1
xsubckt_1201_nxr2_x1 1 2 1196 63 1208 nxr2_x1
xsubckt_1602_sff1_x4 1 2 135 1674 sff1_x4
xsubckt_29_inv_x1 1 2 881 46 inv_x1
xsubckt_28_inv_x1 1 2 882 37 inv_x1
xsubckt_27_inv_x1 1 2 883 41 inv_x1
xsubckt_1053_no3_x1 1 2 1326 750 1331 1327 no3_x1
xsubckt_1637_sff1_x4 1 2 1737 1639 sff1_x4
xsubckt_1289_nao22_x1 1 2 1114 59 1284 1249 nao22_x1
xsubckt_331_nao22_x1 1 2 582 883 789 891 nao22_x1
xsubckt_1056_no3_x1 1 2 1323 766 610 559 no3_x1
xsubckt_1452_nao22_x1 1 2 982 1268 1132 1130 nao22_x1
xsubckt_214_a2_x2 1 2 698 772 710 a2_x2
xsubckt_244_a2_x2 1 2 668 6 16 a2_x2
xsubckt_898_nxr2_x1 1 2 1474 1561 1479 nxr2_x1
xsubckt_518_a2_x2 1 2 395 793 746 a2_x2
xsubckt_508_a2_x2 1 2 405 421 409 a2_x2
xsubckt_500_ao22_x2 1 2 413 414 584 875 ao22_x2
xsubckt_220_an12_x1 1 2 692 47 1745 an12_x1
xsubckt_713_a2_x2 1 2 203 205 204 a2_x2
xsubckt_754_ao2o22_x2 1 2 163 493 434 352 477 ao2o22_x2
xsubckt_768_nao22_x1 1 2 1603 79 621 614 nao22_x1
xsubckt_880_a3_x2 1 2 1492 1565 1510 1508 a3_x2
xsubckt_919_a3_x2 1 2 1454 1477 1457 1455 a3_x2
xsubckt_959_a3_x2 1 2 1415 1418 1417 1416 a3_x2
xsubckt_969_a3_x2 1 2 1406 1413 1412 1407 a3_x2
xsubckt_588_a2_x2 1 2 326 342 330 a2_x2
xsubckt_578_a2_x2 1 2 336 338 337 a2_x2
xsubckt_678_nao22_x1 1 2 236 53 775 766 nao22_x1
xsubckt_745_ao2o22_x2 1 2 172 838 490 468 834 ao2o22_x2
xsubckt_773_a2_x2 1 2 1598 1600 1599 a2_x2
xsubckt_931_nao22_x1 1 2 1442 62 775 766 nao22_x1
xsubckt_970_ao22_x2 1 2 1405 792 657 581 ao22_x2
xsubckt_1004_nao22_x1 1 2 1706 1379 1373 901 nao22_x1
xsubckt_1179_nxr2_x1 1 2 1216 871 1227 nxr2_x1
xsubckt_755_nao2o22_x1 1 2 162 493 434 352 477 nao2o22_x1
xsubckt_1100_ao2o22_x2 1 2 1291 886 768 675 880 ao2o22_x2
xsubckt_1482_nao22_x1 1 2 957 998 1422 1435 nao22_x1
xsubckt_1304_nao22_x1 1 2 1100 1752 1329 1264 nao22_x1
xsubckt_621_ao2o22_x2 1 2 293 846 490 468 843 ao2o22_x2
xsubckt_334_mx2_x2 1 2 579 37 38 1741 mx2_x2
xsubckt_124_an12_x1 1 2 787 1748 1747 an12_x1
xsubckt_281_na4_x1 1 2 632 9 46 711 698 na4_x1
xsubckt_307_noa2ao222_x1 1 2 606 9 661 653 612 47 noa2ao222_x1
xsubckt_927_ao22_x2 1 2 1446 1447 1453 1454 ao22_x2
xsubckt_1178_a3_x2 1 2 1217 66 65 1239 a3_x2
xsubckt_1451_a2_x2 1 2 983 1124 984 a2_x2
xsubckt_1421_a2_x2 1 2 1003 1321 1004 a2_x2
xsubckt_805_na2_x1 1 2 1567 493 1568 na2_x1
xsubckt_1566_na4_x1 1 2 912 593 355 935 913 na4_x1
xsubckt_1471_a2_x2 1 2 966 1111 967 a2_x2
xsubckt_1437_na3_x1 1 2 995 68 1267 996 na3_x1
xsubckt_544_nxr2_x1 1 2 370 379 373 nxr2_x1
xsubckt_140_no4_x1 1 2 771 1747 1748 1746 1745 no4_x1
xsubckt_289_na4_x1 1 2 624 791 629 628 627 na4_x1
xsubckt_796_ao2o22_x2 1 2 1576 833 490 468 829 ao2o22_x2
xsubckt_881_oa2ao222_x2 1 2 1491 1511 1509 1566 478 635 oa2ao222_x2
xsubckt_1208_ao22_x2 1 2 1190 62 1284 1249 ao22_x2
xsubckt_1243_o4_x2 1 2 1157 852 1165 1161 1158 o4_x2
xsubckt_1253_o4_x2 1 2 1148 848 1165 1161 1158 o4_x2
xsubckt_1391_na3_x1 1 2 1022 144 1162 1049 na3_x1
xsubckt_1313_nxr2_x1 1 2 1092 57 1256 nxr2_x1
xsubckt_406_no3_x1 1 2 507 512 510 508 no3_x1
xsubckt_375_na2_x1 1 2 538 542 540 na2_x1
xsubckt_940_nxr2_x1 1 2 1434 1439 1436 nxr2_x1
xsubckt_1661_sff1_x4 1 2 1721 1615 sff1_x4
xsubckt_1551_ao22_x2 1 2 925 926 1396 882 ao22_x2
xsubckt_1398_na3_x1 1 2 1016 143 1162 1049 na3_x1
xsubckt_778_ao2o22_x2 1 2 1593 831 521 504 832 ao2o22_x2
xsubckt_797_noa2a2a23_x1 1 2 1575 907 634 489 1751 467 79 noa2a2a23_x1
xsubckt_1267_na2_x1 1 2 1681 1149 1135 na2_x1
xsubckt_1622_sff1_x4 1 2 1752 1654 sff1_x4
xsubckt_445_a4_x2 1 2 468 548 544 517 469 a4_x2
xsubckt_191_a4_x2 1 2 721 48 773 770 722 a4_x2
xsubckt_759_no3_x1 1 2 158 233 165 161 no3_x1
xsubckt_1221_nxr2_x1 1 2 1178 857 1188 nxr2_x1
xsubckt_1657_sff1_x4 1 2 1725 1619 sff1_x4
xsubckt_1618_sff1_x4 1 2 1756 1658 sff1_x4
xsubckt_335_nmx2_x1 1 2 578 37 38 1741 nmx2_x1
xsubckt_645_ao2o22_x2 1 2 269 435 271 270 494 ao2o22_x2
xsubckt_651_ao22_x2 1 2 263 434 278 264 ao22_x2
xsubckt_1101_an12_x1 1 2 1290 9 1291 an12_x1
xsubckt_388_a3_x2 1 2 525 1747 801 783 a3_x2
xsubckt_328_oa2ao222_x2 1 2 585 595 725 897 735 740 oa2ao222_x2
xsubckt_163_ao22_x2 1 2 748 752 768 880 ao22_x2
xsubckt_964_a4_x2 1 2 1411 792 598 591 498 a4_x2
xsubckt_1511_noa22_x1 1 2 945 529 946 1747 noa22_x1
xsubckt_182_a2_x2 1 2 730 797 773 a2_x2
xsubckt_752_nxr2_x1 1 2 165 175 169 nxr2_x1
xsubckt_867_a3_x2 1 2 1505 1537 1513 1506 a3_x2
xsubckt_110_o2_x2 1 2 801 42 43 o2_x2
xsubckt_275_an12_x1 1 2 638 640 642 an12_x1
xsubckt_911_na4_x1 1 2 1461 1742 46 1735 763 na4_x1
xsubckt_965_a2_x2 1 2 1410 688 530 a2_x2
xsubckt_1011_noa2ao222_x1 1 2 1368 1482 1369 163 1479 353 noa2ao222_x1
xsubckt_160_o2_x2 1 2 751 880 768 o2_x2
xsubckt_660_nxr2_x1 1 2 254 357 258 nxr2_x1
xsubckt_709_nxr2_x1 1 2 207 210 208 nxr2_x1
xsubckt_929_oa2ao222_x2 1 2 1444 1447 1453 1454 791 781 oa2ao222_x2
xsubckt_1026_a3_x2 1 2 1353 9 47 705 a3_x2
xsubckt_1089_oa2ao222_x2 1 2 1692 50 1304 52 1310 818 oa2ao222_x2
xsubckt_1484_nao22_x1 1 2 955 1749 1290 1265 nao22_x1
xsubckt_454_o2_x2 1 2 459 464 462 o2_x2
xsubckt_99_a2_x2 1 2 812 48 1746 a2_x2
xsubckt_663_nao22_x1 1 2 251 430 427 252 nao22_x1
xsubckt_1231_a3_x2 1 2 1169 454 1172 1170 a3_x2
xsubckt_1545_a3_x2 1 2 930 672 1399 931 a3_x2
xsubckt_1426_mx2_x2 1 2 1657 1755 83 1000 mx2_x2
xsubckt_1425_mx2_x2 1 2 1658 1756 84 1000 mx2_x2
xsubckt_614_na2_x1 1 2 300 317 305 na2_x1
xsubckt_573_nao22_x1 1 2 341 81 621 614 nao22_x1
xsubckt_355_na3_x1 1 2 558 9 45 681 na3_x1
xsubckt_820_ao22_x2 1 2 1552 1553 584 855 ao22_x2
xsubckt_1028_na4_x1 1 2 1351 9 47 711 698 na4_x1
xsubckt_1216_nao22_x1 1 2 1183 1295 1422 1435 nao22_x1
xsubckt_1458_a2_x2 1 2 977 1111 978 a2_x2
xsubckt_1429_mx2_x2 1 2 1654 1752 80 1000 mx2_x2
xsubckt_1428_mx2_x2 1 2 1655 1753 81 1000 mx2_x2
xsubckt_1427_mx2_x2 1 2 1656 1754 82 1000 mx2_x2
xsubckt_619_na2_x1 1 2 295 635 297 na2_x1
xsubckt_615_na2_x1 1 2 299 306 304 na2_x1
xsubckt_571_na2_x1 1 2 343 461 345 na2_x1
xsubckt_417_noa2a2a23_x1 1 2 496 45 679 589 534 528 587 noa2a2a23_x1
xsubckt_732_no4_x1 1 2 184 203 187 186 185 no4_x1
xsubckt_960_na2_x1 1 2 69 1419 1415 na2_x1
xsubckt_961_na2_x1 1 2 1414 9 658 na2_x1
xsubckt_1112_na2_x1 1 2 1279 1289 1280 na2_x1
xsubckt_1478_a2_x2 1 2 960 1111 961 a2_x2
xsubckt_1461_na2_x1 1 2 1647 980 975 na2_x1
xsubckt_183_na2_x1 1 2 729 797 773 na2_x1
xsubckt_185_na2_x1 1 2 727 737 729 na2_x1
xsubckt_1102_o2_x2 1 2 1289 897 1291 o2_x2
xsubckt_1175_ao22_x2 1 2 1220 1384 1263 839 ao22_x2
xsubckt_1358_o3_x2 1 2 1050 1171 1058 1051 o3_x2
xsubckt_1336_nao22_x1 1 2 1071 1165 1422 1435 nao22_x1
xsubckt_33_inv_x1 1 2 877 1740 inv_x1
xsubckt_32_inv_x1 1 2 878 68 inv_x1
xsubckt_31_inv_x1 1 2 879 54 inv_x1
xsubckt_30_inv_x1 1 2 880 44 inv_x1
xsubckt_187_na2_x1 1 2 725 799 787 na2_x1
xsubckt_822_no2_x1 1 2 1550 1559 1551 no2_x1
xsubckt_1070_na2_x1 1 2 1699 1322 1314 na2_x1
xsubckt_1072_na2_x1 1 2 1698 1325 1313 na2_x1
xsubckt_1074_na2_x1 1 2 1697 1321 1312 na2_x1
xsubckt_1075_na2_x1 1 2 1311 16 1375 na2_x1
xsubckt_1238_no4_x1 1 2 1162 1353 1352 1272 1247 no4_x1
xsubckt_1603_sff1_x4 1 2 134 1673 sff1_x4
xsubckt_622_noa2a2a23_x1 1 2 292 904 634 489 1754 467 82 noa2a2a23_x1
xsubckt_148_a4_x2 1 2 763 809 773 765 764 a4_x2
xsubckt_128_a4_x2 1 2 783 895 1741 812 790 a4_x2
xsubckt_39_inv_x1 1 2 871 65 inv_x1
xsubckt_38_inv_x1 1 2 872 1738 inv_x1
xsubckt_37_inv_x1 1 2 873 60 inv_x1
xsubckt_36_inv_x1 1 2 874 66 inv_x1
xsubckt_35_inv_x1 1 2 875 1739 inv_x1
xsubckt_34_inv_x1 1 2 876 53 inv_x1
xsubckt_1246_nao22_x1 1 2 1154 1756 1329 1264 nao22_x1
xsubckt_1638_sff1_x4 1 2 1736 1638 sff1_x4
xsubckt_632_ao22_x2 1 2 282 371 369 368 ao22_x2
xsubckt_442_noa2ao222_x1 1 2 471 9 687 685 596 733 noa2ao222_x1
xsubckt_401_a3_x2 1 2 512 893 603 587 a3_x2
xsubckt_188_a4_x2 1 2 724 48 1741 787 746 a4_x2
xsubckt_216_a3_x2 1 2 696 45 711 698 a3_x2
xsubckt_314_a2_x2 1 2 599 604 601 a2_x2
xsubckt_788_no2_x1 1 2 1583 51 50 no2_x1
xsubckt_1121_an12_x1 1 2 1271 1273 1353 an12_x1
xsubckt_1392_oa2ao222_x2 1 2 1021 1199 1196 1269 1248 1271 oa2ao222_x2
xsubckt_618_a2_x2 1 2 296 635 297 a2_x2
xsubckt_608_a2_x2 1 2 306 317 307 a2_x2
xsubckt_781_oa2a2a23_x2 1 2 1590 323 247 188 396 402 1591 oa2a2a23_x2
xsubckt_1355_a4_x2 1 2 1053 638 611 1386 1384 a4_x2
xsubckt_641_nxr2_x1 1 2 273 318 274 nxr2_x1
xsubckt_720_na4_x1 1 2 196 9 45 139 681 na4_x1
xsubckt_1486_nao22_x1 1 2 953 1268 1069 1067 nao22_x1
xsubckt_1002_a2_x2 1 2 1374 752 1375 a2_x2
xsubckt_1521_a2_x2 1 2 943 586 513 a2_x2
xsubckt_1501_a2_x2 1 2 947 606 948 a2_x2
xsubckt_1473_a3_x2 1 2 964 968 966 965 a3_x2
xsubckt_1453_a3_x2 1 2 981 985 983 982 a3_x2
xsubckt_554_na3_x1 1 2 360 370 364 362 na3_x1
xsubckt_420_na2_x1 1 2 493 500 495 na2_x1
xsubckt_293_na4_x1 1 2 620 9 894 711 691 na4_x1
xsubckt_683_na4_x1 1 2 232 353 350 268 259 na4_x1
xsubckt_811_na2_x1 1 2 1561 1567 1563 na2_x1
xsubckt_1443_na3_x1 1 2 990 67 1267 996 na3_x1
xsubckt_1356_a2_x2 1 2 1052 1056 1053 a2_x2
xsubckt_1346_a2_x2 1 2 1061 1064 1062 a2_x2
xsubckt_559_na3_x1 1 2 355 9 1743 685 na3_x1
xsubckt_555_na3_x1 1 2 359 493 361 360 na3_x1
xsubckt_1449_na3_x1 1 2 985 60 1267 996 na3_x1
xsubckt_545_nxr2_x1 1 2 369 378 373 nxr2_x1
xsubckt_776_na2_x1 1 2 1595 1602 1596 na2_x1
xsubckt_785_nao22_x1 1 2 1586 58 753 750 nao22_x1
xsubckt_987_an12_x1 1 2 1389 778 1390 an12_x1
xsubckt_1040_no4_x1 1 2 1339 433 432 392 1340 no4_x1
xsubckt_1050_o2_x2 1 2 1329 1331 1330 o2_x2
xsubckt_1662_sff1_x4 1 2 1720 1614 sff1_x4
xsubckt_1623_sff1_x4 1 2 1751 1653 sff1_x4
xsubckt_448_ao2o22_x2 1 2 465 854 490 468 851 ao2o22_x2
xsubckt_231_a4_x2 1 2 681 773 765 739 707 a4_x2
xsubckt_241_a4_x2 1 2 671 1742 771 769 765 a4_x2
xsubckt_705_ao22_x2 1 2 211 232 231 256 ao22_x2
xsubckt_1222_nxr2_x1 1 2 1177 61 1188 nxr2_x1
xfeed_19 1 2 tie_x0
xfeed_18 1 2 tie_x0
xfeed_17 1 2 tie_x0
xfeed_16 1 2 tie_x0
xfeed_15 1 2 tie_x0
xfeed_14 1 2 tie_x0
xfeed_13 1 2 tie_x0
xfeed_12 1 2 tie_x0
xfeed_11 1 2 rowend_x0
xfeed_10 1 2 tie_x0
xsubckt_1658_sff1_x4 1 2 1724 1618 sff1_x4
xsubckt_1400_noa2ao222_x1 1 2 1014 78 1329 1055 760 668 noa2ao222_x1
xsubckt_1158_nao22_x1 1 2 1235 53 1284 1249 nao22_x1
xsubckt_1619_sff1_x4 1 2 1755 1657 sff1_x4
xsubckt_174_a3_x2 1 2 738 800 771 739 a3_x2
xsubckt_202_a2_x2 1 2 710 48 1744 a2_x2
xsubckt_222_a2_x2 1 2 690 711 691 a2_x2
xfeed_29 1 2 tie_x0
xfeed_28 1 2 tie_x0
xfeed_27 1 2 tie_x0
xfeed_26 1 2 tie_x0
xfeed_25 1 2 tie_x0
xfeed_24 1 2 tie_x0
xfeed_23 1 2 tie_x0
xfeed_22 1 2 tie_x0
xfeed_21 1 2 tie_x0
xfeed_20 1 2 tie_x0
xsubckt_410_nao22_x1 1 2 503 1724 520 505 nao22_x1
xsubckt_272_a2_x2 1 2 641 47 763 a2_x2
xsubckt_282_a2_x2 1 2 631 633 632 a2_x2
xsubckt_320_nao22_x1 1 2 593 596 734 741 nao22_x1
xsubckt_721_a2_x2 1 2 195 197 196 a2_x2
xsubckt_753_nxr2_x1 1 2 164 174 169 nxr2_x1
xsubckt_556_a2_x2 1 2 358 366 359 a2_x2
xsubckt_725_an12_x1 1 2 191 200 192 an12_x1
xsubckt_756_noa2ao222_x1 1 2 161 162 259 349 262 265 noa2ao222_x1
xsubckt_1278_nao22_x1 1 2 1124 1385 1125 49 nao22_x1
xfeed_39 1 2 tie_x0
xfeed_38 1 2 tie_x0
xfeed_37 1 2 tie_x0
xfeed_36 1 2 tie_x0
xfeed_35 1 2 rowend_x0
xfeed_34 1 2 tie_x0
xfeed_33 1 2 tie_x0
xfeed_32 1 2 tie_x0
xfeed_31 1 2 tie_x0
xfeed_30 1 2 tie_x0
xsubckt_874_oa2ao222_x2 1 2 1498 1572 1570 1569 1513 1512 oa2ao222_x2
xsubckt_921_na4_x1 1 2 1452 1536 1526 1525 1517 na4_x1
xsubckt_1402_an12_x1 1 2 1012 1016 1013 an12_x1
xsubckt_1351_nao22_x1 1 2 1057 1058 391 432 nao22_x1
xsubckt_1321_a3_x2 1 2 1084 1094 1089 1085 a3_x2
xsubckt_1290_oa2ao222_x2 1 2 1113 1114 1116 1269 1271 1248 oa2ao222_x2
xsubckt_400_na3_x1 1 2 513 893 603 587 na3_x1
xsubckt_143_na4_x1 1 2 768 48 771 770 769 na4_x1
xsubckt_905_o3_x2 1 2 1467 1471 1470 1469 o3_x2
xsubckt_1126_a3_x2 1 2 1266 1375 1361 1288 a3_x2
xfeed_46 1 2 rowend_x0
xfeed_45 1 2 tie_x0
xfeed_44 1 2 tie_x0
xfeed_43 1 2 tie_x0
xfeed_42 1 2 tie_x0
xfeed_41 1 2 tie_x0
xfeed_40 1 2 tie_x0
xsubckt_1432_mx2_x2 1 2 1651 1749 77 1000 mx2_x2
xsubckt_1431_mx2_x2 1 2 1652 1750 78 1000 mx2_x2
xsubckt_1430_mx2_x2 1 2 1653 1751 79 1000 mx2_x2
xsubckt_1361_a3_x2 1 2 1047 1054 1052 1048 a3_x2
xsubckt_620_na2_x1 1 2 294 904 634 na2_x1
xsubckt_541_an12_x1 1 2 373 461 375 an12_x1
xsubckt_425_ao22_x2 1 2 488 565 580 657 ao22_x2
xsubckt_408_na3_x1 1 2 505 517 516 506 na3_x1
xsubckt_149_na4_x1 1 2 762 809 773 765 764 na4_x1
xsubckt_1272_ao22_x2 1 2 1130 60 1284 1249 ao22_x2
xfeed_49 1 2 tie_x0
xfeed_48 1 2 tie_x0
xfeed_47 1 2 tie_x0
xsubckt_1671_sff1r_x4 1 2 40 11 1605 sff1r_x4
xsubckt_625_na2_x1 1 2 289 461 291 na2_x1
xsubckt_497_na4_x1 1 2 416 9 45 148 681 na4_x1
xsubckt_105_on12_x1 1 2 806 1744 48 on12_x1
xsubckt_232_na2_x1 1 2 680 47 681 na2_x1
xsubckt_1081_nao22_x1 1 2 1696 1306 1333 1341 nao22_x1
xsubckt_1241_o4_x2 1 2 1159 642 639 1387 1385 o4_x2
xfeed_53 1 2 rowend_x0
xfeed_52 1 2 tie_x0
xfeed_51 1 2 tie_x0
xfeed_50 1 2 tie_x0
xsubckt_1581_sff1r_x4 1 2 49 11 1695 sff1r_x4
xsubckt_1548_a2_x2 1 2 927 929 928 a2_x2
xsubckt_1342_oa2ao222_x2 1 2 1065 1066 1068 1269 1271 1248 oa2ao222_x2
xsubckt_971_na2_x1 1 2 1404 635 1405 na2_x1
xsubckt_1124_o3_x2 1 2 1268 1353 1272 1270 o3_x2
xfeed_59 1 2 tie_x0
xfeed_58 1 2 tie_x0
xfeed_57 1 2 tie_x0
xfeed_56 1 2 tie_x0
xfeed_55 1 2 tie_x0
xfeed_54 1 2 tie_x0
xsubckt_1474_na2_x1 1 2 1645 969 964 na2_x1
xsubckt_1291_nao22_x1 1 2 1112 1753 1329 1264 nao22_x1
xsubckt_609_nao22_x1 1 2 305 1722 520 505 nao22_x1
xsubckt_589_na2_x1 1 2 325 342 330 na2_x1
xsubckt_368_ao22_x2 1 2 545 1744 547 896 ao22_x2
xsubckt_40_inv_x1 1 2 870 59 inv_x1
xsubckt_194_na2_x1 1 2 718 787 765 na2_x1
xsubckt_195_na2_x1 1 2 717 720 718 na2_x1
xsubckt_978_na2_x1 1 2 1397 672 1399 na2_x1
xsubckt_1128_na2_x1 1 2 1264 1289 1266 na2_x1
xsubckt_1176_ao22_x2 1 2 1219 65 1284 1249 ao22_x2
xsubckt_1254_xr2_x4 1 2 1147 68 67 xr2_x4
xfeed_60 1 2 tie_x0
xsubckt_41_inv_x1 1 2 869 1737 inv_x1
xsubckt_42_inv_x1 1 2 868 51 inv_x1
xsubckt_43_inv_x1 1 2 867 50 inv_x1
xsubckt_44_inv_x1 1 2 866 64 inv_x1
xsubckt_45_inv_x1 1 2 865 58 inv_x1
xsubckt_46_inv_x1 1 2 864 1736 inv_x1
xsubckt_1085_na2_x1 1 2 1303 52 1304 na2_x1
xsubckt_1113_no3_x1 1 2 1278 1299 1297 1279 no3_x1
xfeed_69 1 2 tie_x0
xfeed_68 1 2 tie_x0
xfeed_67 1 2 rowend_x0
xfeed_66 1 2 tie_x0
xfeed_65 1 2 tie_x0
xfeed_64 1 2 tie_x0
xfeed_63 1 2 tie_x0
xfeed_62 1 2 tie_x0
xfeed_61 1 2 tie_x0
xsubckt_1604_sff1_x4 1 2 147 1672 sff1_x4
xsubckt_47_inv_x1 1 2 863 63 inv_x1
xsubckt_48_inv_x1 1 2 862 57 inv_x1
xsubckt_49_inv_x1 1 2 861 1735 inv_x1
xsubckt_290_nao22_x1 1 2 623 1756 630 624 nao22_x1
xsubckt_306_a3_x2 1 2 607 9 46 676 a3_x2
xsubckt_831_oa2a2a23_x2 1 2 1541 909 634 489 1749 467 77 oa2a2a23_x2
xsubckt_909_nao22_x1 1 2 1463 57 753 750 nao22_x1
xsubckt_1639_sff1_x4 1 2 1735 1637 sff1_x4
xsubckt_1590_sff1_x4 1 2 64 1686 sff1_x4
xsubckt_209_a2_x2 1 2 703 47 705 a2_x2
xsubckt_249_nao22_x1 1 2 663 681 44 45 nao22_x1
xfeed_79 1 2 tie_x0
xfeed_78 1 2 tie_x0
xfeed_77 1 2 tie_x0
xfeed_76 1 2 tie_x0
xfeed_75 1 2 tie_x0
xfeed_74 1 2 tie_x0
xfeed_73 1 2 tie_x0
xfeed_72 1 2 tie_x0
xfeed_71 1 2 tie_x0
xfeed_70 1 2 tie_x0
xsubckt_1586_sff1_x4 1 2 54 1690 sff1_x4
xsubckt_580_ao22_x2 1 2 334 335 584 869 ao22_x2
xsubckt_444_a2_x2 1 2 469 471 470 a2_x2
xsubckt_412_nao22_x1 1 2 501 503 521 853 nao22_x1
xsubckt_190_a2_x2 1 2 722 1746 1743 a2_x2
xsubckt_239_a2_x2 1 2 673 46 676 a2_x2
xsubckt_815_a3_x2 1 2 1557 55 569 568 a3_x2
xsubckt_1643_sff1r_x4 1 2 1715 11 1633 sff1r_x4
xsubckt_1533_nao22_x1 1 2 940 13 12 815 nao22_x1
xsubckt_218_ao2o22_x2 1 2 694 889 702 697 890 ao2o22_x2
xsubckt_748_a2_x2 1 2 169 461 170 a2_x2
xsubckt_923_a2_x2 1 2 1450 1452 1451 a2_x2
xsubckt_980_nao22_x1 1 2 1395 77 673 1400 nao22_x1
xsubckt_1111_a4_x2 1 2 1280 1296 1293 1288 1281 a4_x2
xfeed_89 1 2 tie_x0
xfeed_88 1 2 tie_x0
xfeed_87 1 2 tie_x0
xfeed_86 1 2 rowend_x0
xfeed_85 1 2 tie_x0
xfeed_84 1 2 tie_x0
xfeed_83 1 2 tie_x0
xfeed_82 1 2 tie_x0
xfeed_81 1 2 tie_x0
xfeed_80 1 2 rowend_x0
xsubckt_953_a2_x2 1 2 1421 1434 1423 a2_x2
xsubckt_1308_a3_x2 1 2 1096 1106 1101 1097 a3_x2
xsubckt_600_na3_x1 1 2 314 60 569 568 na3_x1
xsubckt_484_ao22_x2 1 2 429 463 501 550 ao22_x2
xsubckt_1044_a3_x2 1 2 1335 1474 1468 1336 a3_x2
xsubckt_1247_noa22_x1 1 2 1153 1716 638 1386 noa22_x1
xsubckt_1263_nao22_x1 1 2 1138 1139 1160 1715 nao22_x1
xfeed_99 1 2 tie_x0
xfeed_98 1 2 tie_x0
xfeed_97 1 2 tie_x0
xfeed_96 1 2 tie_x0
xfeed_95 1 2 tie_x0
xfeed_94 1 2 tie_x0
xfeed_93 1 2 tie_x0
xfeed_92 1 2 tie_x0
xfeed_91 1 2 tie_x0
xfeed_90 1 2 tie_x0
xsubckt_217_na3_x1 1 2 695 46 711 709 na3_x1
xsubckt_669_nao22_x1 1 2 245 247 501 550 nao22_x1
xsubckt_869_oa2ao222_x2 1 2 1503 1538 1514 1507 478 635 oa2ao222_x2
xsubckt_1103_na3_x1 1 2 1288 9 44 681 na3_x1
xsubckt_1173_nao22_x1 1 2 1222 1295 183 207 nao22_x1
xsubckt_1288_ao22_x2 1 2 1115 59 1284 1249 ao22_x2
xsubckt_125_on12_x1 1 2 786 1747 1748 on12_x1
xsubckt_175_na3_x1 1 2 737 800 771 739 na3_x1
xsubckt_821_na2_x1 1 2 1551 1558 1552 na2_x1
xsubckt_1244_mx2_x2 1 2 1156 1268 1247 878 mx2_x2
xsubckt_1583_sff1r_x4 1 2 51 11 1693 sff1r_x4
xsubckt_1456_na3_x1 1 2 979 59 1267 996 na3_x1
xsubckt_1322_na2_x1 1 2 1677 1095 1084 na2_x1
xsubckt_1298_o4_x2 1 2 1106 835 1165 1161 1158 o4_x2
xsubckt_439_na2_x1 1 2 474 494 478 na2_x1
xsubckt_652_nao22_x1 1 2 262 434 278 264 nao22_x1
xsubckt_828_na2_x1 1 2 1544 909 634 na2_x1
xsubckt_837_ao22_x2 1 2 1535 78 621 614 ao22_x2
xsubckt_879_nao22_x1 1 2 1493 1494 1503 1505 nao22_x1
xsubckt_1063_na3_x1 1 2 1317 47 1343 1318 na3_x1
xsubckt_1065_na3_x1 1 2 1316 46 1343 1318 na3_x1
xsubckt_1293_nao22_x1 1 2 1110 1111 1160 1713 nao22_x1
xsubckt_394_na2_x1 1 2 519 542 539 na2_x1
xsubckt_1067_na3_x1 1 2 1315 45 1343 1318 na3_x1
xsubckt_1069_na3_x1 1 2 1314 44 1343 1318 na3_x1
xsubckt_1115_nao22_x1 1 2 1691 1277 1363 565 nao22_x1
xsubckt_1157_ao22_x2 1 2 1236 53 1284 1249 ao22_x2
xsubckt_1196_ao22_x2 1 2 1201 1384 1263 829 ao22_x2
xsubckt_1663_sff1_x4 1 2 1719 1613 sff1_x4
xsubckt_1385_oa2ao222_x2 1 2 1027 1209 1206 1269 1248 1271 oa2ao222_x2
xsubckt_1283_na2_x1 1 2 1680 1134 1120 na2_x1
xsubckt_399_na2_x1 1 2 514 587 534 na2_x1
xsubckt_351_a4_x2 1 2 562 46 773 772 710 a4_x2
xsubckt_261_ao22_x2 1 2 651 45 676 671 ao22_x2
xsubckt_699_nao22_x1 1 2 216 779 229 219 nao22_x1
xsubckt_746_noa2a2a23_x1 1 2 171 906 634 489 1752 467 80 noa2a2a23_x1
xsubckt_938_nxr2_x1 1 2 1436 1493 1437 nxr2_x1
xsubckt_1624_sff1_x4 1 2 1750 1652 sff1_x4
xsubckt_389_no3_x1 1 2 524 529 526 525 no3_x1
xsubckt_381_a4_x2 1 2 532 895 809 800 587 a4_x2
xsubckt_371_a4_x2 1 2 542 9 46 711 709 a4_x2
xsubckt_196_a4_x2 1 2 716 725 723 720 718 a4_x2
xsubckt_204_a3_x2 1 2 708 47 711 709 a3_x2
xsubckt_257_ao22_x2 1 2 655 724 734 741 ao22_x2
xsubckt_1122_nao2o22_x1 1 2 1270 881 768 1388 888 nao2o22_x1
xsubckt_1659_sff1_x4 1 2 1723 1617 sff1_x4
xsubckt_504_nao22_x1 1 2 409 1723 520 505 nao22_x1
xsubckt_127_a2_x2 1 2 784 895 812 a2_x2
xsubckt_653_ao22_x2 1 2 261 354 266 263 ao22_x2
xsubckt_703_a3_x2 1 2 212 215 214 213 a3_x2
xsubckt_1380_noa2ao222_x1 1 2 1031 81 1329 1055 760 668 noa2ao222_x1
xsubckt_606_a2_x2 1 2 308 315 309 a2_x2
xsubckt_367_oa2ao222_x2 1 2 546 784 744 788 743 747 oa2ao222_x2
xsubckt_362_a2_x2 1 2 551 623 552 a2_x2
xsubckt_342_a2_x2 1 2 571 770 573 a2_x2
xsubckt_332_a2_x2 1 2 581 1743 1742 a2_x2
xsubckt_157_a2_x2 1 2 754 8 7 a2_x2
xsubckt_177_a2_x2 1 2 735 737 736 a2_x2
xsubckt_783_a3_x2 1 2 1588 156 155 1589 a3_x2
xsubckt_1645_sff1r_x4 1 2 1713 11 1631 sff1r_x4
xsubckt_1535_nao22_x1 1 2 939 82 673 1400 nao22_x1
xsubckt_656_a2_x2 1 2 258 350 259 a2_x2
xsubckt_982_nao22_x1 1 2 1707 1394 1401 1406 nao22_x1
xsubckt_1445_nao22_x1 1 2 988 1268 1147 1145 nao22_x1
xsubckt_1138_a4_x2 1 2 1254 58 57 56 1257 a4_x2
xsubckt_534_nao22_x1 1 2 380 474 406 404 nao22_x1
xsubckt_1188_a4_x2 1 2 1208 66 65 64 1239 a4_x2
xsubckt_1226_a3_x2 1 2 1174 548 541 516 a3_x2
xspare_buffer_9 1 2 buf_x8
xspare_buffer_8 1 2 buf_x8
xspare_buffer_6 1 2 buf_x8
xspare_buffer_5 1 2 buf_x8
xspare_buffer_4 1 2 buf_x8
xspare_buffer_0 1 2 14 buf_x8
xsubckt_415_na3_x1 1 2 498 42 814 797 na3_x1
xsubckt_146_an12_x1 1 2 765 48 1741 an12_x1
xsubckt_95_on12_x1 1 2 815 16 36 on12_x1
xsubckt_761_na3_x1 1 2 156 434 159 157 na3_x1
xsubckt_808_na3_x1 1 2 1564 166 159 1571 na3_x1
xsubckt_809_na3_x1 1 2 1563 434 1565 1564 na3_x1
xsubckt_871_oa2ao222_x2 1 2 1501 635 475 1524 1516 461 oa2ao222_x2
xsubckt_1060_a2_x2 1 2 1319 1325 1320 a2_x2
xsubckt_1266_a3_x2 1 2 1135 1148 1143 1136 a3_x2
xsubckt_1311_o4_x2 1 2 1094 830 1165 1161 1158 o4_x2
xsubckt_1296_a3_x2 1 2 1107 1118 1113 1108 a3_x2
xsubckt_240_na2_x1 1 2 672 46 676 na2_x1
xsubckt_899_na4_x1 1 2 1473 150 1594 1593 1575 na4_x1
xsubckt_1046_na4_x1 1 2 1333 1446 1434 1423 1335 na4_x1
xsubckt_1080_a2_x2 1 2 1306 1311 1307 a2_x2
xsubckt_1139_a2_x2 1 2 1253 55 1254 a2_x2
xsubckt_1585_sff1r_x4 1 2 36 11 1691 sff1r_x4
xsubckt_1300_nxr2_x1 1 2 1104 58 1257 nxr2_x1
xsubckt_638_na2_x1 1 2 276 279 277 na2_x1
xsubckt_591_na2_x1 1 2 323 331 329 na2_x1
xsubckt_378_na3_x1 1 2 535 9 1743 687 na3_x1
xsubckt_373_ao22_x2 1 2 540 1746 732 896 ao22_x2
xsubckt_243_na2_x1 1 2 669 46 681 na2_x1
xsubckt_245_na2_x1 1 2 667 6 16 na2_x1
xsubckt_988_o2_x2 1 2 1388 777 1390 o2_x2
xsubckt_1199_a2_x2 1 2 1198 63 1208 a2_x2
xsubckt_1481_na2_x1 1 2 1644 963 958 na2_x1
xsubckt_730_ao22_x2 1 2 186 247 300 302 ao22_x2
xsubckt_985_na2_x1 1 2 1391 888 1393 na2_x1
xsubckt_569_oa2a2a23_x2 1 2 345 905 634 489 1753 467 81 oa2a2a23_x2
xsubckt_50_inv_x1 1 2 860 62 inv_x1
xsubckt_51_inv_x1 1 2 859 56 inv_x1
xsubckt_52_inv_x1 1 2 858 1734 inv_x1
xsubckt_53_inv_x1 1 2 857 61 inv_x1
xsubckt_1090_na2_x1 1 2 1301 678 570 na2_x1
xsubckt_1117_nao22_x1 1 2 1275 9 4 666 nao22_x1
xsubckt_1123_no3_x1 1 2 1269 1353 1272 1270 no3_x1
xsubckt_1605_sff1_x4 1 2 146 1671 sff1_x4
xsubckt_1488_na2_x1 1 2 1643 957 952 na2_x1
xsubckt_531_noa2ao222_x1 1 2 382 41 758 384 386 1740 noa2ao222_x1
xsubckt_453_no2_x1 1 2 460 464 462 no2_x1
xsubckt_112_a3_x2 1 2 799 48 1742 1741 a3_x2
xsubckt_109_no2_x1 1 2 802 42 43 no2_x1
xsubckt_54_inv_x1 1 2 856 55 inv_x1
xsubckt_55_inv_x1 1 2 855 1733 inv_x1
xsubckt_56_inv_x1 1 2 854 1756 inv_x1
xsubckt_57_inv_x1 1 2 853 1732 inv_x1
xsubckt_58_inv_x1 1 2 852 149 inv_x1
xsubckt_59_inv_x1 1 2 851 84 inv_x1
xsubckt_277_ao22_x2 1 2 636 778 7 8 ao22_x2
xsubckt_846_no2_x1 1 2 1526 1535 1527 no2_x1
xsubckt_1095_noa2ao222_x1 1 2 1296 679 46 45 44 671 noa2ao222_x1
xsubckt_1591_sff1_x4 1 2 63 1685 sff1_x4
xsubckt_436_a3_x2 1 2 477 500 492 487 a3_x2
xsubckt_1190_nxr2_x1 1 2 1206 64 1217 nxr2_x1
xspare_feed_13 1 2 tie_x0
xspare_feed_12 1 2 tie_x0
xspare_feed_11 1 2 tie_x0
xspare_feed_10 1 2 tie_x0
xsubckt_1489_noa2ao222_x1 1 2 951 528 511 589 805 813 noa2ao222_x1
xsubckt_594_nao22_x1 1 2 320 343 322 634 nao22_x1
xsubckt_466_a3_x2 1 2 447 658 581 448 a3_x2
xsubckt_309_a2_x2 1 2 604 1747 1744 a2_x2
xsubckt_915_a3_x2 1 2 1458 353 1488 1479 a3_x2
xsubckt_925_oa2a2a23_x2 1 2 1448 402 1547 1523 396 247 1591 oa2a2a23_x2
xsubckt_1147_nao22_x1 1 2 1245 54 1284 1249 nao22_x1
xspare_feed_19 1 2 tie_x0
xspare_feed_18 1 2 tie_x0
xspare_feed_17 1 2 tie_x0
xspare_feed_16 1 2 tie_x0
xspare_feed_15 1 2 tie_x0
xspare_feed_14 1 2 tie_x0
xsubckt_1647_sff1r_x4 1 2 1711 11 1629 sff1r_x4
xsubckt_1587_sff1_x4 1 2 53 1689 sff1_x4
xsubckt_564_a2_x2 1 2 350 476 351 a2_x2
xsubckt_818_a2_x2 1 2 1554 1556 1555 a2_x2
xsubckt_975_a3_x2 1 2 1400 892 46 683 a3_x2
xspare_feed_20 1 2 tie_x0
xsubckt_1310_nao22_x1 1 2 1095 1165 1467 1475 nao22_x1
xsubckt_716_nao22_x1 1 2 200 80 621 614 nao22_x1
xsubckt_894_nao22_x1 1 2 1478 350 1487 1481 nao22_x1
xsubckt_1036_a4_x2 1 2 1343 1362 1356 1354 1345 a4_x2
xsubckt_1220_nao22_x1 1 2 1179 61 1284 1249 nao22_x1
xspare_feed_29 1 2 rowend_x0
xspare_feed_28 1 2 rowend_x0
xspare_feed_27 1 2 tie_x0
xspare_feed_26 1 2 rowend_x0
xspare_feed_25 1 2 tie_x0
xspare_feed_24 1 2 rowend_x0
xspare_feed_23 1 2 rowend_x0
xspare_feed_22 1 2 tie_x0
xspare_feed_21 1 2 rowend_x0
xsubckt_522_o2_x2 1 2 391 433 392 o2_x2
xsubckt_411_ao22_x2 1 2 502 503 521 853 ao22_x2
xsubckt_366_noa2ao222_x1 1 2 547 784 744 788 743 747 noa2ao222_x1
xsubckt_279_o3_x2 1 2 634 642 639 636 o3_x2
xsubckt_643_nxr2_x1 1 2 271 284 282 nxr2_x1
xsubckt_1016_nxr2_x1 1 2 1363 77 1365 nxr2_x1
xsubckt_1134_a3_x2 1 2 1258 68 67 60 a3_x2
xspare_feed_9 1 2 tie_x0
xspare_feed_8 1 2 tie_x0
xspare_feed_7 1 2 tie_x0
xspare_feed_6 1 2 tie_x0
xspare_feed_5 1 2 tie_x0
xspare_feed_4 1 2 tie_x0
xspare_feed_3 1 2 tie_x0
xspare_feed_2 1 2 tie_x0
xspare_feed_1 1 2 tie_x0
xspare_feed_0 1 2 tie_x0
xsubckt_542_o2_x2 1 2 372 462 375 o2_x2
xsubckt_356_na4_x1 1 2 557 9 45 149 681 na4_x1
xsubckt_166_an12_x1 1 2 746 1743 1742 an12_x1
xsubckt_1037_a2_x2 1 2 1342 9 4 a2_x2
xsubckt_1177_nao22_x1 1 2 1218 65 1284 1249 nao22_x1
xspare_feed_39 1 2 rowend_x0
xspare_feed_38 1 2 rowend_x0
xspare_feed_37 1 2 tie_x0
xspare_feed_36 1 2 rowend_x0
xspare_feed_35 1 2 tie_x0
xspare_feed_34 1 2 rowend_x0
xspare_feed_33 1 2 rowend_x0
xspare_feed_32 1 2 tie_x0
xspare_feed_31 1 2 rowend_x0
xspare_feed_30 1 2 tie_x0
xsubckt_836_nao22_x1 1 2 1536 1750 630 624 nao22_x1
xsubckt_922_oa2ao222_x2 1 2 1451 428 1524 1517 658 790 oa2ao222_x2
xsubckt_1057_a2_x2 1 2 1322 1324 1323 a2_x2
xsubckt_1477_nao22_x1 1 2 961 1750 1290 1265 nao22_x1
xsubckt_1462_na3_x1 1 2 974 58 1267 996 na3_x1
xsubckt_1292_a2_x2 1 2 1111 1139 1126 a2_x2
xsubckt_575_na3_x1 1 2 339 59 569 568 na3_x1
xsubckt_447_na2_x1 1 2 466 902 634 na2_x1
xsubckt_994_ao2o22_x2 1 2 1382 759 667 665 897 ao2o22_x2
xsubckt_1071_na3_x1 1 2 1313 43 1343 1318 na3_x1
xsubckt_1073_na3_x1 1 2 1312 42 1343 1318 na3_x1
xspare_feed_49 1 2 rowend_x0
xspare_feed_48 1 2 rowend_x0
xspare_feed_47 1 2 tie_x0
xspare_feed_46 1 2 rowend_x0
xspare_feed_45 1 2 tie_x0
xspare_feed_44 1 2 rowend_x0
xspare_feed_43 1 2 rowend_x0
xspare_feed_42 1 2 tie_x0
xspare_feed_41 1 2 rowend_x0
xspare_feed_40 1 2 tie_x0
xsubckt_1469_na3_x1 1 2 968 57 1267 996 na3_x1
xsubckt_1379_oa2ao222_x2 1 2 1032 1218 1215 1269 1248 1271 oa2ao222_x2
xsubckt_1335_na2_x1 1 2 1676 1083 1072 na2_x1
xsubckt_547_nxr2_x1 1 2 367 370 368 nxr2_x1
xsubckt_795_na2_x1 1 2 1577 907 634 na2_x1
xsubckt_1077_na3_x1 1 2 1309 898 818 12 na3_x1
xsubckt_1078_na3_x1 1 2 1308 1708 898 15 na3_x1
xsubckt_1209_nao22_x1 1 2 1189 62 1284 1249 nao22_x1
xsubckt_1550_nao22_x1 1 2 926 83 673 1400 nao22_x1
xsubckt_223_ao22_x2 1 2 689 731 734 741 ao22_x2
xsubckt_782_no3_x1 1 2 1589 152 151 1590 no3_x1
xsubckt_956_nao22_x1 1 2 1418 55 753 750 nao22_x1
xsubckt_1197_ao22_x2 1 2 1200 63 1284 1249 ao22_x2
xspare_feed_54 1 2 rowend_x0
xspare_feed_53 1 2 rowend_x0
xspare_feed_52 1 2 tie_x0
xspare_feed_51 1 2 rowend_x0
xspare_feed_50 1 2 tie_x0
xsubckt_1664_sff1_x4 1 2 1718 1612 sff1_x4
xsubckt_1625_sff1_x4 1 2 1749 1651 sff1_x4
xsubckt_1570_sff1r_x4 1 2 8 11 1706 sff1r_x4
xsubckt_1370_nao22_x1 1 2 1040 1058 219 229 nao22_x1
xsubckt_1297_na2_x1 1 2 1679 1119 1107 na2_x1
xsubckt_471_a4_x2 1 2 442 627 500 492 487 a4_x2
xsubckt_451_a4_x2 1 2 462 635 500 492 487 a4_x2
xsubckt_118_nao22_x1 1 2 793 804 810 887 nao22_x1
xsubckt_236_a4_x2 1 2 676 1742 771 765 764 a4_x2
xsubckt_246_a4_x2 1 2 666 8 7 6 16 a4_x2
xsubckt_866_nao22_x1 1 2 1506 1511 1509 1566 nao22_x1
xsubckt_939_nxr2_x1 1 2 1435 1438 1436 nxr2_x1
xsubckt_1264_noa22_x1 1 2 1137 1138 1352 83 noa22_x1
xsubckt_1444_noa2ao222_x1 1 2 989 1755 1290 1265 1141 1140 noa2ao222_x1
xsubckt_354_a3_x2 1 2 559 9 45 681 a3_x2
xsubckt_169_a3_x2 1 2 743 895 1741 746 a3_x2
xsubckt_267_no2_x1 1 2 645 696 693 no2_x1
xsubckt_623_oa2a2a23_x2 1 2 291 904 634 489 1754 467 82 oa2a2a23_x2
xsubckt_422_a2_x2 1 2 491 541 516 a2_x2
xsubckt_689_ao22_x2 1 2 226 291 300 302 ao22_x2
xsubckt_819_an12_x1 1 2 1553 1554 1557 an12_x1
xsubckt_1012_nao22_x1 1 2 1367 402 501 550 nao22_x1
xsubckt_287_a2_x2 1 2 626 628 627 a2_x2
xsubckt_297_a2_x2 1 2 616 815 617 a2_x2
xsubckt_901_a2_x2 1 2 1471 1473 1472 a2_x2
xsubckt_1649_sff1r_x4 1 2 1709 11 1627 sff1r_x4
xsubckt_1294_noa22_x1 1 2 1109 1110 1352 81 noa22_x1
xsubckt_628_nao22_x1 1 2 286 289 298 634 nao22_x1
xsubckt_733_o4_x2 1 2 183 203 187 186 185 o4_x2
xsubckt_951_a2_x2 1 2 1423 1427 1424 a2_x2
xsubckt_991_a2_x2 1 2 1385 760 668 a2_x2
xsubckt_1051_an12_x1 1 2 1328 622 1330 an12_x1
xsubckt_1423_a4_x2 1 2 1001 631 1351 1174 1002 a4_x2
xsubckt_1327_ao22_x2 1 2 1079 56 1284 1249 ao22_x2
xsubckt_151_an12_x1 1 2 760 7 8 an12_x1
xsubckt_941_na4_x1 1 2 1433 1560 1550 1549 1542 na4_x1
xsubckt_1022_a3_x2 1 2 1357 632 537 1358 a3_x2
xsubckt_424_na3_x1 1 2 489 541 537 516 na3_x1
xsubckt_97_an12_x1 1 2 814 1747 1748 an12_x1
xsubckt_164_na4_x1 1 2 0 791 781 755 748 na4_x1
xsubckt_701_nao22_x1 1 2 214 66 775 766 nao22_x1
xsubckt_928_nao22_x1 1 2 1445 1447 1453 1454 nao22_x1
xsubckt_659_nxr2_x1 1 2 255 358 258 nxr2_x1
xsubckt_838_nao22_x1 1 2 1534 908 605 599 nao22_x1
xsubckt_1249_a2_x2 1 2 1151 1154 1152 a2_x2
xsubckt_1479_nao22_x1 1 2 959 1268 1081 1079 nao22_x1
xsubckt_1464_a2_x2 1 2 972 1111 973 a2_x2
xsubckt_521_nao22_x1 1 2 392 393 426 431 nao22_x1
xsubckt_990_na2_x1 1 2 1386 1391 1389 na2_x1
xsubckt_1252_nao22_x1 1 2 1149 1165 241 255 nao22_x1
xsubckt_1534_na2_x1 1 2 1609 941 940 na2_x1
xsubckt_1389_nao22_x1 1 2 1670 1024 1059 1588 nao22_x1
xsubckt_992_na2_x1 1 2 1384 760 668 na2_x1
xsubckt_993_na2_x1 1 2 1383 9 666 na2_x1
xsubckt_1162_nao22_x1 1 2 1232 1295 219 229 nao22_x1
xsubckt_1276_na3_x1 1 2 1126 49 760 668 na3_x1
xsubckt_1610_sff1_x4 1 2 1748 1666 sff1_x4
xsubckt_1552_nao22_x1 1 2 1606 925 1333 1406 nao22_x1
xsubckt_144_a4_x2 1 2 767 48 771 770 769 a4_x2
xsubckt_114_a4_x2 1 2 797 48 1746 1742 1741 a4_x2
xsubckt_60_inv_x1 1 2 850 1755 inv_x1
xsubckt_731_nao22_x1 1 2 185 202 324 397 nao22_x1
xsubckt_1572_sff1r_x4 1 2 6 11 1704 sff1r_x4
xsubckt_61_inv_x1 1 2 849 1731 inv_x1
xsubckt_62_inv_x1 1 2 848 148 inv_x1
xsubckt_63_inv_x1 1 2 847 83 inv_x1
xsubckt_64_inv_x1 1 2 846 1754 inv_x1
xsubckt_65_inv_x1 1 2 845 1730 inv_x1
xsubckt_66_inv_x1 1 2 844 141 inv_x1
xsubckt_212_a3_x2 1 2 700 47 747 711 a3_x2
xsubckt_843_an12_x1 1 2 1529 1530 1533 an12_x1
xsubckt_885_noa2ao222_x1 1 2 1487 1494 1503 1505 1562 1489 noa2ao222_x1
xsubckt_1606_sff1_x4 1 2 145 1670 sff1_x4
xsubckt_516_a3_x2 1 2 397 620 615 399 a3_x2
xsubckt_478_a4_x2 1 2 435 635 492 487 479 a4_x2
xsubckt_115_a2_x2 1 2 796 814 797 a2_x2
xsubckt_67_inv_x1 1 2 843 82 inv_x1
xsubckt_68_inv_x1 1 2 842 1753 inv_x1
xsubckt_69_inv_x1 1 2 841 1729 inv_x1
xsubckt_1592_sff1_x4 1 2 62 1684 sff1_x4
xsubckt_598_nao22_x1 1 2 316 82 621 614 nao22_x1
xsubckt_360_a2_x2 1 2 553 597 554 a2_x2
xsubckt_145_a2_x2 1 2 766 45 767 a2_x2
xsubckt_165_a2_x2 1 2 747 807 772 a2_x2
xsubckt_764_oa2ao222_x2 1 2 153 428 189 171 658 790 oa2ao222_x2
xsubckt_1588_sff1_x4 1 2 66 1688 sff1_x4
xsubckt_1404_nao22_x1 1 2 1011 1058 1422 1435 nao22_x1
xsubckt_624_a2_x2 1 2 290 461 291 a2_x2
xsubckt_604_a2_x2 1 2 310 314 311 a2_x2
xsubckt_459_a2_x2 1 2 454 565 537 a2_x2
xsubckt_419_a2_x2 1 2 494 500 495 a2_x2
xsubckt_390_a2_x2 1 2 523 535 524 a2_x2
xsubckt_370_a2_x2 1 2 543 548 544 a2_x2
xsubckt_791_a3_x2 1 2 1580 1586 1585 1581 a3_x2
xsubckt_864_oa2ao222_x2 1 2 1508 635 477 1592 1577 1576 oa2ao222_x2
xsubckt_524_o3_x2 1 2 389 433 432 392 o3_x2
xsubckt_499_a2_x2 1 2 414 418 415 a2_x2
xsubckt_674_a2_x2 1 2 240 254 242 a2_x2
xsubckt_694_a2_x2 1 2 221 223 222 a2_x2
xsubckt_948_a2_x2 1 2 1426 793 581 a2_x2
xsubckt_1564_noa2a2a23_x1 1 2 914 594 1516 918 917 916 915 noa2a2a23_x1
xsubckt_1329_oa2ao222_x2 1 2 1077 1078 1080 1269 1271 1248 oa2ao222_x2
xsubckt_935_ao22_x2 1 2 1439 1457 1456 1476 ao22_x2
xsubckt_1029_a3_x2 1 2 1350 9 47 681 a3_x2
xsubckt_1214_a3_x2 1 2 1184 1192 1191 1185 a3_x2
xsubckt_1424_an12_x1 1 2 1000 1001 1353 an12_x1
xsubckt_365_na4_x1 1 2 548 9 47 747 711 na4_x1
xsubckt_644_nxr2_x1 1 2 270 283 275 nxr2_x1
xsubckt_1059_a3_x2 1 2 1320 1324 1323 1321 a3_x2
xsubckt_1079_a3_x2 1 2 1307 816 1309 1308 a3_x2
xsubckt_1224_a3_x2 1 2 1175 1182 1181 1176 a3_x2
xsubckt_1434_nao22_x1 1 2 998 633 570 567 nao22_x1
xsubckt_629_na3_x1 1 2 285 635 297 290 na3_x1
xsubckt_369_na4_x1 1 2 544 9 711 691 545 na4_x1
xsubckt_884_nao2o22_x1 1 2 1488 1492 1491 1490 494 nao2o22_x1
xsubckt_973_na3_x1 1 2 1402 494 478 1403 na3_x1
xsubckt_1120_na3_x1 1 2 1272 1300 1298 1274 na3_x1
xsubckt_1167_a2_x2 1 2 1227 66 1239 a2_x2
xsubckt_1500_no4_x1 1 2 948 642 639 636 527 no4_x1
xsubckt_1344_nao22_x1 1 2 1063 1111 1160 1709 nao22_x1
xsubckt_108_na2_x1 1 2 803 810 804 na2_x1
xsubckt_845_na2_x1 1 2 1527 1534 1528 na2_x1
xsubckt_976_na3_x1 1 2 1399 892 46 683 na3_x1
xsubckt_986_o2_x2 1 2 1390 8 7 o2_x2
xsubckt_1127_na3_x1 1 2 1265 1375 1361 1288 na3_x1
xsubckt_1476_na3_x1 1 2 962 56 1267 996 na3_x1
xsubckt_1630_sff1_x4 1 2 58 1646 sff1_x4
xsubckt_1348_na2_x1 1 2 1675 1071 1060 na2_x1
xsubckt_1665_sff1_x4 1 2 1717 1611 sff1_x4
xsubckt_100_a3_x2 1 2 811 891 814 812 a3_x2
xsubckt_665_oa2a2a23_x2 1 2 249 593 425 410 408 377 376 oa2a2a23_x2
xsubckt_891_nxr2_x1 1 2 1481 354 1483 nxr2_x1
xsubckt_1626_sff1_x4 1 2 68 1650 sff1_x4
xsubckt_1299_nxr2_x1 1 2 1105 865 1257 nxr2_x1
xsubckt_1284_nao22_x1 1 2 1119 1165 183 207 nao22_x1
xsubckt_553_nao22_x1 1 2 361 369 365 363 nao22_x1
xsubckt_170_a3_x2 1 2 742 895 807 772 a3_x2
xsubckt_219_a3_x2 1 2 693 46 711 698 a3_x2
xsubckt_259_ao22_x2 1 2 653 46 676 671 ao22_x2
xsubckt_616_ao22_x2 1 2 298 474 302 300 ao22_x2
xsubckt_502_a2_x2 1 2 411 420 412 a2_x2
xsubckt_474_a3_x2 1 2 439 457 455 440 a3_x2
xsubckt_317_a2_x2 1 2 596 9 721 a2_x2
xsubckt_718_a3_x2 1 2 198 58 569 568 a3_x2
xsubckt_913_a3_x2 1 2 1459 1463 1462 1460 a3_x2
xsubckt_1194_nao22_x1 1 2 1203 1295 1467 1475 nao22_x1
xsubckt_562_a2_x2 1 2 352 356 353 a2_x2
xsubckt_377_a2_x2 1 2 536 9 687 a2_x2
xsubckt_357_a2_x2 1 2 556 560 557 a2_x2
xsubckt_347_a2_x2 1 2 566 569 568 a2_x2
xsubckt_855_noa2a2a23_x1 1 2 1517 908 634 489 1750 467 78 noa2a2a23_x1
xsubckt_933_a3_x2 1 2 1440 1443 1442 1441 a3_x2
xsubckt_602_na4_x1 1 2 312 9 45 141 681 na4_x1
xsubckt_582_a2_x2 1 2 332 341 333 a2_x2
xsubckt_387_a2_x2 1 2 526 1747 528 a2_x2
xsubckt_870_noa2ao222_x1 1 2 1502 635 475 1524 1516 461 noa2ao222_x1
xsubckt_920_ao22_x2 1 2 1453 1476 1458 1456 ao22_x2
xsubckt_1168_nxr2_x1 1 2 1226 874 1239 nxr2_x1
xsubckt_493_nao22_x1 1 2 420 83 621 614 nao22_x1
xsubckt_1503_mx2_x2 1 2 1633 1715 240 947 mx2_x2
xsubckt_1502_mx2_x2 1 2 1634 1716 390 947 mx2_x2
xsubckt_561_na4_x1 1 2 353 9 1743 40 685 na4_x1
xsubckt_859_oa2ao222_x2 1 2 1513 635 477 1524 1519 1518 oa2ao222_x2
xsubckt_1104_na4_x1 1 2 1287 891 809 773 710 na4_x1
xsubckt_1105_na4_x1 1 2 1286 891 809 773 710 na4_x1
xsubckt_1182_a3_x2 1 2 1213 1221 1220 1214 a3_x2
xsubckt_1192_a3_x2 1 2 1204 1212 1211 1205 a3_x2
xsubckt_1508_mx2_x2 1 2 1628 1710 1446 947 mx2_x2
xsubckt_1507_mx2_x2 1 2 1629 1711 1466 947 mx2_x2
xsubckt_1506_mx2_x2 1 2 1630 1712 1588 947 mx2_x2
xsubckt_1505_mx2_x2 1 2 1631 1713 182 947 mx2_x2
xsubckt_1504_mx2_x2 1 2 1632 1714 218 947 mx2_x2
xsubckt_1466_a3_x2 1 2 970 974 972 971 a3_x2
xsubckt_1446_a3_x2 1 2 987 990 989 988 a3_x2
xsubckt_437_na3_x1 1 2 476 500 492 487 na3_x1
xsubckt_302_na2_x1 1 2 611 47 612 na2_x1
xsubckt_780_na3_x1 1 2 1591 150 1594 1593 na3_x1
xsubckt_825_na3_x1 1 2 1547 1560 1550 1549 na3_x1
xsubckt_1035_a2_x2 1 2 1344 1354 1345 a2_x2
xsubckt_1509_mx2_x2 1 2 1627 1709 1421 947 mx2_x2
xsubckt_525_nao22_x1 1 2 388 779 432 391 nao22_x1
xsubckt_784_na3_x1 1 2 1587 156 155 1589 na3_x1
xsubckt_398_na3_x1 1 2 515 9 893 687 na3_x1
xsubckt_268_na2_x1 1 2 644 699 694 na2_x1
xsubckt_750_noa2ao222_x1 1 2 167 635 477 189 173 172 noa2ao222_x1
xsubckt_789_na3_x1 1 2 1582 778 760 1583 na3_x1
xsubckt_1150_na2_x1 1 2 1690 1276 1243 na2_x1
xsubckt_1166_nao22_x1 1 2 1228 66 1284 1249 nao22_x1
xsubckt_1650_sff1_x4 1 2 1732 1626 sff1_x4
xsubckt_1556_nao22_x1 1 2 921 81 673 1400 nao22_x1
xsubckt_567_ao2o22_x2 1 2 347 842 490 468 839 ao2o22_x2
xsubckt_121_no2_x1 1 2 790 1743 1742 no2_x1
xsubckt_255_nao22_x1 1 2 657 719 734 741 nao22_x1
xsubckt_1611_sff1_x4 1 2 1747 1665 sff1_x4
xsubckt_1475_oa2ao222_x2 1 2 963 1447 1453 1454 633 565 oa2ao222_x2
xsubckt_640_ao22_x2 1 2 274 286 283 275 ao22_x2
xsubckt_70_inv_x1 1 2 840 140 inv_x1
xsubckt_71_inv_x1 1 2 839 81 inv_x1
xsubckt_72_inv_x1 1 2 838 1752 inv_x1
xsubckt_73_inv_x1 1 2 837 1720 inv_x1
xsubckt_234_a4_x2 1 2 678 47 773 772 710 a4_x2
xsubckt_1607_sff1_x4 1 2 144 1669 sff1_x4
xsubckt_409_an12_x1 1 2 504 519 505 an12_x1
xsubckt_74_inv_x1 1 2 836 1728 inv_x1
xsubckt_75_inv_x1 1 2 835 139 inv_x1
xsubckt_76_inv_x1 1 2 834 80 inv_x1
xsubckt_77_inv_x1 1 2 833 1751 inv_x1
xsubckt_78_inv_x1 1 2 832 1719 inv_x1
xsubckt_79_inv_x1 1 2 831 1727 inv_x1
xsubckt_998_no3_x1 1 2 1378 817 777 1390 no3_x1
xsubckt_1013_ao22_x2 1 2 1366 1367 1548 246 ao22_x2
xsubckt_1593_sff1_x4 1 2 61 1683 sff1_x4
xsubckt_636_ao22_x2 1 2 278 318 288 281 ao22_x2
xsubckt_392_a3_x2 1 2 521 543 538 522 a3_x2
xsubckt_384_nao2o22_x1 1 2 529 588 533 531 580 nao2o22_x1
xsubckt_197_a3_x2 1 2 715 732 728 716 a3_x2
xsubckt_205_a2_x2 1 2 707 1746 1745 a2_x2
xsubckt_1589_sff1_x4 1 2 65 1687 sff1_x4
xsubckt_1318_nao22_x1 1 2 1087 1111 1160 1711 nao22_x1
xsubckt_579_a2_x2 1 2 335 339 336 a2_x2
xsubckt_505_ao22_x2 1 2 408 409 521 849 ao22_x2
xsubckt_734_a2_x2 1 2 182 206 184 a2_x2
xsubckt_1000_a3_x2 1 2 1376 9 776 668 a3_x2
xsubckt_1010_a3_x2 1 2 1369 350 1486 1480 a3_x2
xsubckt_1274_oa2ao222_x2 1 2 1128 1129 1131 1269 1271 1248 oa2ao222_x2
xsubckt_1491_a4_x2 1 2 949 619 617 355 950 a4_x2
xsubckt_1334_a3_x2 1 2 1072 1082 1077 1073 a3_x2
xsubckt_416_na4_x1 1 2 497 893 42 814 797 na4_x1
xsubckt_372_na4_x1 1 2 541 9 46 711 709 na4_x1
xsubckt_133_an12_x1 1 2 778 16 6 an12_x1
xsubckt_763_na4_x1 1 2 154 201 191 190 171 na4_x1
xsubckt_830_noa2a2a23_x1 1 2 1542 909 634 489 1749 467 77 noa2a2a23_x1
xsubckt_1119_a3_x2 1 2 1273 1300 1298 1274 a3_x2
xsubckt_1129_a3_x2 1 2 1263 633 1289 1266 a3_x2
xsubckt_1149_a3_x2 1 2 1243 1261 1260 1244 a3_x2
xsubckt_1520_na3_x1 1 2 944 9 896 689 na3_x1
xsubckt_1438_nao22_x1 1 2 994 1756 1290 1265 nao22_x1
xsubckt_1422_a2_x2 1 2 1002 537 1003 a2_x2
xsubckt_635_na3_x1 1 2 279 319 287 280 na3_x1
xsubckt_617_nao22_x1 1 2 297 474 302 300 nao22_x1
xsubckt_487_ao22_x2 1 2 426 430 429 427 ao22_x2
xsubckt_376_na4_x1 1 2 537 9 46 747 711 na4_x1
xsubckt_1262_na4_x1 1 2 1139 817 760 668 1140 na4_x1
xsubckt_509_na2_x1 1 2 404 421 409 na2_x1
xsubckt_460_na2_x1 1 2 453 565 537 na2_x1
xsubckt_321_ao22_x2 1 2 592 804 802 785 ao22_x2
xsubckt_117_na2_x1 1 2 794 887 804 na2_x1
xsubckt_116_na2_x1 1 2 795 814 797 na2_x1
xsubckt_167_on12_x1 1 2 745 1742 1743 on12_x1
xsubckt_300_nao22_x1 1 2 613 84 621 614 nao22_x1
xsubckt_844_ao22_x2 1 2 1528 1529 584 858 ao22_x2
xsubckt_853_na2_x1 1 2 1519 908 634 na2_x1
xsubckt_995_nao2o22_x1 1 2 1381 759 667 665 897 nao2o22_x1
xsubckt_1131_na3_x1 1 2 1261 54 1267 1262 na3_x1
xsubckt_1256_ao22_x2 1 2 1145 67 1284 1249 ao22_x2
xsubckt_1483_na3_x1 1 2 956 55 1267 996 na3_x1
xsubckt_462_na2_x1 1 2 451 1743 793 na2_x1
xsubckt_120_nao22_x1 1 2 791 42 803 796 nao22_x1
xsubckt_972_no4_x1 1 2 1403 621 614 398 1404 no4_x1
xsubckt_1092_na3_x1 1 2 1299 618 471 1414 na3_x1
xsubckt_1164_ao22_x2 1 2 1230 1384 1263 843 ao22_x2
xsubckt_1668_sff1r_x4 1 2 1708 11 1608 sff1r_x4
xsubckt_1368_an12_x1 1 2 1041 1045 1042 an12_x1
xsubckt_1357_na2_x1 1 2 1051 548 1053 na2_x1
xsubckt_1331_nao22_x1 1 2 1075 1111 1160 1710 nao22_x1
xsubckt_468_na2_x1 1 2 445 452 446 na2_x1
xsubckt_737_nao22_x1 1 2 179 59 753 750 nao22_x1
xsubckt_827_nao22_x1 1 2 1545 635 475 1548 nao22_x1
xsubckt_1094_na3_x1 1 2 1297 791 781 1301 na3_x1
xsubckt_1097_na3_x1 1 2 1294 9 46 683 na3_x1
xsubckt_1125_no4_x1 1 2 1267 1385 1353 1272 1270 no4_x1
xsubckt_1631_sff1_x4 1 2 57 1645 sff1_x4
xsubckt_1468_nao22_x1 1 2 969 998 1467 1475 nao22_x1
xsubckt_426_a4_x2 1 2 487 541 537 516 488 a4_x2
xsubckt_326_no2_x1 1 2 587 1747 1744 no2_x1
xsubckt_225_ao22_x2 1 2 687 727 734 741 ao22_x2
xsubckt_308_oa2ao222_x2 1 2 605 9 661 653 612 47 oa2ao222_x2
xsubckt_1666_sff1_x4 1 2 3 1610 sff1_x4
xsubckt_1627_sff1_x4 1 2 67 1649 sff1_x4
xsubckt_330_nao22_x1 1 2 583 41 745 891 nao22_x1
xsubckt_250_a3_x2 1 2 662 669 664 663 a3_x2
xsubckt_671_a4_x2 1 2 243 249 248 245 244 a4_x2
xsubckt_892_nxr2_x1 1 2 1480 353 1483 nxr2_x1
xsubckt_1151_nao22_x1 1 2 1242 1295 241 255 nao22_x1
xsubckt_340_on12_x1 1 2 573 1743 39 on12_x1
xsubckt_329_a3_x2 1 2 584 657 590 585 a3_x2
xsubckt_153_a2_x2 1 2 758 778 760 a2_x2
xsubckt_123_a2_x2 1 2 788 1741 790 a2_x2
xsubckt_712_oa2ao222_x2 1 2 204 428 346 324 658 790 oa2ao222_x2
xsubckt_945_a4_x2 1 2 1429 620 615 424 399 a4_x2
xsubckt_1198_nao22_x1 1 2 1199 63 1284 1249 nao22_x1
xsubckt_1574_sff1_x4 1 2 47 1702 sff1_x4
xsubckt_1345_noa22_x1 1 2 1062 1063 1352 77 noa22_x1
xsubckt_427_a2_x2 1 2 486 633 558 a2_x2
xsubckt_407_a2_x2 1 2 506 515 507 a2_x2
xsubckt_337_an12_x1 1 2 576 1742 1743 an12_x1
xsubckt_193_a2_x2 1 2 719 787 765 a2_x2
xsubckt_739_noa2ao222_x1 1 2 177 40 758 384 386 1737 noa2ao222_x1
xsubckt_767_nao22_x1 1 2 150 1751 630 624 nao22_x1
xsubckt_848_a3_x2 1 2 1524 1536 1526 1525 a3_x2
xsubckt_672_a2_x2 1 2 242 250 243 a2_x2
xsubckt_677_nao22_x1 1 2 237 67 753 750 nao22_x1
xsubckt_889_noa2ao222_x1 1 2 1483 434 1539 1504 1484 493 noa2ao222_x1
xsubckt_906_a2_x2 1 2 1466 1474 1468 a2_x2
xsubckt_1169_nxr2_x1 1 2 1225 66 1239 nxr2_x1
xsubckt_630_nxr2_x1 1 2 284 295 290 nxr2_x1
xsubckt_587_nao22_x1 1 2 327 332 521 841 nao22_x1
xsubckt_840_nao22_x1 1 2 1532 62 563 562 nao22_x1
xsubckt_930_nao22_x1 1 2 1443 56 753 750 nao22_x1
xsubckt_1144_a4_x2 1 2 1248 761 751 1294 1285 a4_x2
xsubckt_1154_a4_x2 1 2 1239 54 53 55 1254 a4_x2
xsubckt_1181_nao22_x1 1 2 1214 1268 1219 1216 nao22_x1
xsubckt_472_ao22_x2 1 2 441 480 444 442 ao22_x2
xsubckt_180_nao22_x1 1 2 732 744 742 784 nao22_x1
xsubckt_714_oa2a2a23_x2 1 2 202 593 425 348 347 331 329 oa2a2a23_x2
xsubckt_917_ao22_x2 1 2 1456 1489 1478 354 ao22_x2
xsubckt_1515_mx2_x2 1 2 1623 1729 181 945 mx2_x2
xsubckt_1514_mx2_x2 1 2 1624 1730 217 945 mx2_x2
xsubckt_1513_mx2_x2 1 2 1625 1731 239 945 mx2_x2
xsubckt_1512_mx2_x2 1 2 1626 1732 389 945 mx2_x2
xsubckt_1320_a2_x2 1 2 1085 1088 1086 a2_x2
xsubckt_1282_a3_x2 1 2 1120 1133 1128 1121 a3_x2
xsubckt_577_na4_x1 1 2 337 9 45 140 681 na4_x1
xsubckt_152_on12_x1 1 2 759 8 7 on12_x1
xsubckt_235_noa2ao222_x1 1 2 677 47 681 679 46 683 noa2ao222_x1
xsubckt_704_na2_x1 1 2 74 216 212 na2_x1
xsubckt_1005_nao2o22_x1 1 2 1372 901 777 759 667 nao2o22_x1
xsubckt_1087_a3_x2 1 2 1302 888 867 1305 a3_x2
xsubckt_1213_nao22_x1 1 2 1185 1268 1190 1187 nao22_x1
xsubckt_1519_mx2_x2 1 2 1619 1725 1420 945 mx2_x2
xsubckt_1518_mx2_x2 1 2 1620 1726 1445 945 mx2_x2
xsubckt_1517_mx2_x2 1 2 1621 1727 1465 945 mx2_x2
xsubckt_1516_mx2_x2 1 2 1622 1728 1587 945 mx2_x2
xsubckt_189_na4_x1 1 2 723 48 1741 787 746 na4_x1
xsubckt_273_ao2o22_x2 1 2 640 889 768 762 890 ao2o22_x2
xsubckt_315_na2_x1 1 2 598 604 601 na2_x1
xsubckt_318_na2_x1 1 2 595 9 721 na2_x1
xsubckt_264_ao2o22_x2 1 2 648 741 734 726 724 ao2o22_x2
xsubckt_664_na2_x1 1 2 250 253 251 na2_x1
xsubckt_1204_na2_x1 1 2 1685 1203 1194 na2_x1
xsubckt_1554_na2_x1 1 2 923 603 924 na2_x1
xsubckt_1388_an12_x1 1 2 1024 1028 1025 an12_x1
xsubckt_1338_nxr2_x1 1 2 1069 856 1254 nxr2_x1
xsubckt_668_na2_x1 1 2 246 892 793 na2_x1
xsubckt_1161_na2_x1 1 2 1689 1242 1233 na2_x1
xsubckt_1651_sff1_x4 1 2 1731 1625 sff1_x4
xsubckt_1612_sff1_x4 1 2 1746 1664 sff1_x4
xsubckt_639_noa2ao222_x1 1 2 275 369 365 363 372 378 noa2ao222_x1
xsubckt_512_nao22_x1 1 2 401 402 404 406 nao22_x1
xsubckt_80_inv_x1 1 2 830 138 inv_x1
xsubckt_266_no3_x1 1 2 646 690 649 647 no3_x1
xsubckt_690_nao22_x1 1 2 225 430 427 226 nao22_x1
xsubckt_974_noa2ao222_x1 1 2 1401 1402 1422 1435 594 1541 noa2ao222_x1
xsubckt_1211_nxr2_x1 1 2 1187 860 1198 nxr2_x1
xsubckt_1537_ao22_x2 1 2 937 1375 1287 580 ao22_x2
xsubckt_1372_oa2ao222_x2 1 2 1038 1228 1225 1269 1248 1271 oa2ao222_x2
xsubckt_364_a4_x2 1 2 549 9 47 747 711 a4_x2
xsubckt_139_no2_x1 1 2 772 1746 1745 no2_x1
xsubckt_138_no2_x1 1 2 773 1747 1748 no2_x1
xsubckt_86_inv_x1 1 2 824 78 inv_x1
xsubckt_85_inv_x1 1 2 825 137 inv_x1
xsubckt_84_inv_x1 1 2 826 1726 inv_x1
xsubckt_83_inv_x1 1 2 827 1718 inv_x1
xsubckt_82_inv_x1 1 2 828 1750 inv_x1
xsubckt_81_inv_x1 1 2 829 79 inv_x1
xsubckt_812_nao22_x1 1 2 1560 1749 630 624 nao22_x1
xsubckt_1014_ao22_x2 1 2 1365 1366 1368 475 ao22_x2
xsubckt_1608_sff1_x4 1 2 143 1668 sff1_x4
xsubckt_482_a3_x2 1 2 431 551 502 464 a3_x2
xsubckt_89_inv_x1 1 2 821 1725 inv_x1
xsubckt_88_inv_x1 1 2 822 1717 inv_x1
xsubckt_87_inv_x1 1 2 823 1749 inv_x1
xsubckt_834_nxr2_x1 1 2 1538 1546 1540 nxr2_x1
xsubckt_949_nao22_x1 1 2 1425 1426 445 453 nao22_x1
xsubckt_1594_sff1_x4 1 2 149 1682 sff1_x4
xsubckt_1363_nao22_x1 1 2 1046 1058 241 255 nao22_x1
xsubckt_345_a2_x2 1 2 568 9 678 a2_x2
xsubckt_766_a3_x2 1 2 151 423 188 170 a3_x2
xsubckt_590_a2_x2 1 2 324 331 329 a2_x2
xsubckt_570_a2_x2 1 2 344 461 345 a2_x2
xsubckt_395_a2_x2 1 2 518 604 546 a2_x2
xsubckt_769_nao22_x1 1 2 1602 907 605 599 nao22_x1
xsubckt_1042_a4_x2 1 2 1337 218 206 184 1338 a4_x2
xsubckt_1189_nxr2_x1 1 2 1207 866 1217 nxr2_x1
xsubckt_1273_nao22_x1 1 2 1129 60 1284 1249 nao22_x1
xsubckt_1314_ao22_x2 1 2 1091 57 1284 1249 ao22_x2
xsubckt_519_noa2ao222_x1 1 2 394 396 501 550 443 395 noa2ao222_x1
xsubckt_506_ao22_x2 1 2 407 411 521 849 ao22_x2
xsubckt_265_o3_x2 1 2 647 686 660 648 o3_x2
xsubckt_1034_an12_x1 1 2 1345 1346 1353 an12_x1
xsubckt_173_an12_x1 1 2 739 1742 1744 an12_x1
xsubckt_685_nxr2_x1 1 2 230 269 233 nxr2_x1
xsubckt_817_na4_x1 1 2 1555 9 45 136 681 na4_x1
xsubckt_1140_a3_x2 1 2 1252 54 55 1254 a3_x2
xsubckt_1160_a3_x2 1 2 1233 1241 1240 1234 a3_x2
xsubckt_1307_a2_x2 1 2 1097 1100 1098 a2_x2
xsubckt_1305_nao22_x1 1 2 1099 1111 1160 1712 nao22_x1
xsubckt_572_nao22_x1 1 2 342 1753 630 624 nao22_x1
xsubckt_510_na2_x1 1 2 403 410 408 na2_x1
xsubckt_429_na4_x1 1 2 484 1743 42 814 797 na4_x1
xsubckt_414_ao22_x2 1 2 499 9 687 685 ao22_x2
xsubckt_382_na4_x1 1 2 531 895 809 800 587 na4_x1
xsubckt_380_na4_x1 1 2 533 895 809 800 576 na4_x1
xsubckt_772_na4_x1 1 2 1599 9 45 138 681 na4_x1
xsubckt_1043_a2_x2 1 2 1336 1588 1337 a2_x2
xsubckt_1542_a2_x2 1 2 933 935 934 a2_x2
xsubckt_1532_na3_x1 1 2 941 50 1391 1389 na3_x1
xsubckt_1522_a2_x2 1 2 942 944 943 a2_x2
xsubckt_1401_na2_x1 1 2 1013 1015 1014 na2_x1
xsubckt_1324_o4_x2 1 2 1082 825 1165 1161 1158 o4_x2
xsubckt_490_noa2ao222_x1 1 2 423 595 718 745 735 740 noa2ao222_x1
xsubckt_155_noa2ao222_x1 1 2 756 778 776 760 767 45 noa2ao222_x1
xsubckt_679_noa2ao222_x1 1 2 235 37 758 384 386 1739 noa2ao222_x1
xsubckt_907_na2_x1 1 2 1465 1474 1468 na2_x1
xsubckt_1143_na3_x1 1 2 1249 761 749 1294 na3_x1
xsubckt_1218_ao22_x2 1 2 1181 1384 1263 819 ao22_x2
xsubckt_1408_na2_x1 1 2 1007 1009 1008 na2_x1
xsubckt_1403_na2_x1 1 2 1668 1017 1012 na2_x1
xsubckt_806_ao22_x2 1 2 1566 1570 160 167 ao22_x2
xsubckt_1362_na2_x1 1 2 1674 1057 1047 na2_x1
xsubckt_1323_oa2ao222_x2 1 2 1083 1447 1453 1454 1169 1174 oa2ao222_x2
xsubckt_1319_noa22_x1 1 2 1086 1087 1352 79 noa22_x1
xsubckt_1165_ao22_x2 1 2 1229 66 1284 1249 ao22_x2
xsubckt_1237_o3_x2 1 2 1163 1353 1272 1247 o3_x2
xsubckt_1632_sff1_x4 1 2 56 1644 sff1_x4
xsubckt_1369_na2_x1 1 2 1673 1046 1041 na2_x1
xsubckt_1367_na2_x1 1 2 1042 1044 1043 na2_x1
xsubckt_1006_no3_x1 1 2 1371 758 1378 1372 no3_x1
xsubckt_1008_no3_x1 1 2 1370 758 1381 1378 no3_x1
xsubckt_1270_nxr2_x1 1 2 1132 873 1259 nxr2_x1
xsubckt_467_no3_x1 1 2 446 536 450 447 no3_x1
xsubckt_292_a4_x2 1 2 621 9 894 711 691 a4_x2
xsubckt_310_a3_x2 1 2 603 895 809 800 a3_x2
xsubckt_814_nao22_x1 1 2 1558 909 605 599 nao22_x1
xsubckt_1628_sff1_x4 1 2 60 1648 sff1_x4
xsubckt_1359_no3_x1 1 2 1049 1329 1055 1050 no3_x1
xsubckt_341_on12_x1 1 2 572 39 1743 on12_x1
xsubckt_1575_sff1_x4 1 2 46 1701 sff1_x4
xsubckt_1455_nao22_x1 1 2 980 998 183 207 nao22_x1
xsubckt_654_a3_x2 1 2 260 353 265 262 a3_x2
xsubckt_1373_noa2ao222_x1 1 2 1037 82 1329 1055 760 668 noa2ao222_x1
xsubckt_270_o4_x2 1 2 10 704 703 644 643 o4_x2
xsubckt_968_a3_x2 1 2 1407 1411 1410 1408 a3_x2
xsubckt_1275_nao22_x1 1 2 1127 1754 1329 1264 nao22_x1
xsubckt_1332_noa22_x1 1 2 1074 1075 1352 78 noa22_x1
xsubckt_230_na4_x1 1 2 682 809 773 769 765 na4_x1
xsubckt_1007_nao22_x1 1 2 1705 1371 1373 900 nao22_x1
xsubckt_1019_a4_x2 1 2 1360 9 1743 46 681 a4_x2
xsubckt_1039_a4_x2 1 2 1340 593 494 478 1403 a4_x2
xsubckt_1049_a4_x2 1 2 1330 9 45 747 711 a4_x2
xsubckt_631_nxr2_x1 1 2 283 296 290 nxr2_x1
xsubckt_430_noa2a2a23_x1 1 2 483 46 679 581 532 671 44 noa2a2a23_x1
xsubckt_101_na3_x1 1 2 810 891 814 812 na3_x1
xsubckt_996_ao22_x2 1 2 1380 774 1392 1388 ao22_x2
xsubckt_1137_a3_x2 1 2 1255 58 57 1257 a3_x2
xsubckt_1393_noa2ao222_x1 1 2 1020 79 1329 1055 760 668 noa2ao222_x1
xsubckt_192_na4_x1 1 2 720 48 773 770 722 na4_x1
xsubckt_237_na4_x1 1 2 675 1742 771 765 764 na4_x1
xsubckt_856_oa2a2a23_x2 1 2 1516 908 634 489 1750 467 78 oa2a2a23_x2
xsubckt_1528_mx2_x2 1 2 1613 1719 1465 942 mx2_x2
xsubckt_1527_mx2_x2 1 2 1614 1720 1587 942 mx2_x2
xsubckt_1526_mx2_x2 1 2 1615 1721 181 942 mx2_x2
xsubckt_1525_mx2_x2 1 2 1616 1722 217 942 mx2_x2
xsubckt_1524_mx2_x2 1 2 1617 1723 239 942 mx2_x2
xsubckt_1523_mx2_x2 1 2 1618 1724 389 942 mx2_x2
xsubckt_574_nao22_x1 1 2 340 905 605 599 nao22_x1
xsubckt_456_na3_x1 1 2 457 635 472 459 na3_x1
xsubckt_322_na2_x1 1 2 591 894 601 na2_x1
xsubckt_849_na3_x1 1 2 1523 1536 1526 1525 na3_x1
xsubckt_865_ao22_x2 1 2 1507 1511 1509 1566 ao22_x2
xsubckt_979_na4_x1 1 2 1396 1413 1412 1407 1398 na4_x1
xsubckt_1242_o4_x2 1 2 1158 1331 1330 1264 1159 o4_x2
xsubckt_1265_a2_x2 1 2 1136 1142 1137 a2_x2
xsubckt_1539_a2_x2 1 2 1608 939 936 a2_x2
xsubckt_1529_mx2_x2 1 2 1612 1718 1445 942 mx2_x2
xsubckt_1295_a2_x2 1 2 1108 1112 1109 a2_x2
xsubckt_327_na2_x1 1 2 586 601 587 na2_x1
xsubckt_199_na4_x1 1 2 713 887 886 811 804 na4_x1
xsubckt_673_na2_x1 1 2 241 250 243 na2_x1
xsubckt_826_ao22_x2 1 2 1546 635 475 1548 ao22_x2
xsubckt_1084_na4_x1 1 2 1304 9 817 776 668 na4_x1
xsubckt_1215_na2_x1 1 2 1684 1193 1184 na2_x1
xsubckt_283_na2_x1 1 2 630 633 632 na2_x1
xsubckt_284_na2_x1 1 2 629 44 671 na2_x1
xsubckt_646_nao2o22_x1 1 2 268 435 271 270 494 nao2o22_x1
xsubckt_675_na2_x1 1 2 239 254 242 na2_x1
xsubckt_1146_ao22_x2 1 2 1246 54 1284 1249 ao22_x2
xsubckt_1172_na2_x1 1 2 1688 1232 1223 na2_x1
xsubckt_1185_ao22_x2 1 2 1211 1384 1263 834 ao22_x2
xsubckt_1652_sff1_x4 1 2 1730 1624 sff1_x4
xsubckt_1339_nxr2_x1 1 2 1068 55 1254 nxr2_x1
xsubckt_141_no2_x1 1 2 770 1742 1741 no2_x1
xsubckt_271_no3_x1 1 2 642 897 890 768 no3_x1
xsubckt_1613_sff1_x4 1 2 1745 1663 sff1_x4
xsubckt_1538_ao22_x2 1 2 936 937 938 1397 ao22_x2
xsubckt_1286_nxr2_x1 1 2 1117 870 1258 nxr2_x1
xsubckt_434_a4_x2 1 2 479 632 628 627 481 a4_x2
xsubckt_147_no2_x1 1 2 764 1744 1743 no2_x1
xsubckt_93_inv_x1 1 2 817 49 inv_x1
xsubckt_92_inv_x1 1 2 818 13 inv_x1
xsubckt_91_inv_x1 1 2 819 77 inv_x1
xsubckt_90_inv_x1 1 2 820 136 inv_x1
xsubckt_207_ao22_x2 1 2 705 711 708 706 ao22_x2
xsubckt_229_a4_x2 1 2 683 809 773 769 765 a4_x2
xsubckt_278_no3_x1 1 2 635 642 639 636 no3_x1
xsubckt_1054_ao22_x2 1 2 1325 1326 1364 491 ao22_x2
xsubckt_1212_nxr2_x1 1 2 1186 62 1198 nxr2_x1
xsubckt_1609_sff1_x4 1 2 142 1667 sff1_x4
xsubckt_532_a3_x2 1 2 381 387 385 382 a3_x2
xsubckt_131_a2_x2 1 2 780 791 781 a2_x2
xsubckt_111_a2_x2 1 2 800 48 1741 a2_x2
xsubckt_96_inv_x1 1 2 4 815 inv_x1
xsubckt_94_inv_x1 1 2 816 5 inv_x1
xsubckt_642_ao22_x2 1 2 272 276 273 494 ao22_x2
xsubckt_649_oa2ao222_x2 1 2 265 320 318 274 495 500 oa2ao222_x2
xsubckt_816_nao22_x1 1 2 1556 61 563 562 nao22_x1
xsubckt_835_nxr2_x1 1 2 1537 1545 1540 nxr2_x1
xsubckt_1595_sff1_x4 1 2 148 1681 sff1_x4
xsubckt_1457_nao22_x1 1 2 978 1753 1290 1265 nao22_x1
xsubckt_161_a2_x2 1 2 750 44 767 a2_x2
xsubckt_171_a2_x2 1 2 741 744 742 a2_x2
xsubckt_513_noa2a22_x1 1 2 400 894 601 528 1747 noa2a22_x1
xsubckt_485_a2_x2 1 2 428 658 576 a2_x2
xsubckt_729_a2_x2 1 2 187 402 188 a2_x2
xsubckt_1155_nxr2_x1 1 2 1238 876 1252 nxr2_x1
xsubckt_1277_nao22_x1 1 2 1125 888 868 50 nao22_x1
xsubckt_585_ao22_x2 1 2 329 330 521 841 ao22_x2
xsubckt_546_ao22_x2 1 2 368 455 441 458 ao22_x2
xsubckt_936_nao22_x1 1 2 1438 1457 1456 1476 nao22_x1
xsubckt_981_ao22_x2 1 2 1394 1395 1396 885 ao22_x2
xsubckt_984_a2_x2 1 2 1392 888 1393 a2_x2
xsubckt_1009_nao22_x1 1 2 1704 1370 1373 899 nao22_x1
xsubckt_1187_nao22_x1 1 2 1209 64 1284 1249 nao22_x1
xsubckt_276_nao22_x1 1 2 637 778 7 8 nao22_x1
xsubckt_301_na3_x1 1 2 612 682 675 670 na3_x1
xsubckt_799_a2_x2 1 2 1573 461 1574 a2_x2
xsubckt_1210_a3_x2 1 2 1188 63 62 1208 a3_x2
xsubckt_1230_a3_x2 1 2 1170 637 606 486 a3_x2
xsubckt_1250_a3_x2 1 2 1150 1157 1155 1151 a3_x2
xsubckt_1547_noa2ao222_x1 1 2 928 84 673 1400 932 1743 noa2ao222_x1
xsubckt_1309_nao22_x1 1 2 1678 1096 1166 1588 nao22_x1
xsubckt_539_noa2a2a23_x1 1 2 375 903 634 489 1755 467 83 noa2a2a23_x1
xsubckt_135_an12_x1 1 2 776 8 7 an12_x1
xsubckt_98_a2_x2 1 2 813 891 814 a2_x2
xsubckt_304_na3_x1 1 2 609 9 45 676 na3_x1
xsubckt_666_nao22_x1 1 2 248 402 302 300 nao22_x1
xsubckt_686_nxr2_x1 1 2 229 256 230 nxr2_x1
xsubckt_1133_a2_x2 1 2 1259 68 67 a2_x2
xsubckt_1260_a3_x2 1 2 1141 817 760 668 a3_x2
xsubckt_1540_na3_x1 1 2 935 9 658 581 na3_x1
xsubckt_1407_noa2ao222_x1 1 2 1008 77 1329 1055 760 668 noa2ao222_x1
xsubckt_576_nao22_x1 1 2 338 65 563 562 nao22_x1
xsubckt_397_na4_x1 1 2 516 9 45 711 698 na4_x1
xsubckt_396_na4_x1 1 2 517 9 711 691 518 na4_x1
xsubckt_134_on12_x1 1 2 777 6 16 on12_x1
xsubckt_132_na2_x1 1 2 779 791 781 na2_x1
xsubckt_787_na4_x1 1 2 1584 1742 46 1736 763 na4_x1
xsubckt_823_ao2o22_x2 1 2 1549 821 521 504 822 ao2o22_x2
xsubckt_914_na2_x1 1 2 71 1464 1459 na2_x1
xsubckt_1170_nao22_x1 1 2 1224 1268 1229 1226 nao22_x1
xsubckt_1670_sff1r_x4 1 2 37 11 1606 sff1r_x4
xsubckt_1580_sff1r_x4 1 2 16 11 1696 sff1r_x4
xsubckt_1546_na3_x1 1 2 929 935 934 930 na3_x1
xsubckt_1470_nao22_x1 1 2 967 1751 1290 1265 nao22_x1
xsubckt_1410_na2_x1 1 2 1667 1011 1006 na2_x1
xsubckt_1365_oa2ao222_x2 1 2 1044 1235 1237 1269 1271 1248 oa2ao222_x2
xsubckt_137_na2_x1 1 2 774 778 776 na2_x1
xsubckt_269_na3_x1 1 2 643 695 646 645 na3_x1
xsubckt_658_na3_x1 1 2 256 357 350 259 na3_x1
xsubckt_876_nao22_x1 1 2 1496 1537 1502 1499 nao22_x1
xsubckt_966_nao22_x1 1 2 1409 528 511 589 nao22_x1
xsubckt_1152_na3_x1 1 2 1241 53 1267 1262 na3_x1
xsubckt_1219_ao22_x2 1 2 1180 61 1284 1249 ao22_x2
xsubckt_1239_o4_x2 1 2 1161 1353 1352 1272 1247 o4_x2
xsubckt_1269_o4_x2 1 2 1133 844 1165 1161 1158 o4_x2
xsubckt_486_na2_x1 1 2 427 658 576 na2_x1
xsubckt_483_na2_x1 1 2 430 790 658 na2_x1
xsubckt_786_nao22_x1 1 2 1585 64 775 766 nao22_x1
xsubckt_793_ao22_x2 1 2 1579 635 475 1592 ao22_x2
xsubckt_878_na2_x1 1 2 1494 1497 1495 na2_x1
xsubckt_904_no3_x1 1 2 1468 1471 1470 1469 no3_x1
xsubckt_1202_nao22_x1 1 2 1195 1268 1200 1197 nao22_x1
xsubckt_1376_na2_x1 1 2 1672 1040 1035 na2_x1
xsubckt_1374_na2_x1 1 2 1036 1038 1037 na2_x1
xsubckt_488_na2_x1 1 2 425 746 658 na2_x1
xsubckt_312_a4_x2 1 2 601 895 809 800 746 a4_x2
xsubckt_319_ao22_x2 1 2 594 596 734 741 ao22_x2
xsubckt_883_ao2o22_x2 1 2 1489 1492 1491 1490 494 ao2o22_x2
xsubckt_1271_nxr2_x1 1 2 1131 60 1259 nxr2_x1
xsubckt_1633_sff1_x4 1 2 55 1643 sff1_x4
xsubckt_201_nao22_x1 1 2 711 712 715 733 nao22_x1
xsubckt_227_ao22_x2 1 2 685 726 734 741 ao22_x2
xsubckt_908_nao22_x1 1 2 1464 779 1475 1467 nao22_x1
xsubckt_958_noa2ao222_x1 1 2 1416 39 758 384 386 1733 noa2ao222_x1
xsubckt_1159_nao22_x1 1 2 1234 1268 1238 1236 nao22_x1
xsubckt_1629_sff1_x4 1 2 59 1647 sff1_x4
xsubckt_1549_nao22_x1 1 2 1607 927 933 1365 nao22_x1
xsubckt_1306_noa22_x1 1 2 1098 1099 1352 80 noa22_x1
xsubckt_662_ao22_x2 1 2 252 374 404 406 ao22_x2
xsubckt_1569_sff1r_x4 1 2 39 11 1707 sff1r_x4
xsubckt_1459_nao22_x1 1 2 976 1268 1117 1115 nao22_x1
xsubckt_529_a3_x2 1 2 384 892 46 763 a3_x2
xsubckt_480_a3_x2 1 2 433 438 436 434 a3_x2
xsubckt_323_a2_x2 1 2 590 592 591 a2_x2
xsubckt_158_a2_x2 1 2 753 778 754 a2_x2
xsubckt_847_ao2o22_x2 1 2 1525 826 521 504 827 ao2o22_x2
xsubckt_1576_sff1_x4 1 2 45 1700 sff1_x4
xsubckt_1543_an12_x1 1 2 932 892 1287 an12_x1
xsubckt_607_a2_x2 1 2 307 316 308 a2_x2
xsubckt_393_a2_x2 1 2 520 542 539 a2_x2
xsubckt_168_a2_x2 1 2 744 1741 746 a2_x2
xsubckt_751_oa2ao222_x2 1 2 166 635 477 189 173 172 oa2ao222_x2
xsubckt_774_an12_x1 1 2 1597 1598 1601 an12_x1
xsubckt_798_oa2a2a23_x2 1 2 1574 907 634 489 1751 467 79 oa2a2a23_x2
xsubckt_832_a2_x2 1 2 1540 461 1541 a2_x2
xsubckt_842_a2_x2 1 2 1530 1532 1531 a2_x2
xsubckt_1020_an12_x1 1 2 1359 46 768 an12_x1
xsubckt_1279_nao22_x1 1 2 1123 1124 1160 1714 nao22_x1
xfeed_109 1 2 tie_x0
xfeed_108 1 2 tie_x0
xfeed_107 1 2 rowend_x0
xfeed_106 1 2 tie_x0
xfeed_105 1 2 tie_x0
xfeed_104 1 2 tie_x0
xfeed_103 1 2 tie_x0
xfeed_102 1 2 tie_x0
xfeed_101 1 2 tie_x0
xfeed_100 1 2 tie_x0
xsubckt_1642_sff1r_x4 1 2 1716 11 1634 sff1r_x4
xsubckt_1442_nao22_x1 1 2 991 998 241 255 nao22_x1
xsubckt_458_nao22_x1 1 2 455 460 473 634 nao22_x1
xsubckt_338_on12_x1 1 2 575 1743 1742 on12_x1
xsubckt_667_a2_x2 1 2 247 892 793 a2_x2
xsubckt_697_a2_x2 1 2 218 228 220 a2_x2
xsubckt_829_ao2o22_x2 1 2 1543 823 490 468 819 ao2o22_x2
xsubckt_449_noa2a2a23_x1 1 2 464 902 634 489 1756 467 84 noa2a2a23_x1
xsubckt_242_na4_x1 1 2 670 1742 771 769 765 na4_x1
xsubckt_758_nao22_x1 1 2 159 165 161 233 nao22_x1
xfeed_119 1 2 tie_x0
xfeed_118 1 2 tie_x0
xfeed_117 1 2 tie_x0
xfeed_116 1 2 rowend_x0
xfeed_115 1 2 tie_x0
xfeed_114 1 2 tie_x0
xfeed_113 1 2 rowend_x0
xfeed_112 1 2 tie_x0
xfeed_111 1 2 tie_x0
xfeed_110 1 2 tie_x0
xsubckt_1316_oa2ao222_x2 1 2 1089 1090 1092 1269 1271 1248 oa2ao222_x2
xsubckt_441_nao22_x1 1 2 472 474 501 550 nao22_x1
xsubckt_113_na3_x1 1 2 798 48 1742 1741 na3_x1
xsubckt_247_na4_x1 1 2 665 8 7 6 16 na4_x1
xsubckt_647_oa2ao222_x2 1 2 267 276 273 494 269 358 oa2ao222_x2
xsubckt_1531_mx2_x2 1 2 1610 3 1364 695 mx2_x2
xsubckt_1530_mx2_x2 1 2 1611 1717 1420 942 mx2_x2
xsubckt_724_na2_x1 1 2 192 199 193 na2_x1
xsubckt_1001_na3_x1 1 2 1375 9 776 668 na3_x1
xsubckt_1082_nao22_x1 1 2 1695 816 1376 817 nao22_x1
xfeed_129 1 2 tie_x0
xfeed_128 1 2 rowend_x0
xfeed_127 1 2 tie_x0
xfeed_126 1 2 tie_x0
xfeed_125 1 2 tie_x0
xfeed_124 1 2 tie_x0
xfeed_123 1 2 tie_x0
xfeed_122 1 2 tie_x0
xfeed_121 1 2 tie_x0
xfeed_120 1 2 tie_x0
xsubckt_1672_sff1r_x4 1 2 38 11 1604 sff1r_x4
xsubckt_1582_sff1r_x4 1 2 52 11 1694 sff1r_x4
xsubckt_1492_mx2_x2 1 2 1642 1740 389 949 mx2_x2
xsubckt_1472_nao22_x1 1 2 965 1268 1093 1091 nao22_x1
xsubckt_1353_na3_x1 1 2 1055 541 516 1263 na3_x1
xsubckt_336_na2_x1 1 2 577 580 579 na2_x1
xsubckt_333_na2_x1 1 2 580 1743 1742 na2_x1
xsubckt_726_ao2o22_x2 1 2 190 836 521 504 837 ao2o22_x2
xsubckt_858_noa2ao222_x1 1 2 1514 635 477 1524 1519 1518 noa2ao222_x1
xsubckt_1498_mx2_x2 1 2 1636 1734 1445 949 mx2_x2
xsubckt_1497_mx2_x2 1 2 1637 1735 1465 949 mx2_x2
xsubckt_1496_mx2_x2 1 2 1638 1736 1587 949 mx2_x2
xsubckt_1495_mx2_x2 1 2 1639 1737 181 949 mx2_x2
xsubckt_1494_mx2_x2 1 2 1640 1738 217 949 mx2_x2
xsubckt_1493_mx2_x2 1 2 1641 1739 239 949 mx2_x2
xsubckt_339_na2_x1 1 2 574 578 575 na2_x1
xsubckt_274_nao2o22_x1 1 2 639 889 768 762 890 nao2o22_x1
xsubckt_294_na2_x1 1 2 619 9 655 na2_x1
xsubckt_681_na2_x1 1 2 75 238 234 na2_x1
xsubckt_1099_na4_x1 1 2 1292 9 893 46 681 na4_x1
xsubckt_1225_na2_x1 1 2 1683 1183 1175 na2_x1
xsubckt_1235_o3_x2 1 2 1165 1173 1168 1167 o3_x2
xfeed_139 1 2 tie_x0
xfeed_138 1 2 tie_x0
xfeed_137 1 2 tie_x0
xfeed_136 1 2 tie_x0
xfeed_135 1 2 rowend_x0
xfeed_134 1 2 tie_x0
xfeed_133 1 2 tie_x0
xfeed_132 1 2 tie_x0
xfeed_131 1 2 tie_x0
xfeed_130 1 2 rowend_x0
xsubckt_1499_mx2_x2 1 2 1635 1733 1420 949 mx2_x2
xsubckt_299_na2_x1 1 2 614 618 616 na2_x1
xsubckt_1183_na2_x1 1 2 1687 1222 1213 na2_x1
xsubckt_1186_ao22_x2 1 2 1210 64 1284 1249 ao22_x2
xsubckt_1229_na2_x1 1 2 1171 632 622 na2_x1
xsubckt_1653_sff1_x4 1 2 1729 1623 sff1_x4
xsubckt_1614_sff1_x4 1 2 1744 1662 sff1_x4
xsubckt_514_a4_x2 1 2 399 781 598 509 400 a4_x2
xsubckt_801_nxr2_x1 1 2 1571 1578 1573 nxr2_x1
xfeed_149 1 2 tie_x0
xfeed_148 1 2 tie_x0
xfeed_147 1 2 tie_x0
xfeed_146 1 2 tie_x0
xfeed_145 1 2 tie_x0
xfeed_144 1 2 tie_x0
xfeed_143 1 2 tie_x0
xfeed_142 1 2 tie_x0
xfeed_141 1 2 tie_x0
xfeed_140 1 2 tie_x0
xsubckt_1490_ao22_x2 1 2 950 951 657 897 ao22_x2
xsubckt_1287_nxr2_x1 1 2 1116 59 1258 nxr2_x1
xsubckt_379_a4_x2 1 2 534 895 809 800 576 a4_x2
xsubckt_324_an12_x1 1 2 589 1747 1744 an12_x1
xsubckt_771_nao22_x1 1 2 1600 63 563 562 nao22_x1
xsubckt_947_oa2ao222_x2 1 2 1427 430 1431 1428 1548 1542 oa2ao222_x2
xsubckt_413_nao22_x1 1 2 500 9 687 685 nao22_x1
xsubckt_221_a2_x2 1 2 691 812 692 a2_x2
xsubckt_251_a2_x2 1 2 661 45 676 a2_x2
xfeed_159 1 2 tie_x0
xfeed_158 1 2 tie_x0
xfeed_157 1 2 tie_x0
xfeed_156 1 2 tie_x0
xfeed_155 1 2 tie_x0
xfeed_154 1 2 tie_x0
xfeed_153 1 2 tie_x0
xfeed_152 1 2 tie_x0
xfeed_151 1 2 tie_x0
xfeed_150 1 2 tie_x0
xsubckt_1596_sff1_x4 1 2 141 1680 sff1_x4
xsubckt_551_ao22_x2 1 2 363 440 456 458 ao22_x2
xsubckt_535_a2_x2 1 2 379 635 380 a2_x2
xsubckt_682_a3_x2 1 2 233 353 350 259 a3_x2
xsubckt_946_a3_x2 1 2 1428 1547 1541 1429 a3_x2
xsubckt_1156_nxr2_x1 1 2 1237 53 1252 nxr2_x1
xsubckt_1644_sff1r_x4 1 2 1714 11 1632 sff1r_x4
xsubckt_586_ao22_x2 1 2 328 332 521 841 ao22_x2
xsubckt_1027_a4_x2 1 2 1352 9 47 711 698 a4_x2
xfeed_209 1 2 tie_x0
xfeed_208 1 2 tie_x0
xfeed_207 1 2 tie_x0
xfeed_206 1 2 tie_x0
xfeed_205 1 2 tie_x0
xfeed_204 1 2 rowend_x0
xfeed_203 1 2 tie_x0
xfeed_202 1 2 tie_x0
xfeed_201 1 2 tie_x0
xfeed_200 1 2 tie_x0
xfeed_169 1 2 tie_x0
xfeed_168 1 2 tie_x0
xfeed_167 1 2 tie_x0
xfeed_166 1 2 rowend_x0
xfeed_165 1 2 tie_x0
xfeed_164 1 2 tie_x0
xfeed_163 1 2 tie_x0
xfeed_162 1 2 tie_x0
xfeed_161 1 2 tie_x0
xfeed_160 1 2 tie_x0
xsubckt_1354_nao22_x1 1 2 1054 84 1329 1055 nao22_x1
xsubckt_465_o3_x2 1 2 448 738 730 449 o3_x2
xsubckt_803_noa2ao222_x1 1 2 1569 164 161 233 174 168 noa2ao222_x1
xsubckt_943_ao22_x2 1 2 1431 427 1548 1432 ao22_x2
xsubckt_1248_noa22_x1 1 2 1152 1153 1352 84 noa22_x1
xsubckt_1419_a3_x2 1 2 1005 680 558 1383 a3_x2
xsubckt_446_na4_x1 1 2 467 548 544 517 469 na4_x1
xsubckt_311_na3_x1 1 2 602 895 809 800 na3_x1
xsubckt_707_na3_x1 1 2 209 476 354 259 na3_x1
xfeed_219 1 2 tie_x0
xfeed_218 1 2 tie_x0
xfeed_217 1 2 tie_x0
xfeed_216 1 2 tie_x0
xfeed_215 1 2 rowend_x0
xfeed_214 1 2 tie_x0
xfeed_213 1 2 tie_x0
xfeed_212 1 2 rowend_x0
xfeed_211 1 2 tie_x0
xfeed_210 1 2 tie_x0
xfeed_179 1 2 tie_x0
xfeed_178 1 2 tie_x0
xfeed_177 1 2 tie_x0
xfeed_176 1 2 tie_x0
xfeed_175 1 2 tie_x0
xfeed_174 1 2 tie_x0
xfeed_173 1 2 tie_x0
xfeed_172 1 2 tie_x0
xfeed_171 1 2 tie_x0
xfeed_170 1 2 tie_x0
xsubckt_353_nao22_x1 1 2 560 54 563 562 nao22_x1
xsubckt_661_na3_x1 1 2 253 407 405 375 na3_x1
xsubckt_687_nxr2_x1 1 2 228 257 230 nxr2_x1
xsubckt_851_ao22_x2 1 2 1521 635 475 1524 ao22_x2
xsubckt_1206_na3_x1 1 2 1192 62 1267 1262 na3_x1
xsubckt_1584_sff1r_x4 1 2 50 11 1692 sff1r_x4
xsubckt_595_nxr2_x1 1 2 319 343 321 nxr2_x1
xsubckt_537_na2_x1 1 2 377 903 634 na2_x1
xsubckt_536_na2_x1 1 2 378 635 380 na2_x1
xsubckt_533_na2_x1 1 2 76 388 381 na2_x1
xsubckt_743_nao22_x1 1 2 174 635 475 189 nao22_x1
xsubckt_1098_a2_x2 1 2 1293 761 1294 a2_x2
xsubckt_1163_na3_x1 1 2 1231 66 1267 1262 na3_x1
xfeed_229 1 2 tie_x0
xfeed_228 1 2 tie_x0
xfeed_227 1 2 tie_x0
xfeed_226 1 2 tie_x0
xfeed_225 1 2 rowend_x0
xfeed_224 1 2 rowend_x0
xfeed_223 1 2 tie_x0
xfeed_222 1 2 tie_x0
xfeed_221 1 2 tie_x0
xfeed_220 1 2 tie_x0
xfeed_189 1 2 tie_x0
xfeed_188 1 2 tie_x0
xfeed_187 1 2 tie_x0
xfeed_186 1 2 tie_x0
xfeed_185 1 2 tie_x0
xfeed_184 1 2 tie_x0
xfeed_183 1 2 tie_x0
xfeed_182 1 2 tie_x0
xfeed_181 1 2 tie_x0
xfeed_180 1 2 tie_x0
xsubckt_1558_na3_x1 1 2 1605 922 921 920 na3_x1
xsubckt_1557_na3_x1 1 2 920 1743 603 924 na3_x1
xsubckt_1375_an12_x1 1 2 1035 1039 1036 an12_x1
xsubckt_1325_nxr2_x1 1 2 1081 859 1255 nxr2_x1
xsubckt_523_no3_x1 1 2 390 433 432 392 no3_x1
xsubckt_262_no4_x1 1 2 650 674 653 652 651 no4_x1
xsubckt_1032_na2_x1 1 2 1347 611 1348 na2_x1
xsubckt_1132_ao22_x2 1 2 1260 1384 1263 851 ao22_x2
xsubckt_1563_ao22_x2 1 2 915 499 1548 1542 ao22_x2
xsubckt_1383_na2_x1 1 2 1671 1034 1029 na2_x1
xsubckt_1381_na2_x1 1 2 1030 1032 1031 na2_x1
xsubckt_473_nao22_x1 1 2 440 480 444 442 nao22_x1
xsubckt_359_ao22_x2 1 2 554 555 584 877 ao22_x2
xsubckt_888_na2_x1 1 2 1484 1496 1485 na2_x1
xsubckt_1038_na2_x1 1 2 1341 9 4 na2_x1
xsubckt_1116_nao22_x1 1 2 1276 1295 391 432 nao22_x1
xfeed_239 1 2 rowend_x0
xfeed_238 1 2 tie_x0
xfeed_237 1 2 tie_x0
xfeed_236 1 2 tie_x0
xfeed_235 1 2 tie_x0
xfeed_234 1 2 tie_x0
xfeed_233 1 2 tie_x0
xfeed_232 1 2 tie_x0
xfeed_231 1 2 tie_x0
xfeed_230 1 2 tie_x0
xfeed_199 1 2 tie_x0
xfeed_198 1 2 tie_x0
xfeed_197 1 2 tie_x0
xfeed_196 1 2 tie_x0
xfeed_195 1 2 tie_x0
xfeed_194 1 2 tie_x0
xfeed_193 1 2 tie_x0
xfeed_192 1 2 rowend_x0
xfeed_191 1 2 tie_x0
xfeed_190 1 2 tie_x0
xsubckt_1634_sff1_x4 1 2 1740 1642 sff1_x4
xsubckt_1387_na2_x1 1 2 1025 1027 1026 na2_x1
xsubckt_432_a4_x2 1 2 481 606 486 484 482 a4_x2
xsubckt_352_no2_x1 1 2 561 563 562 no2_x1
xsubckt_833_noa2ao222_x1 1 2 1539 635 477 1548 1544 1543 noa2ao222_x1
xsubckt_520_a3_x2 1 2 393 422 401 394 a3_x2
xsubckt_489_oa2ao222_x2 1 2 424 595 718 745 735 740 oa2ao222_x2
xsubckt_305_a3_x2 1 2 608 9 46 671 a3_x2
xsubckt_648_noa2ao222_x1 1 2 266 320 318 274 495 500 noa2ao222_x1
xfeed_249 1 2 rowend_x0
xfeed_248 1 2 tie_x0
xfeed_247 1 2 tie_x0
xfeed_246 1 2 tie_x0
xfeed_245 1 2 tie_x0
xfeed_244 1 2 tie_x0
xfeed_243 1 2 tie_x0
xfeed_242 1 2 tie_x0
xfeed_241 1 2 tie_x0
xfeed_240 1 2 tie_x0
xfeed_0 1 2 tie_x0
xsubckt_403_a2_x2 1 2 510 528 511 a2_x2
xsubckt_208_a2_x2 1 2 704 46 705 a2_x2
xsubckt_260_noa22_x1 1 2 652 768 886 890 noa22_x1
xsubckt_824_a3_x2 1 2 1548 1560 1550 1549 a3_x2
xsubckt_1141_nxr2_x1 1 2 1251 879 1253 nxr2_x1
xsubckt_1180_nxr2_x1 1 2 1215 65 1227 nxr2_x1
xsubckt_1236_nao22_x1 1 2 1164 1165 391 432 nao22_x1
xfeed_9 1 2 tie_x0
xfeed_8 1 2 tie_x0
xfeed_7 1 2 tie_x0
xfeed_6 1 2 tie_x0
xfeed_5 1 2 tie_x0
xfeed_4 1 2 tie_x0
xfeed_3 1 2 tie_x0
xfeed_2 1 2 tie_x0
xfeed_1 1 2 rowend_x0
xsubckt_1577_sff1_x4 1 2 44 1699 sff1_x4
xsubckt_238_a2_x2 1 2 674 44 676 a2_x2
xsubckt_983_nao22_x1 1 2 1393 36 51 50 nao22_x1
xsubckt_1258_oa2ao222_x2 1 2 1143 1144 1146 1269 1271 1248 oa2ao222_x2
xfeed_259 1 2 tie_x0
xfeed_258 1 2 tie_x0
xfeed_257 1 2 tie_x0
xfeed_256 1 2 tie_x0
xfeed_255 1 2 tie_x0
xfeed_254 1 2 tie_x0
xfeed_253 1 2 rowend_x0
xfeed_252 1 2 tie_x0
xfeed_251 1 2 rowend_x0
xfeed_250 1 2 tie_x0
xsubckt_1646_sff1r_x4 1 2 1712 11 1630 sff1r_x4
xsubckt_1536_nao22_x1 1 2 938 910 892 1286 nao22_x1
xsubckt_1340_ao22_x2 1 2 1067 55 1284 1249 ao22_x2
xsubckt_1301_ao22_x2 1 2 1103 58 1284 1249 ao22_x2
xsubckt_450_oa2a2a23_x2 1 2 463 902 634 489 1756 467 84 oa2a2a23_x2
xsubckt_298_a2_x2 1 2 615 618 616 a2_x2
xsubckt_715_nao22_x1 1 2 201 1752 630 624 nao22_x1
xsubckt_942_a2_x2 1 2 1432 397 1542 a2_x2
xsubckt_962_a2_x2 1 2 1413 471 1414 a2_x2
xsubckt_1110_a4_x2 1 2 1281 1292 1285 1283 1282 a4_x2
xsubckt_1130_a4_x2 1 2 1262 633 1296 1289 1266 a4_x2
xsubckt_440_ao22_x2 1 2 473 474 501 550 ao22_x2
xsubckt_863_noa2ao222_x1 1 2 1509 635 477 1592 1577 1576 noa2ao222_x1
xsubckt_963_ao22_x2 1 2 1412 617 654 897 ao22_x2
xfeed_309 1 2 rowend_x0
xfeed_308 1 2 tie_x0
xfeed_307 1 2 tie_x0
xfeed_306 1 2 tie_x0
xfeed_305 1 2 tie_x0
xfeed_304 1 2 rowend_x0
xfeed_303 1 2 tie_x0
xfeed_302 1 2 tie_x0
xfeed_301 1 2 tie_x0
xfeed_300 1 2 tie_x0
xfeed_269 1 2 tie_x0
xfeed_268 1 2 tie_x0
xfeed_267 1 2 tie_x0
xfeed_266 1 2 tie_x0
xfeed_265 1 2 tie_x0
xfeed_264 1 2 tie_x0
xfeed_263 1 2 tie_x0
xfeed_262 1 2 tie_x0
xfeed_261 1 2 tie_x0
xfeed_260 1 2 tie_x0
xsubckt_538_ao2o22_x2 1 2 376 850 490 468 847 ao2o22_x2
xsubckt_747_oa2a2a23_x2 1 2 170 906 634 489 1752 467 80 oa2a2a23_x2
xsubckt_903_oa2a2a23_x2 1 2 1469 247 188 1591 396 402 1523 oa2a2a23_x2
xsubckt_1093_a3_x2 1 2 1298 791 781 1301 a3_x2
xsubckt_1405_na3_x1 1 2 1010 142 1162 1049 na3_x1
xsubckt_1347_a3_x2 1 2 1060 1070 1065 1061 a3_x2
xsubckt_517_na3_x1 1 2 396 620 615 399 na3_x1
xsubckt_873_noa2ao222_x1 1 2 1499 1572 1570 1569 1513 1512 noa2ao222_x1
xsubckt_1145_na4_x1 1 2 1247 761 751 1294 1285 na4_x1
xfeed_319 1 2 tie_x0
xfeed_318 1 2 tie_x0
xfeed_317 1 2 tie_x0
xfeed_316 1 2 tie_x0
xfeed_315 1 2 tie_x0
xfeed_314 1 2 tie_x0
xfeed_313 1 2 tie_x0
xfeed_312 1 2 tie_x0
xfeed_311 1 2 tie_x0
xfeed_310 1 2 tie_x0
xfeed_279 1 2 tie_x0
xfeed_278 1 2 rowend_x0
xfeed_277 1 2 tie_x0
xfeed_276 1 2 tie_x0
xfeed_275 1 2 rowend_x0
xfeed_274 1 2 tie_x0
xfeed_273 1 2 tie_x0
xfeed_272 1 2 tie_x0
xfeed_271 1 2 rowend_x0
xfeed_270 1 2 tie_x0
xsubckt_1409_an12_x1 1 2 1006 1010 1007 an12_x1
xsubckt_1360_na3_x1 1 2 1048 135 1162 1049 na3_x1
xsubckt_475_na3_x1 1 2 438 457 455 440 na3_x1
xsubckt_735_na2_x1 1 2 181 206 184 na2_x1
xsubckt_1017_na3_x1 1 2 1362 77 566 1365 na3_x1
xsubckt_1018_na3_x1 1 2 1361 9 46 681 na3_x1
xsubckt_1086_nao22_x1 1 2 1694 1303 1333 1341 nao22_x1
xsubckt_1485_a2_x2 1 2 954 1111 955 a2_x2
xsubckt_1395_an12_x1 1 2 1018 1022 1019 an12_x1
xsubckt_1364_na3_x1 1 2 1045 134 1162 1049 na3_x1
xsubckt_348_na2_x1 1 2 565 569 568 na2_x1
xsubckt_346_na2_x1 1 2 567 9 678 na2_x1
xsubckt_655_nao22_x1 1 2 259 267 261 260 nao22_x1
xsubckt_691_na2_x1 1 2 224 227 225 na2_x1
xsubckt_800_oa2ao222_x2 1 2 1572 635 475 1592 1574 461 oa2ao222_x2
xfeed_329 1 2 tie_x0
xfeed_328 1 2 tie_x0
xfeed_327 1 2 tie_x0
xfeed_326 1 2 rowend_x0
xfeed_325 1 2 tie_x0
xfeed_324 1 2 rowend_x0
xfeed_323 1 2 tie_x0
xfeed_322 1 2 tie_x0
xfeed_321 1 2 tie_x0
xfeed_320 1 2 tie_x0
xfeed_289 1 2 tie_x0
xfeed_288 1 2 tie_x0
xfeed_287 1 2 tie_x0
xfeed_286 1 2 tie_x0
xfeed_285 1 2 tie_x0
xfeed_284 1 2 tie_x0
xfeed_283 1 2 tie_x0
xfeed_282 1 2 tie_x0
xfeed_281 1 2 tie_x0
xfeed_280 1 2 rowend_x0
xsubckt_696_na2_x1 1 2 219 224 221 na2_x1
xsubckt_698_na2_x1 1 2 217 228 220 na2_x1
xsubckt_775_ao22_x2 1 2 1596 1597 584 861 ao22_x2
xsubckt_900_oa2ao222_x2 1 2 1472 428 1592 1575 658 790 oa2ao222_x2
xsubckt_1654_sff1_x4 1 2 1728 1622 sff1_x4
xsubckt_1544_ao22_x2 1 2 931 41 1287 1742 ao22_x2
xsubckt_350_a4_x2 1 2 563 45 773 772 710 a4_x2
xsubckt_203_a3_x2 1 2 709 48 1745 1744 a3_x2
xsubckt_252_ao22_x2 1 2 660 43 803 796 ao22_x2
xsubckt_955_nao22_x1 1 2 1419 779 1435 1422 nao22_x1
xfeed_339 1 2 rowend_x0
xfeed_338 1 2 tie_x0
xfeed_337 1 2 tie_x0
xfeed_336 1 2 tie_x0
xfeed_335 1 2 tie_x0
xfeed_334 1 2 tie_x0
xfeed_333 1 2 tie_x0
xfeed_332 1 2 tie_x0
xfeed_331 1 2 tie_x0
xfeed_330 1 2 tie_x0
xfeed_299 1 2 tie_x0
xfeed_298 1 2 rowend_x0
xfeed_297 1 2 tie_x0
xfeed_296 1 2 tie_x0
xfeed_295 1 2 rowend_x0
xfeed_294 1 2 tie_x0
xfeed_293 1 2 tie_x0
xfeed_292 1 2 tie_x0
xfeed_291 1 2 tie_x0
xfeed_290 1 2 rowend_x0
xspare_buffer_18 1 2 buf_x8
xspare_buffer_17 1 2 buf_x8
xspare_buffer_16 1 2 buf_x8
xspare_buffer_14 1 2 buf_x8
xspare_buffer_13 1 2 buf_x8
xspare_buffer_12 1 2 buf_x8
xspare_buffer_10 1 2 buf_x8
xsubckt_1615_sff1_x4 1 2 1743 1661 sff1_x4
xsubckt_469_a4_x2 1 2 444 565 537 452 446 a4_x2
xsubckt_233_a3_x2 1 2 679 773 772 710 a3_x2
xsubckt_248_ao22_x2 1 2 664 815 667 901 ao22_x2
xsubckt_295_nao22_x1 1 2 618 9 689 655 nao22_x1
xsubckt_802_nxr2_x1 1 2 1570 1579 1573 nxr2_x1
xsubckt_1328_nao22_x1 1 2 1078 56 1284 1249 nao22_x1
xsubckt_605_ao22_x2 1 2 309 310 584 872 ao22_x2
xsubckt_527_a3_x2 1 2 386 1742 46 763 a3_x2
xsubckt_507_nao22_x1 1 2 406 411 521 849 nao22_x1
xsubckt_136_a2_x2 1 2 775 778 776 a2_x2
xsubckt_106_a2_x2 1 2 805 809 807 a2_x2
xfeed_349 1 2 tie_x0
xfeed_348 1 2 tie_x0
xfeed_347 1 2 tie_x0
xfeed_346 1 2 tie_x0
xfeed_345 1 2 tie_x0
xfeed_344 1 2 tie_x0
xfeed_343 1 2 tie_x0
xfeed_342 1 2 tie_x0
xfeed_341 1 2 tie_x0
xfeed_340 1 2 tie_x0
xsubckt_1597_sff1_x4 1 2 140 1679 sff1_x4
xsubckt_391_a2_x2 1 2 522 537 523 a2_x2
xsubckt_361_a2_x2 1 2 552 613 553 a2_x2
xsubckt_156_a2_x2 1 2 755 761 756 a2_x2
xsubckt_186_a2_x2 1 2 726 799 787 a2_x2
xsubckt_710_nxr2_x1 1 2 206 211 208 nxr2_x1
xsubckt_807_nao22_x1 1 2 1565 1570 160 167 nao22_x1
xsubckt_810_a2_x2 1 2 1562 1567 1563 a2_x2
xsubckt_1148_nao22_x1 1 2 1244 1268 1251 1246 nao22_x1
xsubckt_1648_sff1r_x4 1 2 1710 11 1628 sff1r_x4
xsubckt_695_a2_x2 1 2 220 224 221 a2_x2
xsubckt_717_nao22_x1 1 2 199 906 605 599 nao22_x1
xsubckt_850_a2_x2 1 2 1522 474 1523 a2_x2
xfeed_359 1 2 tie_x0
xfeed_358 1 2 tie_x0
xfeed_357 1 2 rowend_x0
xfeed_356 1 2 tie_x0
xfeed_355 1 2 tie_x0
xfeed_354 1 2 rowend_x0
xfeed_353 1 2 tie_x0
xfeed_352 1 2 rowend_x0
xfeed_351 1 2 tie_x0
xfeed_350 1 2 tie_x0
xsubckt_1448_nao22_x1 1 2 986 998 219 229 nao22_x1
xsubckt_633_noa2ao222_x1 1 2 281 371 369 368 286 285 noa2ao222_x1
xsubckt_627_nao22_x1 1 2 287 290 298 634 nao22_x1
xsubckt_841_na4_x1 1 2 1531 9 45 137 681 na4_x1
xsubckt_989_a2_x2 1 2 1387 1391 1389 a2_x2
xsubckt_1076_an12_x1 1 2 1310 12 16 an12_x1
xsubckt_1440_a3_x2 1 2 992 995 994 993 a3_x2
xsubckt_1420_a3_x2 1 2 1004 659 609 1005 a3_x2
xsubckt_452_na4_x1 1 2 461 635 500 492 487 na4_x1
xsubckt_421_ao22_x2 1 2 492 548 622 894 ao22_x2
xsubckt_107_na4_x1 1 2 804 891 814 809 807 na4_x1
xsubckt_102_an12_x1 1 2 809 1745 1746 an12_x1
xsubckt_711_na3_x1 1 2 205 346 328 326 na3_x1
xsubckt_760_o3_x2 1 2 157 233 165 161 o3_x2
xsubckt_1268_nao22_x1 1 2 1134 1165 219 229 nao22_x1
.ends m65_cts_r
